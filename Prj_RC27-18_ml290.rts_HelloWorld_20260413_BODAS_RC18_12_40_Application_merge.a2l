	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017E50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017E51
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017E54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017E58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017E59
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017E5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017E60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017E61
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017E64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017E68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017E69
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017E6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017E70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017E71
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017E74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017E78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017E79
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017E7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017E80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017E81
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017E84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017E88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017E89
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017E8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017E90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017E91
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017E94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017E98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017E99
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017E9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017EA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017EA1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017EA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017EA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017EA9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017EAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017EB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017EB1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017EB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017EB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017EB9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017EBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017EC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017EC1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017EC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017EC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017EC9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017ECC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017ED0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017ED1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017ED4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017ED8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017ED9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017EDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017EE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017EE1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as
	ECU_ADDRESS 0x70017E44
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017EE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017EEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017EED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017EF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017EF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017EF5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017EF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017EFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017EFD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017F00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017F04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017F05
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017F08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017F0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017F0D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017F10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017F14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017F15
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017F18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017F1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017F1D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017F20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017F24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017F25
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017F28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017F2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017F2D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017F30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017F34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017F35
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017F38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017F3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017F3D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017F40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017F44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017F45
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017F48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017F4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017F4D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017F50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017F54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017F55
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017F58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017F5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017F5D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017F60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017F64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017F65
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017F68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017F6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017F6D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017F70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017F74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017F75
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017F78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017F7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017F7D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017F80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017F84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017F85
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[75].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[75].dtc_as
	ECU_ADDRESS 0x70017EE8
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[75].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017F8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017F90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017F91
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017F94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017F98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017F99
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017F9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017FA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017FA1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017FA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017FA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017FA9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017FAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017FB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017FB1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017FB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017FB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017FB9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017FBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017FC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017FC1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017FC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017FC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017FC9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017FCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017FD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017FD1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017FD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017FD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017FD9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017FDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017FE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017FE1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017FE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017FE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017FE9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017FEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017FF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017FF1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017FF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017FF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017FF9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017FFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70018000
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70018001
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70018004
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70018008
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70018009
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[17].spn_u32
	ECU_ADDRESS 0x7001800C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70018010
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70018011
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70018014
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70018018
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70018019
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[19].spn_u32
	ECU_ADDRESS 0x7001801C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70018020
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70018021
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70018024
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70018028
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70018029
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[76].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[76].dtc_as
	ECU_ADDRESS 0x70017F8C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[76].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70018030
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70018034
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70018035
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70018038
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x7001803C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[2].occ_u8
	ECU_ADDRESS 0x7001803D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70018040
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70018044
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70018045
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70018048
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x7001804C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[4].occ_u8
	ECU_ADDRESS 0x7001804D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70018050
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70018054
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70018055
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70018058
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x7001805C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[6].occ_u8
	ECU_ADDRESS 0x7001805D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70018060
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70018064
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70018065
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70018068
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x7001806C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[8].occ_u8
	ECU_ADDRESS 0x7001806D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70018070
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70018074
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70018075
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70018078
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x7001807C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[10].occ_u8
	ECU_ADDRESS 0x7001807D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70018080
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70018084
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70018085
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70018088
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x7001808C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[12].occ_u8
	ECU_ADDRESS 0x7001808D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70018090
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70018094
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70018095
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70018098
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x7001809C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[14].occ_u8
	ECU_ADDRESS 0x7001809D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700180A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700180A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700180A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700180A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700180AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700180AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700180B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700180B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700180B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700180B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700180BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700180BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700180C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700180C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700180C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700180C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700180CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700180CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[77].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[77].dtc_as
	ECU_ADDRESS 0x70018030
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[77].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700180D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700180D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700180D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700180DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700180E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700180E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700180E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700180E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700180E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700180EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700180F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700180F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700180F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700180F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700180F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700180FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70018100
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70018101
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70018104
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70018108
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70018109
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[8].spn_u32
	ECU_ADDRESS 0x7001810C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70018110
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70018111
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70018114
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70018118
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70018119
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[10].spn_u32
	ECU_ADDRESS 0x7001811C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70018120
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70018121
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70018124
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70018128
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70018129
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[12].spn_u32
	ECU_ADDRESS 0x7001812C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70018130
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70018131
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70018134
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70018138
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70018139
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[14].spn_u32
	ECU_ADDRESS 0x7001813C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70018140
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70018141
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70018144
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70018148
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70018149
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[16].spn_u32
	ECU_ADDRESS 0x7001814C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70018150
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70018151
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70018154
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70018158
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70018159
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[18].spn_u32
	ECU_ADDRESS 0x7001815C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70018160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70018161
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70018164
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70018168
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70018169
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[20].spn_u32
	ECU_ADDRESS 0x7001816C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70018170
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70018171
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[78].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[78].dtc_as
	ECU_ADDRESS 0x700180D4
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[78].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70018178
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x7001817C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[1].occ_u8
	ECU_ADDRESS 0x7001817D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70018180
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70018184
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70018185
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70018188
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x7001818C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[3].occ_u8
	ECU_ADDRESS 0x7001818D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70018190
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70018194
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70018195
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70018198
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x7001819C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[5].occ_u8
	ECU_ADDRESS 0x7001819D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700181A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700181A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700181A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700181A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700181AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700181AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700181B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700181B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700181B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700181B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700181BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700181BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700181C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700181C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700181C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700181C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700181CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700181CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700181D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700181D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700181D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700181D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700181DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700181DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700181E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700181E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700181E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700181E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700181EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700181ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700181F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700181F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700181F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700181F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700181FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700181FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70018200
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70018204
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70018205
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70018208
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x7001820C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[19].occ_u8
	ECU_ADDRESS 0x7001820D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70018210
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70018214
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70018215
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[79].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[79].dtc_as
	ECU_ADDRESS 0x70018178
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[79].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[1].spn_u32
	ECU_ADDRESS 0x7001821C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70018220
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70018221
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70018224
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70018228
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70018229
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[3].spn_u32
	ECU_ADDRESS 0x7001822C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70018230
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70018231
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70018234
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70018238
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70018239
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[5].spn_u32
	ECU_ADDRESS 0x7001823C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70018240
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70018241
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70018244
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70018248
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70018249
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[7].spn_u32
	ECU_ADDRESS 0x7001824C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70018250
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70018251
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70018254
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70018258
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70018259
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[9].spn_u32
	ECU_ADDRESS 0x7001825C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70018260
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70018261
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70018264
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70018268
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70018269
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[11].spn_u32
	ECU_ADDRESS 0x7001826C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70018270
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70018271
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70018274
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70018278
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70018279
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[13].spn_u32
	ECU_ADDRESS 0x7001827C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70018280
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70018281
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70018284
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70018288
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70018289
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[15].spn_u32
	ECU_ADDRESS 0x7001828C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70018290
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70018291
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70018294
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70018298
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70018299
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[17].spn_u32
	ECU_ADDRESS 0x7001829C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700182A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700182A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700182A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700182A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700182A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700182AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700182B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700182B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700182B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700182B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700182B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[80].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[80].dtc_as
	ECU_ADDRESS 0x7001821C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[80].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700182C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700182C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700182C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700182C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700182CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700182CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700182D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700182D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700182D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700182D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700182DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700182DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700182E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700182E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700182E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700182E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700182EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700182ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700182F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700182F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700182F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700182F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700182FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700182FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70018300
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70018304
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70018305
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70018308
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x7001830C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[10].occ_u8
	ECU_ADDRESS 0x7001830D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70018310
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70018314
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70018315
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70018318
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x7001831C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[12].occ_u8
	ECU_ADDRESS 0x7001831D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70018320
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70018324
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70018325
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70018328
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x7001832C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[14].occ_u8
	ECU_ADDRESS 0x7001832D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70018330
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70018334
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70018335
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70018338
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x7001833C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[16].occ_u8
	ECU_ADDRESS 0x7001833D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70018340
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70018344
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70018345
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70018348
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x7001834C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[18].occ_u8
	ECU_ADDRESS 0x7001834D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70018350
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70018354
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70018355
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70018358
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x7001835C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as[20].occ_u8
	ECU_ADDRESS 0x7001835D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[81].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[81].dtc_as
	ECU_ADDRESS 0x700182C0
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[81].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70018364
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70018368
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70018369
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[2].spn_u32
	ECU_ADDRESS 0x7001836C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70018370
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70018371
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70018374
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70018378
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70018379
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[4].spn_u32
	ECU_ADDRESS 0x7001837C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70018380
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70018381
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70018384
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70018388
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70018389
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[6].spn_u32
	ECU_ADDRESS 0x7001838C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70018390
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70018391
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70018394
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70018398
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70018399
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[8].spn_u32
	ECU_ADDRESS 0x7001839C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700183A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700183A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700183A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700183A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700183A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700183AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700183B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700183B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700183B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700183B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700183B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700183BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700183C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700183C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700183C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700183C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700183C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700183CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700183D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700183D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700183D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700183D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700183D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700183DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700183E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700183E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700183E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700183E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700183E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700183EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700183F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700183F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700183F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700183F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700183F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700183FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70018400
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70018401
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[82].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[82].dtc_as
	ECU_ADDRESS 0x70018364
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[82].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70018408
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x7001840C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[1].occ_u8
	ECU_ADDRESS 0x7001840D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70018410
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70018414
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70018415
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70018418
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x7001841C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[3].occ_u8
	ECU_ADDRESS 0x7001841D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70018420
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70018424
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70018425
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70018428
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x7001842C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[5].occ_u8
	ECU_ADDRESS 0x7001842D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70018430
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70018434
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70018435
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70018438
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x7001843C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[7].occ_u8
	ECU_ADDRESS 0x7001843D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70018440
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70018444
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70018445
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70018448
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x7001844C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[9].occ_u8
	ECU_ADDRESS 0x7001844D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70018450
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70018454
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70018455
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70018458
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x7001845C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[11].occ_u8
	ECU_ADDRESS 0x7001845D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70018460
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70018464
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70018465
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70018468
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x7001846C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[13].occ_u8
	ECU_ADDRESS 0x7001846D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70018470
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70018474
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70018475
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70018478
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x7001847C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[15].occ_u8
	ECU_ADDRESS 0x7001847D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70018480
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70018484
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70018485
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70018488
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x7001848C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[17].occ_u8
	ECU_ADDRESS 0x7001848D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70018490
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70018494
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70018495
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70018498
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x7001849C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[19].occ_u8
	ECU_ADDRESS 0x7001849D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700184A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700184A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700184A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[83].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[83].dtc_as
	ECU_ADDRESS 0x70018408
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[83].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700184AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700184B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700184B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700184B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700184B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700184B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700184BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700184C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700184C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700184C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700184C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700184C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700184CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700184D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700184D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700184D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700184D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700184D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700184DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700184E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700184E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700184E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700184E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700184E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700184EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700184F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700184F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700184F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700184F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700184F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700184FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70018500
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70018501
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70018504
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70018508
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70018509
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[13].spn_u32
	ECU_ADDRESS 0x7001850C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70018510
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70018511
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70018514
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70018518
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70018519
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[15].spn_u32
	ECU_ADDRESS 0x7001851C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70018520
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70018521
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70018524
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70018528
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70018529
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[17].spn_u32
	ECU_ADDRESS 0x7001852C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70018530
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70018531
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70018534
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70018538
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70018539
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[19].spn_u32
	ECU_ADDRESS 0x7001853C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70018540
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70018541
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70018544
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70018548
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70018549
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[84].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[84].dtc_as
	ECU_ADDRESS 0x700184AC
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[84].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70018550
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70018554
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70018555
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70018558
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x7001855C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[2].occ_u8
	ECU_ADDRESS 0x7001855D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70018560
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70018564
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70018565
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70018568
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x7001856C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[4].occ_u8
	ECU_ADDRESS 0x7001856D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70018570
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70018574
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70018575
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70018578
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x7001857C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[6].occ_u8
	ECU_ADDRESS 0x7001857D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70018580
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70018584
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70018585
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70018588
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x7001858C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[8].occ_u8
	ECU_ADDRESS 0x7001858D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70018590
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70018594
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70018595
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70018598
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x7001859C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[10].occ_u8
	ECU_ADDRESS 0x7001859D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700185A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700185A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700185A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700185A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700185AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700185AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700185B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700185B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700185B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700185B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700185BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700185BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700185C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700185C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700185C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700185C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700185CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700185CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700185D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700185D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700185D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700185D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700185DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700185DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700185E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700185E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700185E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700185E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700185EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700185ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[85].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[85].dtc_as
	ECU_ADDRESS 0x70018550
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[85].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700185F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700185F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700185F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700185FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70018600
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70018601
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70018604
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70018608
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70018609
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[4].spn_u32
	ECU_ADDRESS 0x7001860C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70018610
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70018611
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70018614
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70018618
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70018619
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[6].spn_u32
	ECU_ADDRESS 0x7001861C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70018620
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70018621
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70018624
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70018628
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70018629
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[8].spn_u32
	ECU_ADDRESS 0x7001862C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70018630
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70018631
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70018634
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70018638
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70018639
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[10].spn_u32
	ECU_ADDRESS 0x7001863C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70018640
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70018641
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70018644
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70018648
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70018649
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[12].spn_u32
	ECU_ADDRESS 0x7001864C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70018650
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70018651
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70018654
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70018658
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70018659
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[14].spn_u32
	ECU_ADDRESS 0x7001865C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70018660
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70018661
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70018664
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70018668
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70018669
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[16].spn_u32
	ECU_ADDRESS 0x7001866C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70018670
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70018671
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70018674
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70018678
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70018679
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[18].spn_u32
	ECU_ADDRESS 0x7001867C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70018680
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70018681
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70018684
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70018688
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70018689
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[20].spn_u32
	ECU_ADDRESS 0x7001868C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70018690
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70018691
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[86].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[86].dtc_as
	ECU_ADDRESS 0x700185F4
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[86].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER status_u16
	ECU_ADDRESS 0x700135FE
	SYMBOL_LINK "status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT i_stPmpSnsrSigInvldErr_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER i_stPmpSnsrSigInvldErr_e
	ECU_ADDRESS 0x70013704
	SYMBOL_LINK "i_stPmpSnsrSigInvldErr_e" 0
/end MEASUREMENT


/begin MEASUREMENT i_stBrkSwtSigInvldErr_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER i_stBrkSwtSigInvldErr_e
	ECU_ADDRESS 0x70013705
	SYMBOL_LINK "i_stBrkSwtSigInvldErr_e" 0
/end MEASUREMENT


/begin MEASUREMENT i_uPmpSnsr_mV_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER i_uPmpSnsr_mV_u16
	ECU_ADDRESS 0x70013706
	SYMBOL_LINK "i_uPmpSnsr_mV_u16" 0
/end MEASUREMENT


/begin MEASUREMENT i_frqVehSnsr_Hz_u32 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER i_frqVehSnsr_Hz_u32
	ECU_ADDRESS 0x70013708
	SYMBOL_LINK "i_frqVehSnsr_Hz_u32" 0
/end MEASUREMENT


/begin MEASUREMENT i_iPmpFwdAct_mA_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER i_iPmpFwdAct_mA_u16
	ECU_ADDRESS 0x7001370A
	SYMBOL_LINK "i_iPmpFwdAct_mA_u16" 0
/end MEASUREMENT


/begin MEASUREMENT i_vWhlSpd_kmh_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER i_vWhlSpd_kmh_u16
	ECU_ADDRESS 0x7001370C
	SYMBOL_LINK "i_vWhlSpd_kmh_u16" 0
/end MEASUREMENT


/begin MEASUREMENT chkResult_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER chkResult_e
	ECU_ADDRESS 0x7001370E
	SYMBOL_LINK "chkResult_e" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiUpDwn0x8A03_ts.DTC ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER DFC_bds_TiUpDwn0x8A03_ts.DTC
	ECU_ADDRESS 0x70013710
	SYMBOL_LINK "DFC_bds_TiUpDwn0x8A03_ts.DTC" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiUpDwn0x8A03_ts.DFCid ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER DFC_bds_TiUpDwn0x8A03_ts.DFCid
	ECU_ADDRESS 0x70013714
	SYMBOL_LINK "DFC_bds_TiUpDwn0x8A03_ts.DFCid" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiUpDwn0x8A03_ts.debounceMethod ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER DFC_bds_TiUpDwn0x8A03_ts.debounceMethod
	ECU_ADDRESS 0x70013716
	SYMBOL_LINK "DFC_bds_TiUpDwn0x8A03_ts.debounceMethod" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiUpDwn0x8A02_ts.DTC ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER DFC_bds_TiUpDwn0x8A02_ts.DTC
	ECU_ADDRESS 0x70013718
	SYMBOL_LINK "DFC_bds_TiUpDwn0x8A02_ts.DTC" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiUpDwn0x8A02_ts.DFCid ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER DFC_bds_TiUpDwn0x8A02_ts.DFCid
	ECU_ADDRESS 0x7001371C
	SYMBOL_LINK "DFC_bds_TiUpDwn0x8A02_ts.DFCid" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiUpDwn0x8A02_ts.debounceMethod ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER DFC_bds_TiUpDwn0x8A02_ts.debounceMethod
	ECU_ADDRESS 0x7001371E
	SYMBOL_LINK "DFC_bds_TiUpDwn0x8A02_ts.debounceMethod" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiInRow0x8B02_ts.DTC ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER DFC_bds_TiInRow0x8B02_ts.DTC
	ECU_ADDRESS 0x70013720
	SYMBOL_LINK "DFC_bds_TiInRow0x8B02_ts.DTC" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiInRow0x8B02_ts.DFCid ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER DFC_bds_TiInRow0x8B02_ts.DFCid
	ECU_ADDRESS 0x70013724
	SYMBOL_LINK "DFC_bds_TiInRow0x8B02_ts.DFCid" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiInRow0x8B02_ts.debounceMethod ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER DFC_bds_TiInRow0x8B02_ts.debounceMethod
	ECU_ADDRESS 0x70013726
	SYMBOL_LINK "DFC_bds_TiInRow0x8B02_ts.debounceMethod" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiUpDwn0x8A01_ts.DTC ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER DFC_bds_TiUpDwn0x8A01_ts.DTC
	ECU_ADDRESS 0x70013728
	SYMBOL_LINK "DFC_bds_TiUpDwn0x8A01_ts.DTC" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiUpDwn0x8A01_ts.DFCid ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER DFC_bds_TiUpDwn0x8A01_ts.DFCid
	ECU_ADDRESS 0x7001372C
	SYMBOL_LINK "DFC_bds_TiUpDwn0x8A01_ts.DFCid" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiUpDwn0x8A01_ts.debounceMethod ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER DFC_bds_TiUpDwn0x8A01_ts.debounceMethod
	ECU_ADDRESS 0x7001372E
	SYMBOL_LINK "DFC_bds_TiUpDwn0x8A01_ts.debounceMethod" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiInRow0x8B01_ts.DTC ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER DFC_bds_TiInRow0x8B01_ts.DTC
	ECU_ADDRESS 0x70013730
	SYMBOL_LINK "DFC_bds_TiInRow0x8B01_ts.DTC" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiInRow0x8B01_ts.DFCid ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER DFC_bds_TiInRow0x8B01_ts.DFCid
	ECU_ADDRESS 0x70013734
	SYMBOL_LINK "DFC_bds_TiInRow0x8B01_ts.DFCid" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiInRow0x8B01_ts.debounceMethod ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER DFC_bds_TiInRow0x8B01_ts.debounceMethod
	ECU_ADDRESS 0x70013736
	SYMBOL_LINK "DFC_bds_TiInRow0x8B01_ts.debounceMethod" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiInRow0x8B03_ts.DTC ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER DFC_bds_TiInRow0x8B03_ts.DTC
	ECU_ADDRESS 0x70013738
	SYMBOL_LINK "DFC_bds_TiInRow0x8B03_ts.DTC" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiInRow0x8B03_ts.DFCid ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER DFC_bds_TiInRow0x8B03_ts.DFCid
	ECU_ADDRESS 0x7001373C
	SYMBOL_LINK "DFC_bds_TiInRow0x8B03_ts.DFCid" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_TiInRow0x8B03_ts.debounceMethod ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER DFC_bds_TiInRow0x8B03_ts.debounceMethod
	ECU_ADDRESS 0x7001373E
	SYMBOL_LINK "DFC_bds_TiInRow0x8B03_ts.debounceMethod" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_NoDeb0x8C01_ts.DTC ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER DFC_bds_NoDeb0x8C01_ts.DTC
	ECU_ADDRESS 0x70013740
	SYMBOL_LINK "DFC_bds_NoDeb0x8C01_ts.DTC" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_NoDeb0x8C01_ts.DFCid ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER DFC_bds_NoDeb0x8C01_ts.DFCid
	ECU_ADDRESS 0x70013744
	SYMBOL_LINK "DFC_bds_NoDeb0x8C01_ts.DFCid" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_NoDeb0x8C01_ts.debounceMethod ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER DFC_bds_NoDeb0x8C01_ts.debounceMethod
	ECU_ADDRESS 0x70013746
	SYMBOL_LINK "DFC_bds_NoDeb0x8C01_ts.debounceMethod" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_NoDeb0x8C03_ts.DTC ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER DFC_bds_NoDeb0x8C03_ts.DTC
	ECU_ADDRESS 0x70013748
	SYMBOL_LINK "DFC_bds_NoDeb0x8C03_ts.DTC" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_NoDeb0x8C03_ts.DFCid ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER DFC_bds_NoDeb0x8C03_ts.DFCid
	ECU_ADDRESS 0x7001374C
	SYMBOL_LINK "DFC_bds_NoDeb0x8C03_ts.DFCid" 0
/end MEASUREMENT


/begin MEASUREMENT DFC_bds_NoDeb0x8C03_ts.debounceMethod ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER DFC_bds_NoDeb0x8C03_ts.debounceMethod
	ECU_ADDRESS 0x7001374E
	SYMBOL_LINK "DFC_bds_NoDeb0x8C03_ts.debounceMethod" 0
/end MEASUREMENT


/begin MEASUREMENT NvmWriteRet_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER NvmWriteRet_u16
	ECU_ADDRESS 0x70013B0A
	SYMBOL_LINK "NvmWriteRet_u16" 0
/end MEASUREMENT


/begin MEASUREMENT DiagChkLvlRet_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER DiagChkLvlRet_u8
	ECU_ADDRESS 0x70013AF5
	SYMBOL_LINK "DiagChkLvlRet_u8" 0
/end MEASUREMENT


/begin MEASUREMENT Level_pu8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER Level_pu8
	ECU_ADDRESS 0x70018694
	SYMBOL_LINK "Level_pu8" 0
/end MEASUREMENT


/begin MEASUREMENT ErrMemMgr_s.dtc_error_au32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER ErrMemMgr_s.dtc_error_au32
	ECU_ADDRESS 0x70013850
	ARRAY_SIZE 128
	SYMBOL_LINK "ErrMemMgr_s.dtc_error_au32" 0
/end MEASUREMENT


/begin MEASUREMENT ErrMemMgr_s.stDfes_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ErrMemMgr_s.stDfes_au8
	ECU_ADDRESS 0x700138D0
	ARRAY_SIZE 32
	SYMBOL_LINK "ErrMemMgr_s.stDfes_au8" 0
/end MEASUREMENT


/begin MEASUREMENT ErrMemMgr_s.status_au16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER ErrMemMgr_s.status_au16
	ECU_ADDRESS 0x700138F4
	ARRAY_SIZE 64
	SYMBOL_LINK "ErrMemMgr_s.status_au16" 0
/end MEASUREMENT


/begin MEASUREMENT ErrMemMgr_s.nrDfesEntr_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ErrMemMgr_s.nrDfesEntr_u8
	ECU_ADDRESS 0x70013934
	SYMBOL_LINK "ErrMemMgr_s.nrDfesEntr_u8" 0
/end MEASUREMENT


/begin MEASUREMENT ErrMemMgr_s.clrCntr_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ErrMemMgr_s.clrCntr_au8
	ECU_ADDRESS 0x70013935
	ARRAY_SIZE 32
	SYMBOL_LINK "ErrMemMgr_s.clrCntr_au8" 0
/end MEASUREMENT


/begin MEASUREMENT ErrMemMgr_s.tiOldStamp_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER ErrMemMgr_s.tiOldStamp_u32
	ECU_ADDRESS 0x70013958
	SYMBOL_LINK "ErrMemMgr_s.tiOldStamp_u32" 0
/end MEASUREMENT


/begin MEASUREMENT ErrMemMgr_s.stDtcAvl_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ErrMemMgr_s.stDtcAvl_au8
	ECU_ADDRESS 0x7001395C
	ARRAY_SIZE 32
	SYMBOL_LINK "ErrMemMgr_s.stDtcAvl_au8" 0
/end MEASUREMENT


/begin MEASUREMENT DFES_numEntryAvl ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER DFES_numEntryAvl
	ECU_ADDRESS 0x7001397C
	SYMBOL_LINK "DFES_numEntryAvl" 0
/end MEASUREMENT


/begin MEASUREMENT errList_s.nrErr_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER errList_s.nrErr_u8
	ECU_ADDRESS 0x70013980
	SYMBOL_LINK "errList_s.nrErr_u8" 0
/end MEASUREMENT


/begin MEASUREMENT errList_s.dtcList_au32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER errList_s.dtcList_au32
	ECU_ADDRESS 0x70013984
	ARRAY_SIZE 128
	SYMBOL_LINK "errList_s.dtcList_au32" 0
/end MEASUREMENT


/begin MEASUREMENT errList_s.apiSt_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER errList_s.apiSt_e
	ECU_ADDRESS 0x70013A04
	SYMBOL_LINK "errList_s.apiSt_e" 0
/end MEASUREMENT


/begin MEASUREMENT dsmDTC_getStatus_s.errState_e ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dsmDTC_getStatus_s.errState_e
	ECU_ADDRESS 0x70013A08
	SYMBOL_LINK "dsmDTC_getStatus_s.errState_e" 0
/end MEASUREMENT


/begin MEASUREMENT dsmDTC_getStatus_s.apiSt_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dsmDTC_getStatus_s.apiSt_e
	ECU_ADDRESS 0x70013A0E
	SYMBOL_LINK "dsmDTC_getStatus_s.apiSt_e" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[0].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[0].id
	ECU_ADDRESS 0x70013A10
	SYMBOL_LINK "dfc_as[0].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[0].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[0].debmode
	ECU_ADDRESS 0x70013A12
	SYMBOL_LINK "dfc_as[0].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[1].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[1].id
	ECU_ADDRESS 0x70013A14
	SYMBOL_LINK "dfc_as[1].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[1].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[1].debmode
	ECU_ADDRESS 0x70013A16
	SYMBOL_LINK "dfc_as[1].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[2].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[2].id
	ECU_ADDRESS 0x70013A18
	SYMBOL_LINK "dfc_as[2].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[2].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[2].debmode
	ECU_ADDRESS 0x70013A1A
	SYMBOL_LINK "dfc_as[2].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[3].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[3].id
	ECU_ADDRESS 0x70013A1C
	SYMBOL_LINK "dfc_as[3].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[3].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[3].debmode
	ECU_ADDRESS 0x70013A1E
	SYMBOL_LINK "dfc_as[3].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[4].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[4].id
	ECU_ADDRESS 0x70013A20
	SYMBOL_LINK "dfc_as[4].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[4].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[4].debmode
	ECU_ADDRESS 0x70013A22
	SYMBOL_LINK "dfc_as[4].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[5].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[5].id
	ECU_ADDRESS 0x70013A24
	SYMBOL_LINK "dfc_as[5].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[5].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[5].debmode
	ECU_ADDRESS 0x70013A26
	SYMBOL_LINK "dfc_as[5].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[6].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[6].id
	ECU_ADDRESS 0x70013A28
	SYMBOL_LINK "dfc_as[6].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[6].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[6].debmode
	ECU_ADDRESS 0x70013A2A
	SYMBOL_LINK "dfc_as[6].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[7].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[7].id
	ECU_ADDRESS 0x70013A2C
	SYMBOL_LINK "dfc_as[7].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[7].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[7].debmode
	ECU_ADDRESS 0x70013A2E
	SYMBOL_LINK "dfc_as[7].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[8].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[8].id
	ECU_ADDRESS 0x70013A30
	SYMBOL_LINK "dfc_as[8].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[8].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[8].debmode
	ECU_ADDRESS 0x70013A32
	SYMBOL_LINK "dfc_as[8].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[9].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[9].id
	ECU_ADDRESS 0x70013A34
	SYMBOL_LINK "dfc_as[9].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[9].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[9].debmode
	ECU_ADDRESS 0x70013A36
	SYMBOL_LINK "dfc_as[9].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[10].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[10].id
	ECU_ADDRESS 0x70013A38
	SYMBOL_LINK "dfc_as[10].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[10].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[10].debmode
	ECU_ADDRESS 0x70013A3A
	SYMBOL_LINK "dfc_as[10].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[11].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[11].id
	ECU_ADDRESS 0x70013A3C
	SYMBOL_LINK "dfc_as[11].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[11].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[11].debmode
	ECU_ADDRESS 0x70013A3E
	SYMBOL_LINK "dfc_as[11].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[12].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[12].id
	ECU_ADDRESS 0x70013A40
	SYMBOL_LINK "dfc_as[12].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[12].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[12].debmode
	ECU_ADDRESS 0x70013A42
	SYMBOL_LINK "dfc_as[12].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[13].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[13].id
	ECU_ADDRESS 0x70013A44
	SYMBOL_LINK "dfc_as[13].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[13].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[13].debmode
	ECU_ADDRESS 0x70013A46
	SYMBOL_LINK "dfc_as[13].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[14].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[14].id
	ECU_ADDRESS 0x70013A48
	SYMBOL_LINK "dfc_as[14].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[14].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[14].debmode
	ECU_ADDRESS 0x70013A4A
	SYMBOL_LINK "dfc_as[14].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[15].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[15].id
	ECU_ADDRESS 0x70013A4C
	SYMBOL_LINK "dfc_as[15].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[15].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[15].debmode
	ECU_ADDRESS 0x70013A4E
	SYMBOL_LINK "dfc_as[15].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[16].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[16].id
	ECU_ADDRESS 0x70013A50
	SYMBOL_LINK "dfc_as[16].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[16].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[16].debmode
	ECU_ADDRESS 0x70013A52
	SYMBOL_LINK "dfc_as[16].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[17].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[17].id
	ECU_ADDRESS 0x70013A54
	SYMBOL_LINK "dfc_as[17].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[17].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[17].debmode
	ECU_ADDRESS 0x70013A56
	SYMBOL_LINK "dfc_as[17].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[18].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[18].id
	ECU_ADDRESS 0x70013A58
	SYMBOL_LINK "dfc_as[18].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[18].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[18].debmode
	ECU_ADDRESS 0x70013A5A
	SYMBOL_LINK "dfc_as[18].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[19].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[19].id
	ECU_ADDRESS 0x70013A5C
	SYMBOL_LINK "dfc_as[19].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[19].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[19].debmode
	ECU_ADDRESS 0x70013A5E
	SYMBOL_LINK "dfc_as[19].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[20].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[20].id
	ECU_ADDRESS 0x70013A60
	SYMBOL_LINK "dfc_as[20].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[20].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[20].debmode
	ECU_ADDRESS 0x70013A62
	SYMBOL_LINK "dfc_as[20].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[21].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[21].id
	ECU_ADDRESS 0x70013A64
	SYMBOL_LINK "dfc_as[21].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[21].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[21].debmode
	ECU_ADDRESS 0x70013A66
	SYMBOL_LINK "dfc_as[21].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[22].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[22].id
	ECU_ADDRESS 0x70013A68
	SYMBOL_LINK "dfc_as[22].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[22].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[22].debmode
	ECU_ADDRESS 0x70013A6A
	SYMBOL_LINK "dfc_as[22].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[23].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[23].id
	ECU_ADDRESS 0x70013A6C
	SYMBOL_LINK "dfc_as[23].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[23].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[23].debmode
	ECU_ADDRESS 0x70013A6E
	SYMBOL_LINK "dfc_as[23].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[24].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[24].id
	ECU_ADDRESS 0x70013A70
	SYMBOL_LINK "dfc_as[24].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[24].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[24].debmode
	ECU_ADDRESS 0x70013A72
	SYMBOL_LINK "dfc_as[24].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[25].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[25].id
	ECU_ADDRESS 0x70013A74
	SYMBOL_LINK "dfc_as[25].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[25].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[25].debmode
	ECU_ADDRESS 0x70013A76
	SYMBOL_LINK "dfc_as[25].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[26].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[26].id
	ECU_ADDRESS 0x70013A78
	SYMBOL_LINK "dfc_as[26].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[26].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[26].debmode
	ECU_ADDRESS 0x70013A7A
	SYMBOL_LINK "dfc_as[26].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[27].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[27].id
	ECU_ADDRESS 0x70013A7C
	SYMBOL_LINK "dfc_as[27].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[27].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[27].debmode
	ECU_ADDRESS 0x70013A7E
	SYMBOL_LINK "dfc_as[27].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[28].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[28].id
	ECU_ADDRESS 0x70013A80
	SYMBOL_LINK "dfc_as[28].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[28].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[28].debmode
	ECU_ADDRESS 0x70013A82
	SYMBOL_LINK "dfc_as[28].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[29].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[29].id
	ECU_ADDRESS 0x70013A84
	SYMBOL_LINK "dfc_as[29].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[29].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[29].debmode
	ECU_ADDRESS 0x70013A86
	SYMBOL_LINK "dfc_as[29].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[30].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[30].id
	ECU_ADDRESS 0x70013A88
	SYMBOL_LINK "dfc_as[30].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[30].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[30].debmode
	ECU_ADDRESS 0x70013A8A
	SYMBOL_LINK "dfc_as[30].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[31].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[31].id
	ECU_ADDRESS 0x70013A8C
	SYMBOL_LINK "dfc_as[31].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[31].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[31].debmode
	ECU_ADDRESS 0x70013A8E
	SYMBOL_LINK "dfc_as[31].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[32].id ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[32].id
	ECU_ADDRESS 0x70013A90
	SYMBOL_LINK "dfc_as[32].id" 0
/end MEASUREMENT


/begin MEASUREMENT dfc_as[32].debmode ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dfc_as[32].debmode
	ECU_ADDRESS 0x70013A92
	SYMBOL_LINK "dfc_as[32].debmode" 0
/end MEASUREMENT


/begin MEASUREMENT status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER status_u16
	ECU_ADDRESS 0x7001397E
	SYMBOL_LINK "status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT cntrDfes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER cntrDfes_u8
	ECU_ADDRESS 0x7001370F
	SYMBOL_LINK "cntrDfes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT cntrApplBuf_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER cntrApplBuf_u8
	ECU_ADDRESS 0x70013A94
	SYMBOL_LINK "cntrApplBuf_u8" 0
/end MEASUREMENT


/begin MEASUREMENT idxActEntry_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER idxActEntry_u8
	ECU_ADDRESS 0x70013A95
	SYMBOL_LINK "idxActEntry_u8" 0
/end MEASUREMENT


/begin MEASUREMENT idxFirstEmptyEntry_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER idxFirstEmptyEntry_u8
	ECU_ADDRESS 0x70013A96
	SYMBOL_LINK "idxFirstEmptyEntry_u8" 0
/end MEASUREMENT


/begin MEASUREMENT TIME_IN_ROW ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER TIME_IN_ROW
	ECU_ADDRESS 0x70018861
	SYMBOL_LINK "TIME_IN_ROW" 0
/end MEASUREMENT


/begin MEASUREMENT EVENT_IN_ROW ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER EVENT_IN_ROW
	ECU_ADDRESS 0x70018862
	SYMBOL_LINK "EVENT_IN_ROW" 0
/end MEASUREMENT


/begin MEASUREMENT TIME_UP_DOWN ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER TIME_UP_DOWN
	ECU_ADDRESS 0x70018863
	SYMBOL_LINK "TIME_UP_DOWN" 0
/end MEASUREMENT


/begin MEASUREMENT EVENT_UP_DOWN ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER EVENT_UP_DOWN
	ECU_ADDRESS 0x70018864
	SYMBOL_LINK "EVENT_UP_DOWN" 0
/end MEASUREMENT


/begin MEASUREMENT TIME_UP_DOWN_SMALL ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER TIME_UP_DOWN_SMALL
	ECU_ADDRESS 0x70018865
	SYMBOL_LINK "TIME_UP_DOWN_SMALL" 0
/end MEASUREMENT


/begin MEASUREMENT EVENT_UP_DOWN_SMALL ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER EVENT_UP_DOWN_SMALL
	ECU_ADDRESS 0x70018866
	SYMBOL_LINK "EVENT_UP_DOWN_SMALL" 0
/end MEASUREMENT


/begin MEASUREMENT TIME_IN_ROW_SMALL ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER TIME_IN_ROW_SMALL
	ECU_ADDRESS 0x70018867
	SYMBOL_LINK "TIME_IN_ROW_SMALL" 0
/end MEASUREMENT


/begin MEASUREMENT EVENT_IN_ROW_SMALL ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER EVENT_IN_ROW_SMALL
	ECU_ADDRESS 0x70018868
	SYMBOL_LINK "EVENT_IN_ROW_SMALL" 0
/end MEASUREMENT


/begin MEASUREMENT NO_DEBOUNCE ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER NO_DEBOUNCE
	ECU_ADDRESS 0x70018869
	SYMBOL_LINK "NO_DEBOUNCE" 0
/end MEASUREMENT


/begin MEASUREMENT NATIVE ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER NATIVE
	ECU_ADDRESS 0x7001886A
	SYMBOL_LINK "NATIVE" 0
/end MEASUREMENT


/begin MEASUREMENT PDUR_VARIANT_PRE_COMPILE ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PDUR_VARIANT_PRE_COMPILE
	ECU_ADDRESS 0x7001881A
	SYMBOL_LINK "PDUR_VARIANT_PRE_COMPILE" 0
/end MEASUREMENT


/begin MEASUREMENT PDUR_VARIANT_POSTBUILD_LOADABLE ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PDUR_VARIANT_POSTBUILD_LOADABLE
	ECU_ADDRESS 0x7001881B
	SYMBOL_LINK "PDUR_VARIANT_POSTBUILD_LOADABLE" 0
/end MEASUREMENT


/begin MEASUREMENT PDUR_CONFIGURATION_VARIANT ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PDUR_CONFIGURATION_VARIANT
	ECU_ADDRESS 0x70018820
	SYMBOL_LINK "PDUR_CONFIGURATION_VARIANT" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_CddToPduR_HWVrsNumIBS2105_Src ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_CddToPduR_HWVrsNumIBS2105_Src
	ECU_ADDRESS 0x70018821
	SYMBOL_LINK "PduRConf_PduRSrcPdu_CddToPduR_HWVrsNumIBS2105_Src" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRDestPdu_PduRToLinTp_HWVrsNumIBS2105_Dest ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRDestPdu_PduRToLinTp_HWVrsNumIBS2105_Dest
	ECU_ADDRESS 0x70018822
	SYMBOL_LINK "PduRConf_PduRDestPdu_PduRToLinTp_HWVrsNumIBS2105_Dest" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_DoIP_Rx_DoIP2PduR_Src_Java ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_DoIP_Rx_DoIP2PduR_Src_Java
	ECU_ADDRESS 0x70018823
	SYMBOL_LINK "PduRConf_PduRSrcPdu_DoIP_Rx_DoIP2PduR_Src_Java" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRDestPdu_DoIP_Rx_PduR2Dcm_Dest_Java ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRDestPdu_DoIP_Rx_PduR2Dcm_Dest_Java
	ECU_ADDRESS 0x70018824
	SYMBOL_LINK "PduRConf_PduRDestPdu_DoIP_Rx_PduR2Dcm_Dest_Java" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_DoIP_Tx_Dcm2PduR_Src_JavaTool ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_DoIP_Tx_Dcm2PduR_Src_JavaTool
	ECU_ADDRESS 0x70018825
	SYMBOL_LINK "PduRConf_PduRSrcPdu_DoIP_Tx_Dcm2PduR_Src_JavaTool" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRDestPdu_DoIP_Tx_PduR2DoIP_Dest_Java ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRDestPdu_DoIP_Tx_PduR2DoIP_Dest_Java
	ECU_ADDRESS 0x70018826
	SYMBOL_LINK "PduRConf_PduRDestPdu_DoIP_Tx_PduR2DoIP_Dest_Java" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_LinTPToPduR_HWVrsNumIBS2105_Src ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_LinTPToPduR_HWVrsNumIBS2105_Src
	ECU_ADDRESS 0x70018827
	SYMBOL_LINK "PduRConf_PduRSrcPdu_LinTPToPduR_HWVrsNumIBS2105_Src" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRDestPdu_PduRToCdd_HWVrsNumIBS2105_Dest ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRDestPdu_PduRToCdd_HWVrsNumIBS2105_Dest
	ECU_ADDRESS 0x70018828
	SYMBOL_LINK "PduRConf_PduRDestPdu_PduRToCdd_HWVrsNumIBS2105_Dest" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_NM_TX_FA_Com2PduR_Src ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_NM_TX_FA_Com2PduR_Src
	ECU_ADDRESS 0x70018829
	SYMBOL_LINK "PduRConf_PduRSrcPdu_NM_TX_FA_Com2PduR_Src" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRDestPdu_NM_TX_FA_PduR2CanNm_Dest ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRDestPdu_NM_TX_FA_PduR2CanNm_Dest
	ECU_ADDRESS 0x7001882A
	SYMBOL_LINK "PduRConf_PduRDestPdu_NM_TX_FA_PduR2CanNm_Dest" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_rbr_Pdu_Com2PduR_CCVS_xTx_Src ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_rbr_Pdu_Com2PduR_CCVS_xTx_Src
	ECU_ADDRESS 0x7001882B
	SYMBOL_LINK "PduRConf_PduRSrcPdu_rbr_Pdu_Com2PduR_CCVS_xTx_Src" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRDestPdu_rbr_Pdu_CanIf_CCVS_xTx_Dest ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRDestPdu_rbr_Pdu_CanIf_CCVS_xTx_Dest
	ECU_ADDRESS 0x7001882C
	SYMBOL_LINK "PduRConf_PduRDestPdu_rbr_Pdu_CanIf_CCVS_xTx_Dest" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_rbr_Pdu_CanIf_sig_C_xRx_Src ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_rbr_Pdu_CanIf_sig_C_xRx_Src
	ECU_ADDRESS 0x7001882D
	SYMBOL_LINK "PduRConf_PduRSrcPdu_rbr_Pdu_CanIf_sig_C_xRx_Src" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_rbr_Pdu_Com2PduR_C_xTx_Src ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_rbr_Pdu_Com2PduR_C_xTx_Src
	ECU_ADDRESS 0x7001882E
	SYMBOL_LINK "PduRConf_PduRSrcPdu_rbr_Pdu_Com2PduR_C_xTx_Src" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRDestPdu_rbr_Pdu_CanIf_sig_C_xTx_Dest ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRDestPdu_rbr_Pdu_CanIf_sig_C_xTx_Dest
	ECU_ADDRESS 0x7001882F
	SYMBOL_LINK "PduRConf_PduRDestPdu_rbr_Pdu_CanIf_sig_C_xTx_Dest" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_rbr_Pdu_CanIf_EngCtrl1_xRx_Dest ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_rbr_Pdu_CanIf_EngCtrl1_xRx_Dest
	ECU_ADDRESS 0x70018830
	SYMBOL_LINK "PduRConf_PduRSrcPdu_rbr_Pdu_CanIf_EngCtrl1_xRx_Dest" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_UdsOnCan_FctExtdidRx_CanTp2PduR_Src ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_UdsOnCan_FctExtdidRx_CanTp2PduR_Src
	ECU_ADDRESS 0x70018831
	SYMBOL_LINK "PduRConf_PduRSrcPdu_UdsOnCan_FctExtdidRx_CanTp2PduR_Src" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRDestPdu_UdsOnCan_FctExtdidRx_PduR2Dcm_Dest ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRDestPdu_UdsOnCan_FctExtdidRx_PduR2Dcm_Dest
	ECU_ADDRESS 0x70018832
	SYMBOL_LINK "PduRConf_PduRDestPdu_UdsOnCan_FctExtdidRx_PduR2Dcm_Dest" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_UdsOnCan_PhyRxExtdId_CanTp2PduR_Src ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_UdsOnCan_PhyRxExtdId_CanTp2PduR_Src
	ECU_ADDRESS 0x70018833
	SYMBOL_LINK "PduRConf_PduRSrcPdu_UdsOnCan_PhyRxExtdId_CanTp2PduR_Src" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRDestPdu_UdsOnCan_PhyRxExtdId_PduR2Dcm_Dest ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRDestPdu_UdsOnCan_PhyRxExtdId_PduR2Dcm_Dest
	ECU_ADDRESS 0x70018834
	SYMBOL_LINK "PduRConf_PduRDestPdu_UdsOnCan_PhyRxExtdId_PduR2Dcm_Dest" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRSrcPdu_UdsOnCan_PhyTxExtdId_Dcm2PduR_Src ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRSrcPdu_UdsOnCan_PhyTxExtdId_Dcm2PduR_Src
	ECU_ADDRESS 0x70018835
	SYMBOL_LINK "PduRConf_PduRSrcPdu_UdsOnCan_PhyTxExtdId_Dcm2PduR_Src" 0
/end MEASUREMENT


/begin MEASUREMENT PduRConf_PduRDestPdu_UdsOnCan_PhyTxExtdId_PduR2CanTp_Dest ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PduRConf_PduRDestPdu_UdsOnCan_PhyTxExtdId_PduR2CanTp_Dest
	ECU_ADDRESS 0x70018836
	SYMBOL_LINK "PduRConf_PduRDestPdu_UdsOnCan_PhyTxExtdId_PduR2CanTp_Dest" 0
/end MEASUREMENT


/begin MEASUREMENT LinIfConf_LinIfChannel_LinIfChannel_0 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER LinIfConf_LinIfChannel_LinIfChannel_0
	ECU_ADDRESS 0x70018837
	SYMBOL_LINK "LinIfConf_LinIfChannel_LinIfChannel_0" 0
/end MEASUREMENT


/begin MEASUREMENT LinIfConf_LinIfFrame_LinIf_MRF ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER LinIfConf_LinIfFrame_LinIf_MRF
	ECU_ADDRESS 0x70018838
	SYMBOL_LINK "LinIfConf_LinIfFrame_LinIf_MRF" 0
/end MEASUREMENT


/begin MEASUREMENT LinIfConf_LinIfFrame_LinIf_SRF ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER LinIfConf_LinIfFrame_LinIf_SRF
	ECU_ADDRESS 0x70018839
	SYMBOL_LINK "LinIfConf_LinIfFrame_LinIf_SRF" 0
/end MEASUREMENT


/begin MEASUREMENT NULL_SCHEDULE ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER NULL_SCHEDULE
	ECU_ADDRESS 0x7001883A
	SYMBOL_LINK "NULL_SCHEDULE" 0
/end MEASUREMENT


/begin MEASUREMENT LinIf_Scht_MasterReq_LinIfChannel_0_bds_Pb_preDefRef_vrnt01 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER LinIf_Scht_MasterReq_LinIfChannel_0_bds_Pb_preDefRef_vrnt01
	ECU_ADDRESS 0x7001883B
	SYMBOL_LINK "LinIf_Scht_MasterReq_LinIfChannel_0_bds_Pb_preDefRef_vrnt01" 0
/end MEASUREMENT


/begin MEASUREMENT LinIf_Scht_SlaveResp_LinIfChannel_0_bds_Pb_preDefRef_vrnt01 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER LinIf_Scht_SlaveResp_LinIfChannel_0_bds_Pb_preDefRef_vrnt01
	ECU_ADDRESS 0x7001883C
	SYMBOL_LINK "LinIf_Scht_SlaveResp_LinIfChannel_0_bds_Pb_preDefRef_vrnt01" 0
/end MEASUREMENT


/begin MEASUREMENT LinIf_Scht_RUN_MAIN_LinIfChannel_0_bds_Pb_preDefRef_vrnt01 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER LinIf_Scht_RUN_MAIN_LinIfChannel_0_bds_Pb_preDefRef_vrnt01
	ECU_ADDRESS 0x7001883D
	SYMBOL_LINK "LinIf_Scht_RUN_MAIN_LinIfChannel_0_bds_Pb_preDefRef_vrnt01" 0
/end MEASUREMENT


/begin MEASUREMENT COM_VARIANT_PRE_COMPILE ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER COM_VARIANT_PRE_COMPILE
	ECU_ADDRESS 0x7001883E
	SYMBOL_LINK "COM_VARIANT_PRE_COMPILE" 0
/end MEASUREMENT


/begin MEASUREMENT COM_VARIANT_LINK_TIME ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER COM_VARIANT_LINK_TIME
	ECU_ADDRESS 0x7001883F
	SYMBOL_LINK "COM_VARIANT_LINK_TIME" 0
/end MEASUREMENT


/begin MEASUREMENT COM_VARIANT_POSTBUILD_LOADABLE ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER COM_VARIANT_POSTBUILD_LOADABLE
	ECU_ADDRESS 0x70018840
	SYMBOL_LINK "COM_VARIANT_POSTBUILD_LOADABLE" 0
/end MEASUREMENT


/begin MEASUREMENT COM_VARIANT_POSTBUILD_SELECTABLE ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER COM_VARIANT_POSTBUILD_SELECTABLE
	ECU_ADDRESS 0x70018841
	SYMBOL_LINK "COM_VARIANT_POSTBUILD_SELECTABLE" 0
/end MEASUREMENT


/begin MEASUREMENT COM_CONFIGURATION_VARIANT ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER COM_CONFIGURATION_VARIANT
	ECU_ADDRESS 0x70018842
	SYMBOL_LINK "COM_CONFIGURATION_VARIANT" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPdu_ComIPdu_CCVS_xTx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPdu_ComIPdu_CCVS_xTx
	ECU_ADDRESS 0x70018843
	SYMBOL_LINK "ComConf_ComIPdu_ComIPdu_CCVS_xTx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPdu_ComIPdu_C_xTx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPdu_ComIPdu_C_xTx
	ECU_ADDRESS 0x70018844
	SYMBOL_LINK "ComConf_ComIPdu_ComIPdu_C_xTx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPdu_NM_TX_FA ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPdu_NM_TX_FA
	ECU_ADDRESS 0x70018845
	SYMBOL_LINK "ComConf_ComIPdu_NM_TX_FA" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPdu_ComIPdu_C_xRx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPdu_ComIPdu_C_xRx
	ECU_ADDRESS 0x70018846
	SYMBOL_LINK "ComConf_ComIPdu_ComIPdu_C_xRx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPdu_ComIPdu_EngCtrl1_xRx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPdu_ComIPdu_EngCtrl1_xRx
	ECU_ADDRESS 0x70018847
	SYMBOL_LINK "ComConf_ComIPdu_ComIPdu_EngCtrl1_xRx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComSignal_ComSignal_WheelBasedVehicleSpeed_xTx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComSignal_ComSignal_WheelBasedVehicleSpeed_xTx
	ECU_ADDRESS 0x70018848
	SYMBOL_LINK "ComConf_ComSignal_ComSignal_WheelBasedVehicleSpeed_xTx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComSignal_ComSignal_ParkingBrakeSwitch_xTx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComSignal_ComSignal_ParkingBrakeSwitch_xTx
	ECU_ADDRESS 0x70018849
	SYMBOL_LINK "ComConf_ComSignal_ComSignal_ParkingBrakeSwitch_xTx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComSignal_ComSignal_C_xTx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComSignal_ComSignal_C_xTx
	ECU_ADDRESS 0x7001884A
	SYMBOL_LINK "ComConf_ComSignal_ComSignal_C_xTx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComSignal_ComSignal_C_xRx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComSignal_ComSignal_C_xRx
	ECU_ADDRESS 0x7001884B
	SYMBOL_LINK "ComConf_ComSignal_ComSignal_C_xRx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComSignal_ComSignal_EngSpeed_xRx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComSignal_ComSignal_EngSpeed_xRx
	ECU_ADDRESS 0x7001884C
	SYMBOL_LINK "ComConf_ComSignal_ComSignal_EngSpeed_xRx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComSignal_ComSignal_ActualEngPercentTorque_xRx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComSignal_ComSignal_ActualEngPercentTorque_xRx
	ECU_ADDRESS 0x7001884D
	SYMBOL_LINK "ComConf_ComSignal_ComSignal_ActualEngPercentTorque_xRx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComSignalGroup_ComSignalGroup_Tx_1 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComSignalGroup_ComSignalGroup_Tx_1
	ECU_ADDRESS 0x7001884E
	SYMBOL_LINK "ComConf_ComSignalGroup_ComSignalGroup_Tx_1" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComSignalGroup_ComSignalGroup_Rx_1 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComSignalGroup_ComSignalGroup_Rx_1
	ECU_ADDRESS 0x7001884F
	SYMBOL_LINK "ComConf_ComSignalGroup_ComSignalGroup_Rx_1" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComGroupSignal_ComGroupSignal_Tx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComGroupSignal_ComGroupSignal_Tx
	ECU_ADDRESS 0x70018850
	SYMBOL_LINK "ComConf_ComGroupSignal_ComGroupSignal_Tx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComGroupSignal_ComGroupSignal_Rx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComGroupSignal_ComGroupSignal_Rx
	ECU_ADDRESS 0x70018851
	SYMBOL_LINK "ComConf_ComGroupSignal_ComGroupSignal_Rx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_ComIPduGroup_CAN_2_Rx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_ComIPduGroup_CAN_2_Rx
	ECU_ADDRESS 0x70018852
	SYMBOL_LINK "ComConf_ComIPduGroup_ComIPduGroup_CAN_2_Rx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_ComIPduGroup_CAN_2_Tx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_ComIPduGroup_CAN_2_Tx
	ECU_ADDRESS 0x70018853
	SYMBOL_LINK "ComConf_ComIPduGroup_ComIPduGroup_CAN_2_Tx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_ComIPduGroup_C_Rx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_ComIPduGroup_C_Rx
	ECU_ADDRESS 0x70018854
	SYMBOL_LINK "ComConf_ComIPduGroup_ComIPduGroup_C_Rx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_ComIPduGroup_C_Tx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_ComIPduGroup_C_Tx
	ECU_ADDRESS 0x70018855
	SYMBOL_LINK "ComConf_ComIPduGroup_ComIPduGroup_C_Tx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_LE_CAN_NM_TX ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_LE_CAN_NM_TX
	ECU_ADDRESS 0x70018856
	SYMBOL_LINK "ComConf_ComIPduGroup_LE_CAN_NM_TX" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_LP_CAN_NM_TX ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_LP_CAN_NM_TX
	ECU_ADDRESS 0x70018857
	SYMBOL_LINK "ComConf_ComIPduGroup_LP_CAN_NM_TX" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_LinChannel_0_RX ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_LinChannel_0_RX
	ECU_ADDRESS 0x70018858
	SYMBOL_LINK "ComConf_ComIPduGroup_LinChannel_0_RX" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_LinChannel_0_TX ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_LinChannel_0_TX
	ECU_ADDRESS 0x70018859
	SYMBOL_LINK "ComConf_ComIPduGroup_LinChannel_0_TX" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_LinRx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_LinRx
	ECU_ADDRESS 0x7001885A
	SYMBOL_LINK "ComConf_ComIPduGroup_LinRx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_LinTx ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_LinTx
	ECU_ADDRESS 0x7001885B
	SYMBOL_LINK "ComConf_ComIPduGroup_LinTx" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_MLIN_RX ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_MLIN_RX
	ECU_ADDRESS 0x7001885C
	SYMBOL_LINK "ComConf_ComIPduGroup_MLIN_RX" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_MLIN_TX ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_MLIN_TX
	ECU_ADDRESS 0x7001885D
	SYMBOL_LINK "ComConf_ComIPduGroup_MLIN_TX" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_PT_CAN_RX ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_PT_CAN_RX
	ECU_ADDRESS 0x7001885E
	SYMBOL_LINK "ComConf_ComIPduGroup_PT_CAN_RX" 0
/end MEASUREMENT


/begin MEASUREMENT ComConf_ComIPduGroup_PT_CAN_TX ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER ComConf_ComIPduGroup_PT_CAN_TX
	ECU_ADDRESS 0x7001885F
	SYMBOL_LINK "ComConf_ComIPduGroup_PT_CAN_TX" 0
/end MEASUREMENT


/begin MEASUREMENT BDS_LIN_CHNL_1_DU8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER BDS_LIN_CHNL_1_DU8
	ECU_ADDRESS 0x70018860
	SYMBOL_LINK "BDS_LIN_CHNL_1_DU8" 0
/end MEASUREMENT


/begin COMPU_METHOD CnvRule_NumberOneToOne "This is a predefined standard conversion rule for signals representing a number with a 1:1 conversion (*nr*_*)."
	IDENTICAL "%.0" "-"
/end COMPU_METHOD

/end MODULE
/end PROJECT
