/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[14].spn_u32
	ECU_ADDRESS 0x7001508C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015090
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015091
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015094
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015098
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015099
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[16].spn_u32
	ECU_ADDRESS 0x7001509C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700150A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700150A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700150A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700150A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700150A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700150AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700150B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700150B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700150B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700150B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700150B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700150BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700150C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700150C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as
	ECU_ADDRESS 0x70015024
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700150C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700150CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700150CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700150D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700150D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700150D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700150D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700150DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700150DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700150E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700150E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700150E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700150E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700150EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700150ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700150F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700150F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700150F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700150F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700150FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700150FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015100
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015104
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015105
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015108
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x7001510C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[9].occ_u8
	ECU_ADDRESS 0x7001510D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015110
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015114
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015115
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015118
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x7001511C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[11].occ_u8
	ECU_ADDRESS 0x7001511D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015120
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015124
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015125
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015128
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x7001512C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[13].occ_u8
	ECU_ADDRESS 0x7001512D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015130
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015134
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015135
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015138
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x7001513C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[15].occ_u8
	ECU_ADDRESS 0x7001513D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015140
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015144
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015145
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015148
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x7001514C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[17].occ_u8
	ECU_ADDRESS 0x7001514D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015150
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015154
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015155
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015158
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x7001515C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[19].occ_u8
	ECU_ADDRESS 0x7001515D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015164
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015165
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[3].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[3].dtc_as
	ECU_ADDRESS 0x700150C8
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[3].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[1].spn_u32
	ECU_ADDRESS 0x7001516C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015170
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015171
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015174
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015178
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015179
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[3].spn_u32
	ECU_ADDRESS 0x7001517C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015180
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015181
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015184
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015188
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015189
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[5].spn_u32
	ECU_ADDRESS 0x7001518C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015190
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015191
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015194
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015198
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015199
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[7].spn_u32
	ECU_ADDRESS 0x7001519C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700151A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700151A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700151A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700151A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700151A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700151AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700151B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700151B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700151B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700151B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700151B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700151BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700151C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700151C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700151C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700151C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700151C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700151CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700151D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700151D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700151D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700151D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700151D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700151DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700151E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700151E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700151E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700151E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700151E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700151EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700151F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700151F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700151F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700151F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700151F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700151FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015200
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015201
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015204
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015208
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015209
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[4].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[4].dtc_as
	ECU_ADDRESS 0x7001516C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[4].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015210
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015214
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015215
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015218
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x7001521C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[2].occ_u8
	ECU_ADDRESS 0x7001521D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015220
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015224
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015225
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015228
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x7001522C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[4].occ_u8
	ECU_ADDRESS 0x7001522D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015230
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015234
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015235
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015238
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x7001523C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[6].occ_u8
	ECU_ADDRESS 0x7001523D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015240
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015244
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015245
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015248
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x7001524C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[8].occ_u8
	ECU_ADDRESS 0x7001524D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015250
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015254
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015255
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015258
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x7001525C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[10].occ_u8
	ECU_ADDRESS 0x7001525D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015260
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015264
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015265
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015268
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x7001526C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[12].occ_u8
	ECU_ADDRESS 0x7001526D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015270
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015274
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015275
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015278
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x7001527C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[14].occ_u8
	ECU_ADDRESS 0x7001527D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015280
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015284
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015285
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015288
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x7001528C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[16].occ_u8
	ECU_ADDRESS 0x7001528D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015290
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015294
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015295
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015298
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x7001529C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[18].occ_u8
	ECU_ADDRESS 0x7001529D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700152A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700152A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700152A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700152A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700152AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700152AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[5].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[5].dtc_as
	ECU_ADDRESS 0x70015210
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[5].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700152B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700152B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700152B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700152BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700152C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700152C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700152C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700152C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700152C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700152CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700152D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700152D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700152D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700152D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700152D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700152DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700152E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700152E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700152E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700152E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700152E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700152EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700152F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700152F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700152F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700152F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700152F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700152FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015300
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015301
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015304
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015308
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015309
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[12].spn_u32
	ECU_ADDRESS 0x7001530C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015310
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015311
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015314
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015318
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015319
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[14].spn_u32
	ECU_ADDRESS 0x7001531C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015320
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015321
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015324
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015328
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015329
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[16].spn_u32
	ECU_ADDRESS 0x7001532C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015330
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015331
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015334
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015338
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015339
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[18].spn_u32
	ECU_ADDRESS 0x7001533C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015340
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015341
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015344
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015348
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015349
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[20].spn_u32
	ECU_ADDRESS 0x7001534C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015350
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015351
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[6].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[6].dtc_as
	ECU_ADDRESS 0x700152B4
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[6].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015358
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x7001535C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[1].occ_u8
	ECU_ADDRESS 0x7001535D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015360
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015364
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015365
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015368
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x7001536C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[3].occ_u8
	ECU_ADDRESS 0x7001536D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015370
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015374
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015375
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015378
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x7001537C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[5].occ_u8
	ECU_ADDRESS 0x7001537D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015380
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015384
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015385
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015388
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x7001538C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[7].occ_u8
	ECU_ADDRESS 0x7001538D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015390
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015394
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015395
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015398
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x7001539C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[9].occ_u8
	ECU_ADDRESS 0x7001539D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700153A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700153A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700153A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700153A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700153AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700153AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700153B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700153B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700153B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700153B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700153BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700153BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700153C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700153C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700153C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700153C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700153CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700153CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700153D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700153D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700153D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700153D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700153DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700153DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700153E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700153E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700153E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700153E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700153EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700153ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700153F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700153F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700153F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[7].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[7].dtc_as
	ECU_ADDRESS 0x70015358
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[7].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700153FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015400
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015401
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015404
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015408
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015409
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[3].spn_u32
	ECU_ADDRESS 0x7001540C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015410
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015411
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015414
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015418
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015419
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[5].spn_u32
	ECU_ADDRESS 0x7001541C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015420
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015421
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015424
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015428
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015429
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[7].spn_u32
	ECU_ADDRESS 0x7001542C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015430
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015431
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015434
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015438
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015439
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[9].spn_u32
	ECU_ADDRESS 0x7001543C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015440
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015441
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015444
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015448
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015449
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[11].spn_u32
	ECU_ADDRESS 0x7001544C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015450
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015451
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015454
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015458
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015459
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[13].spn_u32
	ECU_ADDRESS 0x7001545C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015460
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015461
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015464
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015468
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015469
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[15].spn_u32
	ECU_ADDRESS 0x7001546C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015470
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015471
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015474
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015478
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015479
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[17].spn_u32
	ECU_ADDRESS 0x7001547C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015480
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015481
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015484
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015488
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015489
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[19].spn_u32
	ECU_ADDRESS 0x7001548C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015490
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015491
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015494
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015498
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015499
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[8].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[8].dtc_as
	ECU_ADDRESS 0x700153FC
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[8].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700154A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700154A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700154A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700154A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700154AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700154AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700154B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700154B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700154B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700154B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700154BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700154BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700154C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700154C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700154C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700154C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700154CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700154CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700154D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700154D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700154D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700154D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700154DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700154DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700154E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700154E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700154E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700154E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700154EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700154ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700154F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700154F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700154F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700154F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700154FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700154FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015500
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015504
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015505
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015508
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x7001550C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[14].occ_u8
	ECU_ADDRESS 0x7001550D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015510
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015514
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015515
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015518
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x7001551C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[16].occ_u8
	ECU_ADDRESS 0x7001551D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015520
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015524
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015525
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015528
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x7001552C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[18].occ_u8
	ECU_ADDRESS 0x7001552D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015530
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015534
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015535
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015538
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x7001553C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as[20].occ_u8
	ECU_ADDRESS 0x7001553D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[9].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[9].dtc_as
	ECU_ADDRESS 0x700154A0
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[9].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015544
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015548
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015549
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[2].spn_u32
	ECU_ADDRESS 0x7001554C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015550
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015551
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015554
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015558
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015559
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[4].spn_u32
	ECU_ADDRESS 0x7001555C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015560
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015561
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015564
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015568
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015569
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[6].spn_u32
	ECU_ADDRESS 0x7001556C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015570
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015571
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015574
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015578
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015579
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[8].spn_u32
	ECU_ADDRESS 0x7001557C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015580
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015581
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015584
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015588
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015589
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[10].spn_u32
	ECU_ADDRESS 0x7001558C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015590
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015591
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015594
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015598
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015599
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[12].spn_u32
	ECU_ADDRESS 0x7001559C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700155A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700155A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700155A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700155A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700155A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700155AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700155B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700155B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700155B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700155B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700155B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700155BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700155C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700155C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700155C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700155C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700155C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700155CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700155D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700155D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700155D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700155D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700155D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700155DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700155E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700155E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[10].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[10].dtc_as
	ECU_ADDRESS 0x70015544
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[10].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700155E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700155EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700155ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700155F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700155F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700155F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700155F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700155FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700155FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015600
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015604
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015605
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015608
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x7001560C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[5].occ_u8
	ECU_ADDRESS 0x7001560D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015610
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015614
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015615
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015618
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x7001561C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[7].occ_u8
	ECU_ADDRESS 0x7001561D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015620
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015624
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015625
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015628
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x7001562C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[9].occ_u8
	ECU_ADDRESS 0x7001562D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015630
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015634
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015635
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015638
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x7001563C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[11].occ_u8
	ECU_ADDRESS 0x7001563D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015640
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015644
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015645
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015648
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x7001564C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[13].occ_u8
	ECU_ADDRESS 0x7001564D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015650
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015654
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015655
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015658
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x7001565C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[15].occ_u8
	ECU_ADDRESS 0x7001565D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015660
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015664
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015665
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015668
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x7001566C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[17].occ_u8
	ECU_ADDRESS 0x7001566D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015670
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015674
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015675
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015678
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x7001567C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[19].occ_u8
	ECU_ADDRESS 0x7001567D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015680
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015684
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015685
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[11].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[11].dtc_as
	ECU_ADDRESS 0x700155E8
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[11].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[1].spn_u32
	ECU_ADDRESS 0x7001568C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015690
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015691
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015694
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015698
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015699
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[3].spn_u32
	ECU_ADDRESS 0x7001569C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700156A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700156A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700156A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700156A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700156A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700156AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700156B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700156B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700156B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700156B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700156B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700156BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700156C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700156C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700156C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700156C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700156C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700156CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700156D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700156D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700156D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700156D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700156D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700156DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700156E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700156E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700156E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700156E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700156E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700156EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700156F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700156F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700156F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700156F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700156F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700156FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015700
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015701
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015704
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015708
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015709
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[17].spn_u32
	ECU_ADDRESS 0x7001570C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015710
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015711
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015714
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015718
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015719
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[19].spn_u32
	ECU_ADDRESS 0x7001571C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015720
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015721
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015724
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015728
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015729
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[12].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[12].dtc_as
	ECU_ADDRESS 0x7001568C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[12].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015730
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015734
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015735
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015738
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x7001573C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[2].occ_u8
	ECU_ADDRESS 0x7001573D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015740
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015744
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015745
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015748
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x7001574C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[4].occ_u8
	ECU_ADDRESS 0x7001574D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015750
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015754
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015755
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015758
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x7001575C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[6].occ_u8
	ECU_ADDRESS 0x7001575D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015760
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015764
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015765
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015768
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x7001576C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[8].occ_u8
	ECU_ADDRESS 0x7001576D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015770
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015774
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015775
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015778
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x7001577C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[10].occ_u8
	ECU_ADDRESS 0x7001577D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015780
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015784
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015785
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015788
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x7001578C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[12].occ_u8
	ECU_ADDRESS 0x7001578D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015790
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015794
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015795
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015798
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x7001579C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[14].occ_u8
	ECU_ADDRESS 0x7001579D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700157A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700157A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700157A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700157A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700157AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700157AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700157B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700157B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700157B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700157B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700157BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700157BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700157C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700157C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700157C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700157C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700157CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700157CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[13].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[13].dtc_as
	ECU_ADDRESS 0x70015730
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[13].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700157D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700157D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700157D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700157DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700157E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700157E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700157E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700157E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700157E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700157EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700157F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700157F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700157F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700157F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700157F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700157FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015800
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015801
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015804
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015808
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015809
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[8].spn_u32
	ECU_ADDRESS 0x7001580C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015810
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015811
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015814
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015818
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015819
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[10].spn_u32
	ECU_ADDRESS 0x7001581C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015820
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015821
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015824
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015828
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015829
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[12].spn_u32
	ECU_ADDRESS 0x7001582C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015830
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015831
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015834
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015838
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015839
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[14].spn_u32
	ECU_ADDRESS 0x7001583C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015840
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015841
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015844
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015848
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015849
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[16].spn_u32
	ECU_ADDRESS 0x7001584C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015850
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015851
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015854
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015858
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015859
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[18].spn_u32
	ECU_ADDRESS 0x7001585C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015860
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015861
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015864
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015868
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015869
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[20].spn_u32
	ECU_ADDRESS 0x7001586C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015870
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015871
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[14].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[14].dtc_as
	ECU_ADDRESS 0x700157D4
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[14].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015878
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x7001587C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[1].occ_u8
	ECU_ADDRESS 0x7001587D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015880
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015884
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015885
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015888
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x7001588C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[3].occ_u8
	ECU_ADDRESS 0x7001588D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015890
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015894
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015895
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015898
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x7001589C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[5].occ_u8
	ECU_ADDRESS 0x7001589D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700158A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700158A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700158A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700158A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700158AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700158AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700158B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700158B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700158B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700158B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700158BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700158BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700158C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700158C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700158C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700158C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700158CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700158CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700158D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700158D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700158D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700158D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700158DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700158DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700158E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700158E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700158E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700158E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700158EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700158ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700158F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700158F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700158F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700158F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700158FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700158FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015900
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015904
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015905
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015908
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x7001590C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[19].occ_u8
	ECU_ADDRESS 0x7001590D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015910
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015914
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015915
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[15].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[15].dtc_as
	ECU_ADDRESS 0x70015878
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[15].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[1].spn_u32
	ECU_ADDRESS 0x7001591C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015920
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015921
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015924
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015928
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015929
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[3].spn_u32
	ECU_ADDRESS 0x7001592C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015930
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015931
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015934
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015938
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015939
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[5].spn_u32
	ECU_ADDRESS 0x7001593C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015940
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015941
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015944
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015948
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015949
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[7].spn_u32
	ECU_ADDRESS 0x7001594C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015950
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015951
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015954
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015958
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015959
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[9].spn_u32
	ECU_ADDRESS 0x7001595C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015960
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015961
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015964
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015968
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015969
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[11].spn_u32
	ECU_ADDRESS 0x7001596C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015970
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015971
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015974
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015978
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015979
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[13].spn_u32
	ECU_ADDRESS 0x7001597C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015980
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015981
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015984
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015988
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015989
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[15].spn_u32
	ECU_ADDRESS 0x7001598C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015990
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015991
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015994
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015998
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015999
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[17].spn_u32
	ECU_ADDRESS 0x7001599C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700159A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700159A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700159A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700159A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700159A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700159AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700159B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700159B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700159B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700159B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700159B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[16].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[16].dtc_as
	ECU_ADDRESS 0x7001591C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[16].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700159C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700159C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700159C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700159C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700159CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700159CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700159D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700159D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700159D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700159D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700159DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700159DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700159E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700159E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700159E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700159E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700159EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700159ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700159F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700159F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700159F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700159F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700159FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700159FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015A00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015A04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015A05
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015A08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015A0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015A0D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015A10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015A14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015A15
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015A18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015A1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015A1D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015A20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015A24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015A25
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015A28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015A2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015A2D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015A30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015A34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015A35
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015A38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015A3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015A3D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015A40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015A44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015A45
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015A48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015A4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015A4D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015A50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015A54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015A55
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015A58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015A5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015A5D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[17].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[17].dtc_as
	ECU_ADDRESS 0x700159C0
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[17].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015A64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015A68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015A69
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015A6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015A70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015A71
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015A74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015A78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015A79
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015A7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015A80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015A81
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015A84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015A88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015A89
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015A8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015A90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015A91
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015A94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015A98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015A99
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015A9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015AA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015AA1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015AA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015AA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015AA9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015AAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015AB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015AB1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015AB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015AB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015AB9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015ABC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015AC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015AC1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015AC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015AC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015AC9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015ACC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015AD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015AD1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015AD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015AD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015AD9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015ADC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015AE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015AE1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015AE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015AE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015AE9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015AEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015AF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015AF1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015AF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015AF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015AF9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015AFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015B00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015B01
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[18].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[18].dtc_as
	ECU_ADDRESS 0x70015A64
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[18].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015B08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015B0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015B0D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015B10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015B14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015B15
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015B18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015B1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015B1D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015B20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015B24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015B25
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015B28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015B2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015B2D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015B30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015B34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015B35
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015B38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015B3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015B3D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015B40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015B44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015B45
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015B48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015B4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015B4D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015B50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015B54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015B55
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015B58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015B5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015B5D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015B60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015B64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015B65
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015B68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015B6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015B6D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015B70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015B74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015B75
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015B78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015B7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015B7D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015B80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015B84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015B85
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015B88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015B8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015B8D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015B90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015B94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015B95
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015B98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015B9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015B9D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015BA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015BA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015BA5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[19].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[19].dtc_as
	ECU_ADDRESS 0x70015B08
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[19].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015BAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015BB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015BB1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015BB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015BB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015BB9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015BBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015BC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015BC1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015BC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015BC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015BC9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015BCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015BD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015BD1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015BD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015BD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015BD9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015BDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015BE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015BE1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015BE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015BE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015BE9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015BEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015BF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015BF1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015BF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015BF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015BF9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015BFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015C00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015C01
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015C04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015C08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015C09
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015C0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015C10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015C11
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015C14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015C18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015C19
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015C1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015C20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015C21
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015C24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015C28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015C29
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015C2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015C30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015C31
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015C34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015C38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015C39
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015C3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015C40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015C41
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015C44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015C48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015C49
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[20].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[20].dtc_as
	ECU_ADDRESS 0x70015BAC
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[20].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015C50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015C54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015C55
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015C58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015C5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015C5D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015C60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015C64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015C65
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015C68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015C6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015C6D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015C70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015C74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015C75
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015C78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015C7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015C7D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015C80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015C84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015C85
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015C88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015C8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015C8D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015C90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015C94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015C95
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015C98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015C9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015C9D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015CA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015CA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015CA5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015CA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015CAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015CAD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015CB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015CB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015CB5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015CB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015CBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015CBD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015CC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015CC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015CC5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015CC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015CCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015CCD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015CD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015CD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015CD5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015CD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015CDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015CDD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015CE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015CE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015CE5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015CE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015CEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015CED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[21].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[21].dtc_as
	ECU_ADDRESS 0x70015C50
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[21].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015CF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015CF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015CF9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015CFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015D00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015D01
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015D04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015D08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015D09
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015D0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015D10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015D11
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015D14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015D18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015D19
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015D1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015D20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015D21
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015D24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015D28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015D29
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015D2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015D30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015D31
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015D34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015D38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015D39
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015D3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015D40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015D41
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015D44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015D48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015D49
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015D4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015D50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015D51
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015D54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015D58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015D59
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015D5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015D60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015D61
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015D64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015D68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015D69
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015D6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015D70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015D71
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015D74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015D78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015D79
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015D7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015D80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015D81
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015D84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015D88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015D89
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015D8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015D90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015D91
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[22].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[22].dtc_as
	ECU_ADDRESS 0x70015CF4
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[22].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015D98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015D9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015D9D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015DA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015DA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015DA5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015DA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015DAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015DAD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015DB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015DB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015DB5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015DB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015DBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015DBD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015DC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015DC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015DC5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015DC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015DCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015DCD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015DD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015DD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015DD5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015DD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015DDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015DDD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015DE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015DE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015DE5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015DE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015DEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015DED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015DF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015DF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015DF5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015DF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015DFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015DFD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015E00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015E04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015E05
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015E08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015E0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015E0D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015E10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015E14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015E15
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015E18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015E1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015E1D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015E20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015E24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015E25
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015E28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015E2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015E2D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015E30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015E34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015E35
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[23].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[23].dtc_as
	ECU_ADDRESS 0x70015D98
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[23].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015E3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015E40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015E41
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015E44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015E48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015E49
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015E4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015E50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015E51
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015E54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015E58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015E59
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015E5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015E60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015E61
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015E64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015E68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015E69
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015E6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015E70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015E71
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015E74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015E78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015E79
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015E7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015E80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015E81
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015E84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015E88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015E89
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015E8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015E90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015E91
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015E94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015E98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015E99
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015E9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015EA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015EA1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015EA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015EA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015EA9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015EAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015EB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015EB1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015EB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015EB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015EB9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015EBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015EC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015EC1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015EC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015EC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015EC9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015ECC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015ED0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015ED1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015ED4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015ED8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015ED9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[24].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[24].dtc_as
	ECU_ADDRESS 0x70015E3C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[24].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015EE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015EE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015EE5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015EE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015EEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015EED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015EF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015EF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015EF5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015EF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015EFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015EFD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015F00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015F04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015F05
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015F08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015F0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015F0D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015F10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015F14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015F15
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015F18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015F1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015F1D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015F20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015F24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015F25
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015F28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015F2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015F2D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015F30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015F34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015F35
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015F38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015F3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015F3D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015F40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015F44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015F45
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015F48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015F4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015F4D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015F50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015F54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015F55
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015F58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70015F5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70015F5D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015F60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015F64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015F65
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015F68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70015F6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70015F6D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015F70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015F74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015F75
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015F78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70015F7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70015F7D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[25].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[25].dtc_as
	ECU_ADDRESS 0x70015EE0
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[25].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015F84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015F88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015F89
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70015F8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015F90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015F91
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015F94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015F98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015F99
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70015F9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015FA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015FA1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015FA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015FA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015FA9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70015FAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015FB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015FB1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015FB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015FB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015FB9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70015FBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015FC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015FC1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015FC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015FC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015FC9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70015FCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015FD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015FD1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015FD4
