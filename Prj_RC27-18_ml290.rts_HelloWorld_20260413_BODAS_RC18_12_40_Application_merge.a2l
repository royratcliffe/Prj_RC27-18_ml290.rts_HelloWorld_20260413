	ECU_ADDRESS 0x70016F11
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016F14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016F18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016F19
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016F1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016F20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016F21
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016F24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016F28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016F29
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016F2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016F30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016F31
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016F34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016F38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016F39
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016F3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016F40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016F41
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016F44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016F48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016F49
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016F4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016F50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016F51
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016F54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016F58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016F59
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016F5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016F60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016F61
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016F64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016F68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016F69
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016F6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016F70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016F71
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016F74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016F78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016F79
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016F7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016F80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016F81
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as
	ECU_ADDRESS 0x70016EE4
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016F88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016F8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016F8D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016F90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016F94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016F95
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016F98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016F9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016F9D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016FA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016FA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016FA5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016FA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016FAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016FAD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016FB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016FB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016FB5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016FB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016FBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016FBD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016FC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016FC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016FC5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016FC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016FCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016FCD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016FD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016FD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016FD5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016FD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016FDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016FDD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016FE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016FE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016FE5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016FE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016FEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016FED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016FF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016FF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016FF5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016FF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016FFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016FFD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017000
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017004
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017005
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017008
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x7001700C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[17].occ_u8
	ECU_ADDRESS 0x7001700D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017010
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017014
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017015
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017018
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x7001701C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[19].occ_u8
	ECU_ADDRESS 0x7001701D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017020
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017024
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017025
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[51].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[51].dtc_as
	ECU_ADDRESS 0x70016F88
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[51].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[1].spn_u32
	ECU_ADDRESS 0x7001702C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017030
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017031
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017034
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017038
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017039
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[3].spn_u32
	ECU_ADDRESS 0x7001703C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017040
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017041
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017044
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017048
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017049
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[5].spn_u32
	ECU_ADDRESS 0x7001704C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017050
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017051
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017054
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017058
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017059
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[7].spn_u32
	ECU_ADDRESS 0x7001705C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017060
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017061
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017064
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017068
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017069
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[9].spn_u32
	ECU_ADDRESS 0x7001706C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017070
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017071
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017074
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017078
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017079
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[11].spn_u32
	ECU_ADDRESS 0x7001707C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017080
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017081
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017084
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017088
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017089
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[13].spn_u32
	ECU_ADDRESS 0x7001708C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017090
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017091
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017094
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017098
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017099
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[15].spn_u32
	ECU_ADDRESS 0x7001709C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700170A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700170A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700170A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700170A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700170A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700170AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700170B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700170B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700170B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700170B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700170B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700170BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700170C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700170C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700170C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700170C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700170C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[52].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[52].dtc_as
	ECU_ADDRESS 0x7001702C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[52].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700170D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700170D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700170D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700170D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700170DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700170DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700170E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700170E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700170E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700170E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700170EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700170ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700170F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700170F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700170F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700170F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700170FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700170FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017100
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017104
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017105
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017108
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x7001710C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[8].occ_u8
	ECU_ADDRESS 0x7001710D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017110
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017114
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017115
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017118
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x7001711C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[10].occ_u8
	ECU_ADDRESS 0x7001711D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017120
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017124
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017125
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017128
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x7001712C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[12].occ_u8
	ECU_ADDRESS 0x7001712D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017130
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017134
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017135
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017138
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x7001713C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[14].occ_u8
	ECU_ADDRESS 0x7001713D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017140
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017144
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017145
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017148
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x7001714C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[16].occ_u8
	ECU_ADDRESS 0x7001714D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017150
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017154
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017155
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017158
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x7001715C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[18].occ_u8
	ECU_ADDRESS 0x7001715D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017164
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017165
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017168
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x7001716C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as[20].occ_u8
	ECU_ADDRESS 0x7001716D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[53].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[53].dtc_as
	ECU_ADDRESS 0x700170D0
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[53].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017174
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017178
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017179
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[2].spn_u32
	ECU_ADDRESS 0x7001717C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017180
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017181
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017184
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017188
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017189
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[4].spn_u32
	ECU_ADDRESS 0x7001718C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017190
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017191
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017194
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017198
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017199
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[6].spn_u32
	ECU_ADDRESS 0x7001719C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700171A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700171A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700171A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700171A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700171A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700171AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700171B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700171B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700171B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700171B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700171B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700171BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700171C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700171C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700171C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700171C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700171C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700171CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700171D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700171D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700171D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700171D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700171D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700171DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700171E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700171E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700171E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700171E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700171E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700171EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700171F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700171F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700171F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700171F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700171F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700171FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017200
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017201
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017204
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017208
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017209
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[20].spn_u32
	ECU_ADDRESS 0x7001720C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017210
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017211
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[54].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[54].dtc_as
	ECU_ADDRESS 0x70017174
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[54].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017218
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x7001721C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[1].occ_u8
	ECU_ADDRESS 0x7001721D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017220
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017224
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017225
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017228
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x7001722C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[3].occ_u8
	ECU_ADDRESS 0x7001722D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017230
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017234
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017235
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017238
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x7001723C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[5].occ_u8
	ECU_ADDRESS 0x7001723D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017240
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017244
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017245
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017248
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x7001724C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[7].occ_u8
	ECU_ADDRESS 0x7001724D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017250
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017254
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017255
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017258
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x7001725C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[9].occ_u8
	ECU_ADDRESS 0x7001725D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017260
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017264
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017265
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017268
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x7001726C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[11].occ_u8
	ECU_ADDRESS 0x7001726D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017270
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017274
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017275
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017278
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x7001727C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[13].occ_u8
	ECU_ADDRESS 0x7001727D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017280
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017284
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017285
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017288
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x7001728C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[15].occ_u8
	ECU_ADDRESS 0x7001728D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017290
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017294
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017295
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017298
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x7001729C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[17].occ_u8
	ECU_ADDRESS 0x7001729D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700172A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700172A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700172A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700172A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700172AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700172AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700172B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700172B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700172B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[55].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[55].dtc_as
	ECU_ADDRESS 0x70017218
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[55].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700172BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700172C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700172C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700172C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700172C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700172C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700172CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700172D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700172D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700172D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700172D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700172D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700172DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700172E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700172E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700172E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700172E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700172E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700172EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700172F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700172F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700172F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700172F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700172F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700172FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017300
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017301
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017304
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017308
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017309
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[11].spn_u32
	ECU_ADDRESS 0x7001730C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017310
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017311
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017314
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017318
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017319
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[13].spn_u32
	ECU_ADDRESS 0x7001731C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017320
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017321
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017324
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017328
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017329
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[15].spn_u32
	ECU_ADDRESS 0x7001732C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017330
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017331
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017334
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017338
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017339
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[17].spn_u32
	ECU_ADDRESS 0x7001733C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017340
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017341
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017344
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017348
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017349
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[19].spn_u32
	ECU_ADDRESS 0x7001734C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017350
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017351
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017354
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017358
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017359
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[56].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[56].dtc_as
	ECU_ADDRESS 0x700172BC
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[56].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017360
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017364
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017365
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017368
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x7001736C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[2].occ_u8
	ECU_ADDRESS 0x7001736D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017370
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017374
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017375
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017378
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x7001737C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[4].occ_u8
	ECU_ADDRESS 0x7001737D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017380
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017384
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017385
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017388
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x7001738C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[6].occ_u8
	ECU_ADDRESS 0x7001738D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017390
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017394
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017395
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017398
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x7001739C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[8].occ_u8
	ECU_ADDRESS 0x7001739D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700173A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700173A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700173A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700173A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700173AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700173AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700173B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700173B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700173B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700173B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700173BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700173BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700173C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700173C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700173C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700173C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700173CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700173CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700173D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700173D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700173D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700173D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700173DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700173DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700173E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700173E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700173E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700173E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700173EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700173ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700173F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700173F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700173F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700173F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700173FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700173FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[57].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[57].dtc_as
	ECU_ADDRESS 0x70017360
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[57].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017404
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017408
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017409
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[2].spn_u32
	ECU_ADDRESS 0x7001740C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017410
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017411
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017414
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017418
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017419
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[4].spn_u32
	ECU_ADDRESS 0x7001741C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017420
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017421
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017424
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017428
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017429
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[6].spn_u32
	ECU_ADDRESS 0x7001742C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017430
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017431
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017434
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017438
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017439
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[8].spn_u32
	ECU_ADDRESS 0x7001743C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017440
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017441
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017444
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017448
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017449
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[10].spn_u32
	ECU_ADDRESS 0x7001744C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017450
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017451
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017454
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017458
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017459
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[12].spn_u32
	ECU_ADDRESS 0x7001745C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017460
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017461
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017464
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017468
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017469
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[14].spn_u32
	ECU_ADDRESS 0x7001746C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017470
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017471
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017474
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017478
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017479
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[16].spn_u32
	ECU_ADDRESS 0x7001747C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017480
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017481
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017484
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017488
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017489
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[18].spn_u32
	ECU_ADDRESS 0x7001748C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017490
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017491
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017494
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017498
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017499
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[20].spn_u32
	ECU_ADDRESS 0x7001749C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700174A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700174A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[58].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[58].dtc_as
	ECU_ADDRESS 0x70017404
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[58].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700174A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700174AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700174AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700174B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700174B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700174B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700174B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700174BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700174BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700174C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700174C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700174C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700174C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700174CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700174CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700174D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700174D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700174D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700174D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700174DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700174DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700174E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700174E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700174E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700174E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700174EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700174ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700174F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700174F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700174F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700174F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700174FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700174FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017500
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017504
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017505
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017508
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x7001750C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[13].occ_u8
	ECU_ADDRESS 0x7001750D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017510
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017514
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017515
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017518
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x7001751C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[15].occ_u8
	ECU_ADDRESS 0x7001751D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017520
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017524
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017525
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017528
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x7001752C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[17].occ_u8
	ECU_ADDRESS 0x7001752D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017530
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017534
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017535
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017538
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x7001753C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[19].occ_u8
	ECU_ADDRESS 0x7001753D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017540
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017544
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017545
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[59].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[59].dtc_as
	ECU_ADDRESS 0x700174A8
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[59].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[1].spn_u32
	ECU_ADDRESS 0x7001754C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017550
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017551
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017554
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017558
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017559
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[3].spn_u32
	ECU_ADDRESS 0x7001755C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017560
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017561
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017564
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017568
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017569
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[5].spn_u32
	ECU_ADDRESS 0x7001756C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017570
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017571
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017574
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017578
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017579
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[7].spn_u32
	ECU_ADDRESS 0x7001757C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017580
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017581
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017584
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017588
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017589
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[9].spn_u32
	ECU_ADDRESS 0x7001758C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017590
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017591
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017594
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017598
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017599
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[11].spn_u32
	ECU_ADDRESS 0x7001759C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700175A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700175A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700175A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700175A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700175A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700175AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700175B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700175B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700175B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700175B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700175B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700175BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700175C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700175C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700175C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700175C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700175C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700175CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700175D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700175D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700175D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700175D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700175D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700175DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700175E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700175E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700175E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700175E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700175E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[60].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[60].dtc_as
	ECU_ADDRESS 0x7001754C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[60].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700175F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700175F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700175F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700175F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700175FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700175FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017600
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017604
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017605
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017608
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x7001760C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[4].occ_u8
	ECU_ADDRESS 0x7001760D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017610
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017614
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017615
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017618
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x7001761C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[6].occ_u8
	ECU_ADDRESS 0x7001761D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017620
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017624
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017625
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017628
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x7001762C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[8].occ_u8
	ECU_ADDRESS 0x7001762D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017630
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017634
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017635
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017638
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x7001763C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[10].occ_u8
	ECU_ADDRESS 0x7001763D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017640
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017644
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017645
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017648
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x7001764C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[12].occ_u8
	ECU_ADDRESS 0x7001764D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017650
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017654
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017655
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017658
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x7001765C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[14].occ_u8
	ECU_ADDRESS 0x7001765D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017660
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017664
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017665
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017668
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x7001766C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[16].occ_u8
	ECU_ADDRESS 0x7001766D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017670
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017674
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017675
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017678
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x7001767C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[18].occ_u8
	ECU_ADDRESS 0x7001767D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017680
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017684
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017685
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017688
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x7001768C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as[20].occ_u8
	ECU_ADDRESS 0x7001768D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[61].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[61].dtc_as
	ECU_ADDRESS 0x700175F0
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[61].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017694
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017698
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017699
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[2].spn_u32
	ECU_ADDRESS 0x7001769C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700176A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700176A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700176A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700176A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700176A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700176AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700176B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700176B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700176B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700176B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700176B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700176BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700176C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700176C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700176C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700176C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700176C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700176CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700176D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700176D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700176D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700176D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700176D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700176DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700176E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700176E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700176E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700176E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700176E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700176EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700176F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700176F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700176F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700176F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700176F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700176FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017700
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017701
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017704
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017708
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017709
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[16].spn_u32
	ECU_ADDRESS 0x7001770C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017710
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017711
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017714
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017718
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017719
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[18].spn_u32
	ECU_ADDRESS 0x7001771C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017720
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017721
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017724
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017728
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017729
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[20].spn_u32
	ECU_ADDRESS 0x7001772C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017730
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017731
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[62].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[62].dtc_as
	ECU_ADDRESS 0x70017694
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[62].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017738
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x7001773C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[1].occ_u8
	ECU_ADDRESS 0x7001773D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017740
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017744
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017745
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017748
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x7001774C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[3].occ_u8
	ECU_ADDRESS 0x7001774D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017750
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017754
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017755
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017758
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x7001775C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[5].occ_u8
	ECU_ADDRESS 0x7001775D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017760
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017764
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017765
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017768
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x7001776C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[7].occ_u8
	ECU_ADDRESS 0x7001776D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017770
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017774
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017775
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017778
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x7001777C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[9].occ_u8
	ECU_ADDRESS 0x7001777D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017780
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017784
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017785
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017788
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x7001778C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[11].occ_u8
	ECU_ADDRESS 0x7001778D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017790
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017794
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017795
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017798
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x7001779C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[13].occ_u8
	ECU_ADDRESS 0x7001779D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700177A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700177A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700177A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700177A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700177AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700177AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700177B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700177B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700177B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700177B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700177BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700177BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700177C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700177C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700177C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700177C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700177CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700177CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700177D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700177D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700177D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[63].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[63].dtc_as
	ECU_ADDRESS 0x70017738
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[63].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700177DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700177E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700177E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700177E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700177E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700177E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700177EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700177F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700177F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700177F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700177F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700177F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700177FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017800
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017801
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017804
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017808
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017809
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[7].spn_u32
	ECU_ADDRESS 0x7001780C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017810
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017811
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017814
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017818
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017819
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[9].spn_u32
	ECU_ADDRESS 0x7001781C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017820
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017821
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017824
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017828
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017829
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[11].spn_u32
	ECU_ADDRESS 0x7001782C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017830
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017831
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017834
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017838
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017839
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[13].spn_u32
	ECU_ADDRESS 0x7001783C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017840
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017841
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017844
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017848
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017849
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[15].spn_u32
	ECU_ADDRESS 0x7001784C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017850
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017851
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017854
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017858
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017859
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[17].spn_u32
	ECU_ADDRESS 0x7001785C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017860
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017861
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017864
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017868
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017869
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[19].spn_u32
	ECU_ADDRESS 0x7001786C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017870
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017871
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017874
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017878
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017879
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[64].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[64].dtc_as
	ECU_ADDRESS 0x700177DC
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[64].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017880
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017884
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017885
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017888
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x7001788C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[2].occ_u8
	ECU_ADDRESS 0x7001788D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017890
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017894
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017895
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017898
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x7001789C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[4].occ_u8
	ECU_ADDRESS 0x7001789D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700178A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700178A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700178A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700178A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700178AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700178AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700178B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700178B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700178B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700178B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700178BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700178BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700178C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700178C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700178C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700178C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700178CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700178CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700178D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700178D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700178D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700178D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700178DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700178DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700178E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700178E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700178E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700178E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700178EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700178ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700178F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700178F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700178F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700178F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700178FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700178FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017900
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017904
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017905
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017908
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x7001790C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[18].occ_u8
	ECU_ADDRESS 0x7001790D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017910
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017914
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017915
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017918
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x7001791C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as[20].occ_u8
	ECU_ADDRESS 0x7001791D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[65].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[65].dtc_as
	ECU_ADDRESS 0x70017880
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[65].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017924
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017928
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017929
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[2].spn_u32
	ECU_ADDRESS 0x7001792C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017930
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017931
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017934
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017938
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017939
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[4].spn_u32
	ECU_ADDRESS 0x7001793C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017940
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017941
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017944
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017948
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017949
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[6].spn_u32
	ECU_ADDRESS 0x7001794C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017950
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017951
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017954
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017958
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017959
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[8].spn_u32
	ECU_ADDRESS 0x7001795C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017960
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017961
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017964
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017968
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017969
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[10].spn_u32
	ECU_ADDRESS 0x7001796C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017970
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017971
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017974
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017978
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017979
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[12].spn_u32
	ECU_ADDRESS 0x7001797C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017980
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017981
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017984
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017988
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017989
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[14].spn_u32
	ECU_ADDRESS 0x7001798C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017990
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017991
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017994
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017998
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017999
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[16].spn_u32
	ECU_ADDRESS 0x7001799C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700179A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700179A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700179A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700179A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700179A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700179AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700179B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700179B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700179B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700179B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700179B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700179BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700179C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700179C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[66].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[66].dtc_as
	ECU_ADDRESS 0x70017924
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[66].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700179C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700179CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700179CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700179D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700179D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700179D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700179D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700179DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700179DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700179E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700179E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700179E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700179E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700179EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700179ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700179F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700179F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700179F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700179F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700179FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700179FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017A00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017A04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017A05
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017A08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017A0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017A0D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017A10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017A14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017A15
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017A18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017A1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017A1D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017A20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017A24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017A25
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017A28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017A2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017A2D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017A30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017A34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017A35
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017A38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017A3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017A3D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017A40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017A44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017A45
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017A48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017A4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017A4D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017A50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017A54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017A55
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017A58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017A5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017A5D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017A60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017A64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017A65
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[67].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[67].dtc_as
	ECU_ADDRESS 0x700179C8
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[67].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017A6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017A70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017A71
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017A74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017A78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017A79
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017A7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017A80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017A81
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017A84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017A88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017A89
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017A8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017A90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017A91
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017A94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017A98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017A99
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017A9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017AA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017AA1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017AA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017AA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017AA9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017AAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017AB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017AB1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017AB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017AB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017AB9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017ABC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017AC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017AC1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017AC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017AC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017AC9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017ACC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017AD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017AD1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017AD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017AD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017AD9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017ADC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017AE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017AE1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017AE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017AE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017AE9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017AEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017AF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017AF1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017AF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017AF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017AF9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017AFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017B00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017B01
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017B04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017B08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017B09
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[68].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[68].dtc_as
	ECU_ADDRESS 0x70017A6C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[68].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017B10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017B14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017B15
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017B18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017B1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017B1D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017B20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017B24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017B25
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017B28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017B2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017B2D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017B30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017B34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017B35
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017B38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017B3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017B3D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017B40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017B44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017B45
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017B48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017B4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017B4D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017B50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017B54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017B55
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017B58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017B5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017B5D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017B60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017B64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017B65
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017B68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017B6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017B6D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017B70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017B74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017B75
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017B78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017B7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017B7D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017B80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017B84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017B85
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017B88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017B8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017B8D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017B90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017B94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017B95
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017B98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017B9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017B9D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017BA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017BA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017BA5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017BA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017BAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017BAD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[69].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[69].dtc_as
	ECU_ADDRESS 0x70017B10
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[69].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017BB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017BB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017BB9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017BBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017BC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017BC1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017BC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017BC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017BC9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017BCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017BD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017BD1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017BD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017BD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017BD9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017BDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017BE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017BE1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017BE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017BE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017BE9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017BEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017BF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017BF1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017BF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017BF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017BF9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017BFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017C00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017C01
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017C04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017C08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017C09
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017C0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017C10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017C11
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017C14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017C18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017C19
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017C1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017C20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017C21
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017C24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017C28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017C29
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017C2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017C30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017C31
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017C34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017C38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017C39
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017C3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017C40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017C41
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017C44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017C48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017C49
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017C4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017C50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017C51
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[70].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[70].dtc_as
	ECU_ADDRESS 0x70017BB4
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[70].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017C58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017C5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017C5D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017C60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017C64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017C65
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017C68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017C6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017C6D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017C70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017C74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017C75
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017C78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017C7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017C7D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017C80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017C84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017C85
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017C88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017C8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017C8D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017C90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017C94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017C95
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017C98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017C9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017C9D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017CA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017CA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017CA5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017CA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017CAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017CAD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017CB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017CB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017CB5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017CB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017CBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017CBD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017CC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017CC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017CC5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017CC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017CCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017CCD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017CD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017CD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017CD5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017CD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017CDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017CDD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017CE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017CE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017CE5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017CE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017CEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017CED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017CF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017CF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017CF5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[71].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[71].dtc_as
	ECU_ADDRESS 0x70017C58
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[71].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017CFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017D00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017D01
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017D04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017D08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017D09
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017D0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017D10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017D11
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017D14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017D18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017D19
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017D1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017D20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017D21
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017D24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017D28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017D29
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017D2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017D30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017D31
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017D34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017D38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017D39
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017D3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017D40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017D41
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017D44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017D48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017D49
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017D4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017D50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017D51
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017D54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017D58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017D59
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017D5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017D60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017D61
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017D64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017D68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017D69
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017D6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017D70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017D71
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017D74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017D78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017D79
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017D7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017D80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017D81
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017D84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017D88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017D89
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017D8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017D90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017D91
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017D94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017D98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017D99
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[72].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[72].dtc_as
	ECU_ADDRESS 0x70017CFC
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[72].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017DA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017DA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017DA5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017DA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70017DAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70017DAD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70017DB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70017DB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70017DB5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70017DB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70017DBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70017DBD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70017DC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70017DC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70017DC5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70017DC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70017DCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70017DCD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70017DD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70017DD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70017DD5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70017DD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70017DDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70017DDD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70017DE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70017DE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70017DE5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70017DE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70017DEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70017DED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70017DF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70017DF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70017DF5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70017DF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70017DFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70017DFD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70017E00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70017E04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70017E05
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70017E08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70017E0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70017E0D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70017E10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70017E14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70017E15
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70017E18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70017E1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70017E1D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70017E20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70017E24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70017E25
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70017E28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70017E2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70017E2D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70017E30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70017E34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70017E35
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70017E38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70017E3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70017E3D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[73].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[73].dtc_as
	ECU_ADDRESS 0x70017DA0
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[73].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70017E44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70017E48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70017E49
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[74].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70017E4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[74].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[74].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
