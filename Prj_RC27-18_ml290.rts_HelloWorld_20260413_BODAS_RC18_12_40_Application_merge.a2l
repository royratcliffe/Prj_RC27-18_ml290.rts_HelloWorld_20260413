    5 "DCU17"
    6 "MDGC1"


/end COMPU_VTAB

/begin COMPU_METHOD
    Eep_MainStates_Verb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Eep_MainStates_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Eep_MainStates_Verb
    ""
    TAB_VERB
    15
    0 "EEP_SHUTDWN_RUN"
    1 "EEP_INI_RUN"
    2 "EEP_MIGRATION_RUN"
    3 "EEP_INI_INTERNAL"
    4 "EEP_NORMAL_RUN"
    5 "EEP_BEGPD_REQUEST"
    6 "EEP_BEGPD_RUN"
    7 "EEP_ENDPD_REQUEST"
    8 "EEP_ENDPD_RUN"
    9 "EEP_PREDRV_REQUEST"
    10 "EEP_PREDRV_RUN"
    11 "EEP_FIRSTINIT_INI"
    12 "EEP_RAM_INI"
    13 "EEP_ENVRAM_INI"
    14 "EEP_REINIT_INI"


/end COMPU_VTAB

/begin COMPU_METHOD
    Eep_PostDrvState_Verb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Eep_PostDrvState_Verb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Eep_PostDrvState_Verb
    ""
    TAB_VERB
    5
    0 "EEP_POSTDRV_INI"
    1 "EEP_POSTDRV_SEARCHBLKIDX"
    2 "EEP_POSTDRV_SAVEBLK"
    3 "EEP_POSTDRV_SAVEBLK_PENDING"
    4 "EEP_POSTDRV_WAIT"


/end COMPU_VTAB

/begin COMPU_METHOD
    EGREVAPRUSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGREVAPRUSFLDP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGREVAPRUSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EGRVLVINSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGRVLVINSDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGRVLVINSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EGRVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGRVLVI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGRVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EGRVLVLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EGRVLVLPI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EGRVLVLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    EGTSwt
    ""
    RAT_FUNC
    "%10.9"
    "-"

    COEFFS 0 16384000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EGTSwt_S16
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 16384 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EMGYSHOFFIN2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EMGYSHOFFIN2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EMGYSHOFFIN2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    EMGYSTRTSWT2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EMGYSTRTSWT2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EMGYSTRTSWT2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ENADATASETID_CALPAR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENADATASETID_CALPAR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENADATASETID_CALPAR_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Energy
    ""
    RAT_FUNC
    "%6.2"
    "kJ"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Energy_J_HiRes
    ""
    RAT_FUNC
    "%6.2"
    "J"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Energy_q0p0001
    ""
    RAT_FUNC
    "%7.6"
    "kJ"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Energy_q0p001_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "kJ"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ENGCMPTMTT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGCMPTMTT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGCMPTMTT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    ENGDA_CTFLD_NUM_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ENGMIDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGMIDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGMIDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    EngN
    ""
    RAT_FUNC
    "%6.3"
    "rpm"

    COEFFS 0 2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EngN_LRes
    ""
    RAT_FUNC
    "%6.1"
    "rpm"

    COEFFS 0 0.025 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ENGOILT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGOILT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGOILT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ENGRESTRT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGRESTRT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGRESTRT_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ENGSPD_SWTENA_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENGSPD_SWTENA_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENGSPD_SWTENA_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    EnrgPerMass
    ""
    RAT_FUNC
    "%6.3"
    "MJ/Kg"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ENVP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENVP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENVP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ENVT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ENVT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ENVT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMBCA_FACSEGTIMEACC_CURX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMBCR_DTINCSTRT_CURX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMBCR_FACWEIGHTPAS_DSTX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMBCR_FACWEIGHT_DSTX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_DIAGSRC2_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_FACPLAUS_DSTX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_NUMSEGLEN_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_NUMSEG_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_PHINCOR_CURX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_PHITEMPADAPCORSIZEDSTX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCAS_PHITEMPCOR05_DSTX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMCAS_PRODCORRNVAL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCAS_PRODCORRNVAL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCAS_PRODCORRNVAL_SC_Compu
    ""
    TAB_VERB
    2
    0 "OFF"
    1 "ON"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMCAS_REFADPNTSTRENARESP_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMCAS_REFADPNTSTR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCAS_REFADPNTSTR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCAS_REFADPNTSTR_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCAS_SELNDIAGFAILRADPN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCAS_SELNDIAGFAILRADPN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCAS_SELNDIAGFAILRADPN_SC_Compu
    ""
    TAB_VERB
    2
    0 "DISAD_DIAG_FAILRADPN"
    1 "ENAD_DIAG_FAILRADPN"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMCRS_DGIPLSCORRNACTVD_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMCRS_DIAGDETAILEXTD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_DIAGDETAILEXTD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_DIAGDETAILEXTD_SC_Compu
    ""
    TAB_VERB
    3
    0 "DISABLE"
    1 "ENABLE_SIGNAL"
    2 "ENABLE_NOSIGNAL"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMCRS_DIAGSRC_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMCRS_DIAGSYNCLOST_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_DIAGSYNCLOST_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_DIAGSYNCLOST_SC_Compu
    ""
    TAB_VERB
    2
    0 "DISABLE_DIAGSYNCLOST"
    1 "ENABLE_DIAGSYNCLOST"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCRS_ENASIGLVLDIAG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_ENASIGLVLDIAG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_ENASIGLVLDIAG_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMCRS_MAXAXISPNTSTIPLSCRV_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCRS_NRENGSPDSEGPLAUS_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    EPMCRS_NUMINCOUT_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMCRS_PLSWIDTHAPPLACTVD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_PLSWIDTHAPPLACTVD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_PLSWIDTHAPPLACTVD_SC_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCRS_RESLTOTREV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_RESLTOTREV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_RESLTOTREV_SC_Compu
    ""
    TAB_VERB
    3
    0 "RESL1000"
    1 "RESL100"
    2 "RESL10"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCRS_REVSTRTCONT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_REVSTRTCONT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_REVSTRTCONT_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCRS_TIINCOUTPVBL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_TIINCOUTPVBL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_TIINCOUTPVBL_SC_Compu
    ""
    TAB_VERB
    3
    1 "TIINC"
    2 "TIINCLRES"
    3 "TIINC_TIINCLRES"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMCRS_TIINCOUT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMCRS_TIINCOUT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMCRS_TIINCOUT_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMERR_NRERRINFOARY_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMERR_NRERRINFOARY_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMERR_NRERRINFOARY_SC_Compu
    ""
    TAB_VERB
    3
    1 "small block size"
    2 "medium block size"
    3 "big block size"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMHWE_RTM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMHWE_RTM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMHWE_RTM_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_RTM"
    1 "RTM"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMRRS_IGNLOCKRELSIMDT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMRRS_IGNLOCKRELSIMDT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMRRS_IGNLOCKRELSIMDT_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMRRS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMRRS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMRRS_SY_Compu
    ""
    TAB_VERB
    3
    0 "NO_RRS"
    1 "REV"
    2 "REV_STOP"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMRRS_TITEMP_CURX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMRVSROTYMETH_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMRVSROTYMETH_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMRVSROTYMETH_SY_Compu
    ""
    TAB_VERB
    2
    0 "TOOTHPERD"
    1 "PLSTI"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPMSYN_INJRLS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMSYN_INJRLS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMSYN_INJRLS_SC_Compu
    ""
    TAB_VERB
    2
    0 "INJRLS_ALWAYS"
    1 "INJRLS_AFTERANGLE"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPMSYN_PHIINCCOR_CURX_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPMTDC_PRODCORRNVAL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPMTDC_PRODCORRNVAL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPMTDC_PRODCORRNVAL_SC_Compu
    ""
    TAB_VERB
    2
    0 "OFF"
    1 "ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_ATS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_ATS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_ATS_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_ACCESS"
    1 "ACCESS"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_CAMSFTSNSRDEACTVN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_CAMSFTSNSRDEACTVN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_CAMSFTSNSRDEACTVN_SC_Compu
    ""
    TAB_VERB
    2
    0 "CANNOT_DEACTIVATE"
    1 "BY_CALIBRATION"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_CUSTADP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_CUSTADP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_CUSTADP_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_DGIDIRCORRN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_DGIDIRCORRN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_DGIDIRCORRN_SC_Compu
    ""
    TAB_VERB
    2
    0 "DIRCORRN_OFF"
    1 "DIRCORRN_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_DGIDIRFRCD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_DGIDIRFRCD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_DGIDIRFRCD_SC_Compu
    ""
    TAB_VERB
    2
    0 "DIRFRCD_OFF"
    1 "DIRFRCD_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_DGIDYNCHG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_DGIDYNCHG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_DGIDYNCHG_SC_Compu
    ""
    TAB_VERB
    2
    0 "DYNCHG_OFF"
    1 "DYNCHG_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_DGIPLSRNG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_DGIPLSRNG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_DGIPLSRNG_SC_Compu
    ""
    TAB_VERB
    2
    0 "PLSRNG_OFF"
    1 "PLSRNG_ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_HIRESLSEGLENCAL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_HIRESLSEGLENCAL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_HIRESLSEGLENCAL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_INDCAMSFTCFG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_INDCAMSFTCFG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_INDCAMSFTCFG_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_KEEPDGISYNC_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_KEEPDGISYNC_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_KEEPDGISYNC_SC_Compu
    ""
    TAB_VERB
    2
    0 "STD"
    1 "KEEPDGISYNC"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_MEASURE_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_MEASURE_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_MEASURE_SY_Compu
    ""
    TAB_VERB
    3
    0 "NO_MP"
    1 "TEST_MP"
    2 "RAW_AG_TEST_MP"


/end COMPU_VTAB

/begin COMPU_METHOD

    EPM_NRAGEVE_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EPM_RVSROTPRED_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_RVSROTPRED_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_RVSROTPRED_SC_Compu
    ""
    TAB_VERB
    2
    0 "Deactvd"
    1 "Inct_Ti_Thd"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_SPD_CALC_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_SPD_CALC_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_SPD_CALC_SY_Compu
    ""
    TAB_VERB
    4
    0 "SPD_IN_IGNEDGE"
    1 "SPD_IN_WAITGAP"
    2 "SPD_LOW_NEG"
    3 "SPD_LOW_NEG_HIRES"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_STRTSELECT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_STRTSELECT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_STRTSELECT_SC_Compu
    ""
    TAB_VERB
    5
    0 "NO_SELECT"
    1 "SEL_StaActV_C"
    2 "SEL_StaActV_CA02"
    3 "SEL_StaActV_CA03"
    4 "SEL_StaActV_CA04"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_STRTWOCAMSFTSIGDETN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_STRTWOCAMSFTSIGDETN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_STRTWOCAMSFTSIGDETN_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_SYNCSLV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_SYNCSLV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_SYNCSLV_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_SLV_SYNC"
    1 "SLV_VIA_CAN_SYNC"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_TDCDSTCLB_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_TDCDSTCLB_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_TDCDSTCLB_SC_Compu
    ""
    TAB_VERB
    2
    0 "STANDARD"
    1 "ARRAY"


/end COMPU_VTAB

/begin COMPU_METHOD
    EPM_TIMING_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EPM_TIMING_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EPM_TIMING_SY_Compu
    ""
    TAB_VERB
    3
    0 "STD"
    1 "HE_ONEBOX"
    2 "RC_MASLV"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERCLNTVLVT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERCLNTVLVT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERCLNTVLVT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_CALCSTMILALWAYS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_CALCSTMILALWAYS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_CALCSTMILALWAYS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_CUST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_CUST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_CUST_SY_Compu
    ""
    TAB_VERB
    4
    0 "ERRLMP_RB"
    1 "ERRLMP_VAG"
    2 "ERRLMP_BMW"
    3 "ERRLMP_DAcom"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_PSPRS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_UNIFY_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_UNIFY_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_UNIFY_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ERRLMP_VLDTSTDSQ_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ERRLMP_VLDTSTDSQ_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ERRLMP_VLDTSTDSQ_SC_Compu
    ""
    TAB_VERB
    2
    0 "Not_Supported"
    1 "Vrnt_1"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_ACTVTSYNCHAINCFG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_ACTVTSYNCHAINCFG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_ACTVTSYNCHAINCFG_SC_Compu
    ""
    TAB_VERB
    3
    0 "ACTVTSYNCHAIN_NONE"
    1 "ACTVTSYNCHAIN_EBOS"
    2 "ACTVTSYNCHAIN_ESC"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_ACTVTSYNTSKCHAIN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_ACTVTSYNTSKCHAIN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_ACTVTSYNTSKCHAIN_SC_Compu
    ""
    TAB_VERB
    2
    0 "DEACTIVE"
    1 "ACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_ENAPROCGROUP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_ENAPROCGROUP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_ENAPROCGROUP_SC_Compu
    ""
    TAB_VERB
    2
    0 "DISABLED"
    1 "ENABLED"


/end COMPU_VTAB

/begin COMPU_METHOD

    ESC_NRAGEVEWCYC_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ESC_NRTSKAGEVE_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ESC_SAMPLETICALCN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SAMPLETICALCN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SAMPLETICALCN_SC_Compu
    ""
    TAB_VERB
    2
    0 "SEG_AG_BASD"
    1 "TSK_TI_STAMP_BASD"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SELNCAMSFTTSKACTVN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SELNCAMSFTTSKACTVN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SELNCAMSFTTSKACTVN_SC_Compu
    ""
    TAB_VERB
    3
    0 "NO_CAMSFTTSKACTVN"
    1 "PLAT_CAMSFTTSKACTVN"
    2 "HDP_CAMSFTTSKACTVN"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SELNMETHSYNSDL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SELNMETHSYNSDL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SELNMETHSYNSDL_SC_Compu
    ""
    TAB_VERB
    2
    0 "OS_TSK_BASD_SDL"
    1 "ESC_CNTNR_BASD_SDL"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SELNNOTSTDTISYNCNTSK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SELNNOTSTDTISYNCNTSK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SELNNOTSTDTISYNCNTSK_SC_Compu
    ""
    TAB_VERB
    2
    0 "NO_SELN"
    1 "40ms"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SELSAMPLETICFGMETHOD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SELSAMPLETICFGMETHOD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SELSAMPLETICFGMETHOD_SC_Compu
    ""
    TAB_VERB
    2
    0 "MAN_CFG_METHOD"
    1 "AUT_CFG_METHOD"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SWTSYNRTMEASMT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SWTSYNRTMEASMT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SWTSYNRTMEASMT_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ESC_SYNCTASK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ESC_SYNCTASK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ESC_SYNCTASK_SC_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD

    Eta2
    ""
    RAT_FUNC
    "%6.4"
    ""

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    ETC_Act_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETC_Act_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETC_Act_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETHIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETHIPCORETYPE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETHIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETHSWT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETHSWT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETHSWT_SC_Compu
    ""
    TAB_VERB
    3
    0 "0"
    1 "1"
    2 "2"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETHTSYN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETHTSYN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETHTSYN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETH_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETH_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETH_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    ETKS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ETKS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ETKS_SY_Compu
    ""
    TAB_VERB
    2
    0 "No ETKS"
    1 "ETKS"


/end COMPU_VTAB

/begin COMPU_METHOD

    ETS_LEAN_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETS_NSC_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETS_PFLT1_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETS_PFLT2_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETS_PHC_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    ETS_SOX_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    EVAPRDSMIXFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EVAPRDSMIXFLDP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EVAPRDSMIXFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EVAPRDSMIXFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EVAPRDSMIXFLDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EVAPRDSMIXFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EVTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EVTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EVTYP_SY_Compu
    ""
    TAB_VERB
    2
    0 "NOEV"
    1 "EV"


/end COMPU_VTAB

/begin COMPU_METHOD
    ExeCon_State_01
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ExeCon_State_01
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ExeCon_State_01
    ""
    TAB_VERB
    4
    0 "SYC_BOOT"
    1 "SYC_PROC_INIT"
    2 "SYC_PROC_EXEC"
    3 "SYC_SHUTDOWN"


/end COMPU_VTAB

/begin COMPU_METHOD
    ExeCon_State_02
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF ExeCon_State_02
    
/end COMPU_METHOD

/begin COMPU_VTAB

    ExeCon_State_02
    ""
    TAB_VERB
    7
    0 "SYC_INI"
    1 "SYC_INISYN"
    2 "SYC_INIEND"
    3 "SYC_PREDRIVE"
    4 "SYC_DRIVE"
    5 "SYC_POSTDRIVE"
    6 "SYC_POST_OS_EXIT"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHEVAPRDSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHEVAPRDSFLDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHEVAPRDSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHEVAPRDSGAST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHEVAPRDSGAST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHEVAPRDSGAST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHEVAPRUSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHEVAPRUSFLDP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHEVAPRUSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHEVAPRUSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHEVAPRUSFLDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHEVAPRUSFLDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHEVAPRUSGAST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHEVAPRUSGAST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHEVAPRUSGAST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHFLPLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHFLPLPI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHFLPLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    EXHPPFLT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF EXHPPFLT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    EXHPPFLT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Fact
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 8192 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact1
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 128 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FactLow
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1024 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_NSC
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_NSCEff
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_q0p001
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_q0p1_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "-"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Fact_VolNSC
    ""
    RAT_FUNC
    "%9.8"
    "-"

    COEFFS 0 1000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FDE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FDE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FDE_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    FlConsum_l_h
    ""
    RAT_FUNC
    "%6.4"
    "l/h"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    FlConsum_ul
    ""
    RAT_FUNC
    "%6.2"
    "ul"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FLEXPSCTRLRNR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FLEXPSCTRLRNR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FLEXPSCTRLRNR_SC_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    FLFLTDSP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FLFLTDSP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FLFLTDSP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FLOATIFRESLSELN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FLOATIFRESLSELN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FLOATIFRESLSELN_SC_Compu
    ""
    TAB_VERB
    2
    0 "Integer_calculation"
    1 "Floating_point_calculation"


/end COMPU_VTAB

/begin COMPU_METHOD
    FLXR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FLXR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FLXR_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD

    Fl_Vol_q0p05
    ""
    RAT_FUNC
    "%6.4"
    "l"

    COEFFS 0 20 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    FRARTP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FRARTP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FRARTP_SC_Compu
    ""
    TAB_VERB
    2
    0 "NO_FRARTP"
    1 "FRARTP_USED"


/end COMPU_VTAB

/begin COMPU_METHOD
    FRNM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FRNM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FRNM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FRTP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FRTP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FRTP_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FRTSYN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FRTSYN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FRTSYN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FSPDSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FSPDSFLDP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FSPDSFLDP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FUELP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FUELP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FUELP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FUELT2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FUELT2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FUELT2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    FUELT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF FUELT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    FUELT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    GBXOILP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GBXOILP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GBXOILP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    GBXOILT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GBXOILT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GBXOILT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    GDI_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GDI_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GDI_SY_Compu
    ""
    TAB_VERB
    2
    0 "GDI_NO"
    1 "GDI"


/end COMPU_VTAB

/begin COMPU_METHOD
    GLBDA_ACTRACTVN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GLBDA_ACTRACTVN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GLBDA_ACTRACTVN_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disable_Actuator_Activation"
    1 "Enable_Actuator_Activation"


/end COMPU_VTAB

/begin COMPU_METHOD

    GptaClc6_ti_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "us"

    COEFFS 0 2.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    GSSYS_TYPEEXHFLW_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPEEXHFLW_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPEEXHFLW_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD
    GSSYS_TYPPCR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF GSSYS_TYPPCR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    GSSYS_TYPPCR_SY_Compu
    ""
    TAB_VERB
    2
    1 "HESRV_SNGLFLW"
    2 "HESRV_TWFLW"


/end COMPU_VTAB

/begin COMPU_METHOD

    HCMassPerTime_q0p0000004
    ""
    RAT_FUNC
    "%9.8"
    "kg/s"

    COEFFS 0 2500000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    HEATRCORET_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HEATRCORET_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HEATRCORET_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HEM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HEM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HEM_SY_Compu
    ""
    TAB_VERB
    3
    0 "NO_HEM"
    1 "HEM_CYL"
    2 "HEM_BNK"


/end COMPU_VTAB

/begin COMPU_METHOD
    HESRV_HETYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HESRV_HETYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HESRV_HETYP_SY_Compu
    ""
    TAB_VERB
    4
    1 "HESRV_MASTERSLAVE"
    2 "HESRV_VCU"
    3 "HESRV_HCU"
    255 "HESRV_ONEBOX"


/end COMPU_VTAB

/begin COMPU_METHOD
    HEVCHGR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HEVCHGR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HEVCHGR_SY_Compu
    ""
    TAB_VERB
    5
    0 "NOCHGR"
    1 "CHGR_UHV"
    2 "CHGR_UHVLV"
    3 "CHGR_BHV"
    4 "CHGR_BHVLV"


/end COMPU_VTAB

/begin COMPU_METHOD
    HEVPLINAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HEVPLINAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HEVPLINAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HEVTYP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HEVTYP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HEVTYP_SY_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "HEVTYP_SER"
    2 "HEVTYP_SERPARL"
    3 "HEVTYP_PWRSPLT"
    4 "HEVTYP_PARL"
    5 "HEVTYP_EAD"
    6 "HEVTYP_EDCT"
    7 "HEVTYP_PARLSER"


/end COMPU_VTAB

/begin COMPU_METHOD
    HPDIFF_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HPDIFF_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HPDIFF_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HPIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HPIN_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HPIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HPOUTPRR_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HPOUTPRR_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HPOUTPRR_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HTANKP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HTANKP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HTANKP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HTANKT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HTANKT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HTANKT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HTIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HTIN_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HTIN_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HTOUT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HTOUT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HTOUT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HVACHEATPMPP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HVACHEATPMPP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HVACHEATPMPP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HVACHEATPMPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HVACHEATPMPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HVACHEATPMPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HVACSPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HVACSPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HVACSPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HWDPD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HWDPD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HWDPD_SC_Compu
    ""
    TAB_VERB
    3
    0 "HWDPD_NEUT"
    1 "HWDPD_SWNOTSEL"
    2 "HWDPD_SWSEL"


/end COMPU_VTAB

/begin COMPU_METHOD
    HYDSTORGHIPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HYDSTORGHIPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HYDSTORGHIPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HYDSTORGLOPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HYDSTORGLOPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HYDSTORGLOPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HYDSYSHIPTSEC_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HYDSYSHIPTSEC_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HYDSYSHIPTSEC_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    HYDSYSLOPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF HYDSYSLOPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    HYDSYSLOPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031SRV9NOXBIN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031SRV9NOXBIN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031SRV9NOXBIN_SC_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031SRV9VT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031SRV9VT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031SRV9VT_SC_Compu
    ""
    TAB_VERB
    2
    0 "VT_disabled"
    1 "VT_enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031SRV9VT_STORGRSTBHVR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031SRV9VT_STORGRSTBHVR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031SRV9VT_STORGRSTBHVR_SC_Compu
    ""
    TAB_VERB
    3
    1 "ENVRAM_IUMPRReset"
    2 "EEPROM_NoReset"
    3 "EEPROM_CalibrationReset"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_CVNALG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031_CVNALG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_CVNALG_SC_Compu
    ""
    TAB_VERB
    4
    1 "CVN_ALG_CRC32_DIABAS"
    2 "CVN_ALG_CRC32_SECULIBS"
    3 "CVN_ALG_SHA256_BCL"
    4 "CVN_ALG_SHA256_HSM"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_EXTCVNSTORGBHVR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031_EXTCVNSTORGBHVR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_EXTCVNSTORGBHVR_SC_Compu
    ""
    TAB_VERB
    2
    1 "PSTDRV"
    2 "RAS1s"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_OBD_CNTL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031_OBD_CNTL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_OBD_CNTL_SC_Compu
    ""
    TAB_VERB
    4
    0 "I15031_ACTIVE"
    1 "I15031_SRV_ADJUST"
    2 "I15031_INACTIVE"
    3 "I15031_NOT_EXISTING"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_PID1CVerb
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF I15031_PID1CVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_PID1CVerb
    ""
    TAB_VERB
    40
    1 "OBD II"
    2 "OBD"
    3 "OBD and OBD II"
    4 "OBD I"
    5 "No OBD"
    6 "EOBD"
    7 "EOBD and OBD II"
    8 "EOBD and OBD"
    9 "EOBD, OBD and OBD II"
    10 "JOBD"
    11 "JOBD and OBD II"
    12 "JOBD and EOBD"
    13 "JOBD, EOBD and OBD II"
    14 "OBD, EOBD and KOBD"
    15 "OBD, OBD II, EOBD and KOBD"
    17 "EMD"
    18 "EMD+"
    19 "HD OBD-C"
    20 "HD OBD"
    21 "WWH OBD"
    23 "HD EOBD-I"
    24 "HD EOBD-I N"
    25 "HD EOBD-II"
    26 "HD EOBD-II N"
    28 "OBDBr-1"
    29 "OBDBr-2"
    30 "KOBD"
    31 "IOBD I"
    32 "IOBD II"
    33 "HD EOBD-VI"
    34 "OBD, OBD II and HD OBD"
    35 "OBDBr-3"
    36 "MC EOBD-I"
    37 "MC EOBD-II"
    38 "MC COBD-I"
    39 "MC TOBD-I"
    40 "MC JOBD-I"
    41 "CN-OBD-6"
    42 "OBDBr-D"
    43 "CN-HDOBD-VI"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_PID5FVerb
    ""
    TAB_VERB
    "%6.3"
    "-"
    COMPU_TAB_REF I15031_PID5FVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_PID5FVerb
    ""
    TAB_VERB
    4
    14 "EURO IV B1"
    15 "EURO V B2"
    16 "EURO C"
    17 "EURO VI"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_SRV8_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031_SRV8_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_SRV8_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_srv9_CVN_CalcVerb
    ""
    TAB_VERB
    "%2.1"
    "-"
    COMPU_TAB_REF I15031_srv9_CVN_CalcVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_srv9_CVN_CalcVerb
    ""
    TAB_VERB
    7
    0 "NOTAVAILABLE"
    1 "CALC_START"
    2 "CALC_BUSY"
    3 "CALC_WRITE"
    4 "CALC_READY"
    5 "CALC_CLEAR"
    6 "CALC_CLEARBUSY"


/end COMPU_VTAB

/begin COMPU_METHOD
    I15031_srv9_VT_SupprRecent_CalVerb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I15031_srv9_VT_SupprRecent_CalVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I15031_srv9_VT_SupprRecent_CalVerb
    ""
    TAB_VERB
    2
    0 "OFF"
    1 "ON"


/end COMPU_VTAB

/begin COMPU_METHOD
    I27145_CANID_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I27145_CANID_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I27145_CANID_SC_Compu
    ""
    TAB_VERB
    3
    0 "WWHOBD_0"
    1 "WWHOBD_1"
    2 "WWHOBD_2"


/end COMPU_VTAB

/begin COMPU_METHOD
    I27145_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF I27145_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    I27145_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    IDLSHTDWN_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IDLSHTDWN_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IDLSHTDWN_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    IGNCL_QAG_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IGNCL_QAG_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IGNCL_QAG_SY_Compu
    ""
    TAB_VERB
    2
    1 "0.75 GradKW"
    2 "0.10 GradKW"


/end COMPU_VTAB

/begin COMPU_METHOD

    INJCRV_INJMASSPIIFACT_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMass
    ""
    RAT_FUNC
    "%6.4"
    "mg/hub"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMassCyc
    ""
    RAT_FUNC
    "%6.4"
    "mg/cyc"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMassInj
    ""
    RAT_FUNC
    "%6.4"
    "mg/inj"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMs_q0p1_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "mg/hub"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjMs_q0p2_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "mg/hub"

    COEFFS 0 5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjQnt
    ""
    RAT_FUNC
    "%6.3"
    "mm^3/hub"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjQntInj
    ""
    RAT_FUNC
    "%6.4"
    "mm^3/inj"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    INJSYS_POI1SETPOINT_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    INJSYS_POI2SETPOINT_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    INJSYS_POI3SETPOINT_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    InjTime_us
    ""
    RAT_FUNC
    "%6.3"
    "us"

    COEFFS 0 2.5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    INJVLV_ABE_ACTIVE_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJVLV_ABE_ACTIVE_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJVLV_ABE_ACTIVE_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    INJVLV_ABE_NOTACTIVE_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INJVLV_ABE_NOTACTIVE_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INJVLV_ABE_NOTACTIVE_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    INTKAIRT_INTKMNFLD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INTKAIRT_INTKMNFLD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INTKAIRT_INTKMNFLD_SC_Compu
    ""
    TAB_VERB
    3
    0 "no_signal"
    1 "sensor"
    2 "model"


/end COMPU_VTAB

/begin COMPU_METHOD
    INTKAIRT_SNSR1POS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INTKAIRT_SNSR1POS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INTKAIRT_SNSR1POS_SC_Compu
    ""
    TAB_VERB
    6
    0 "no_sensor"
    1 "IntkMnfld"
    2 "MnfldIcoDs"
    3 "ThrVlvUs"
    4 "CmprDs"
    5 "AirFltDs"


/end COMPU_VTAB

/begin COMPU_METHOD
    INTKAIRT_SNSR2POS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INTKAIRT_SNSR2POS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INTKAIRT_SNSR2POS_SC_Compu
    ""
    TAB_VERB
    6
    0 "no_sensor"
    1 "IntkMnfld"
    2 "MnfldIcoDs"
    3 "ThrVlvUs"
    4 "CmprDs"
    5 "AirFltDs"


/end COMPU_VTAB

/begin COMPU_METHOD
    INTKAIRT_SNSR3POS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INTKAIRT_SNSR3POS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INTKAIRT_SNSR3POS_SC_Compu
    ""
    TAB_VERB
    6
    0 "no_sensor"
    1 "IntkMnfld"
    2 "MnfldIcoDs"
    3 "ThrVlvUs"
    4 "CmprDs"
    5 "AirFltDs"


/end COMPU_VTAB

/begin COMPU_METHOD
    INTKAIRT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF INTKAIRT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    INTKAIRT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    IOEXTDEV_CJ260_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    IOEXTDEV_PORTEXP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IOEXTDEV_PORTEXP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IOEXTDEV_PORTEXP_SC_Compu
    ""
    TAB_VERB
    2
    0 "No_Port_Expander"
    1 "Port_Expander_I2C"


/end COMPU_VTAB

/begin COMPU_METHOD
    IPDUM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IPDUM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IPDUM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    IUMPR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IUMPR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IUMPR_SY_Compu
    ""
    TAB_VERB
    2
    0 "NO_IUMPR_ACTIVE"
    1 "IUMPR_ACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    IUMPR_VERS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF IUMPR_VERS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    IUMPR_VERS_SY_Compu
    ""
    TAB_VERB
    4
    0 "IUMPR_2005"
    1 "IUMPR_2007"
    2 "IUMPR_2009"
    3 "IUMPR_2016"


/end COMPU_VTAB

/begin COMPU_METHOD
    J1939NM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF J1939NM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    J1939NM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    J1939RM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF J1939RM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    J1939RM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    J1939TP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF J1939TP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    J1939TP_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Kd_pRail2Q_1
    ""
    RAT_FUNC
    "%7.6"
    "mm^3/s/hPa"

    COEFFS 0 40960 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kd_Prc_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "%"

    COEFFS 0 8000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ki_pRail2Q_1
    ""
    RAT_FUNC
    "%7.6"
    "mm^3/s^2/hPa"

    COEFFS 0 10737.41824 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    KLINE_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF KLINE_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    KLINE_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Kp_LmbdRec2InjMass_1
    ""
    RAT_FUNC
    "%6.4"
    "mg/stroke"

    COEFFS 0 81.92 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Kp_pRail2Q_1
    ""
    RAT_FUNC
    "%7.6"
    "mm^3/s/hPa"

    COEFFS 0 81920 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    L9779_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF L9779_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    L9779_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    L9959_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    L9966_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    lambda
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    lambdaRec
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    lambdaRecVal
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    LDCOM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LDCOM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LDCOM_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Length
    ""
    RAT_FUNC
    "%6.2"
    "m"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    LengthMm
    ""
    RAT_FUNC
    "%6.2"
    "mm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    LINIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LINIPCORETYPE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LINIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    LIN_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LIN_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LIN_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    LSM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LSM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LSM_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    LSU_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF LSU_CT_SENSORS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    LSU_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    5
    0 "0"
    1 "1"
    2 "2"
    3 "3"
    4 "4"


/end COMPU_VTAB

/begin COMPU_METHOD
    MDG1CPUDEVICE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MDG1CPUDEVICE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MDG1CPUDEVICE_SC_Compu
    ""
    TAB_VERB
    9
    0 "None"
    1 "Device1"
    2 "Device2"
    3 "Device3"
    4 "Device4"
    5 "Device5"
    13 "Device3+"
    14 "Device4+"
    15 "Device5+"


/end COMPU_VTAB

/begin COMPU_METHOD
    MDG1CPUSTEP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MDG1CPUSTEP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MDG1CPUSTEP_SC_Compu
    ""
    TAB_VERB
    10
    0 "None"
    1 "1"
    2 "2"
    110 "110"
    120 "120"
    130 "130"
    140 "140"
    210 "210"
    220 "220"
    230 "230"


/end COMPU_VTAB

/begin COMPU_METHOD
    MDG1CPUVENDOR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MDG1CPUVENDOR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MDG1CPUVENDOR_SC_Compu
    ""
    TAB_VERB
    4
    0 "None"
    1 "IFX"
    2 "JDP"
    3 "ST"


/end COMPU_VTAB

/begin COMPU_METHOD

    md_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "Nm"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MEM_CENDIAGACTVD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MEM_CENDIAGACTVD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MEM_CENDIAGACTVD_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MEM_DIAGACTVDEXTD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MEM_DIAGACTVDEXTD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MEM_DIAGACTVDEXTD_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MILLMP_ENGSTRTWITH2SECCDN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MILLMP_ENGSTRTWITH2SECCDN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MILLMP_ENGSTRTWITH2SECCDN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCCom_stCheckState_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCCom_stCheckState_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCCom_stCheckState_Compu
    ""
    TAB_VERB
    8
    0 "MOCCOM_CO_COR_IN_TIME_AND_VALUE_1"
    1 "MOCCOM_CO_COR_IN_TIME_AND_VALUE_2"
    2 "MOCCOM_CO_TOO_EARLY"
    3 "MOCCOM_CO_COR_IN_TIME_AND_VALUE_3"
    4 "MOCCOM_CO_TOO_LATE"
    5 "MOCCOM_CO_COR_IN_TIME_AND_VALUE_4A"
    6 "MOCCOM_CO_COR_IN_TIME_AND_VALUE_4B"
    7 "MOCCOM_CO_COR_IN_TIME_INC_IN_VALUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCCom_stComState_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCCom_stComState_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCCom_stComState_Compu
    ""
    TAB_VERB
    3
    0 "MOCCOM_CO_SYNCHRONIZING"
    1 "MOCCOM_CO_RECEIVING_QUERY"
    2 "MOCCOM_CO_SENDING_RESP"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCCPU_IT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCCPU_IT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCCPU_IT_SY_Compu
    ""
    TAB_VERB
    7
    0 "CHISTE"
    1 "FIT"
    2 "OTCG"
    3 "CHISTEundOTCG"
    4 "FITundOTCG"
    5 "Lock-Step"
    6 "HW_CMPBL_SOLN"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCFC_GTMCLKMON_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCFC_GTMCLKMON_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCFC_GTMCLKMON_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCFC_GTMCONNTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCFC_GTMCONNTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCFC_GTMCONNTYP_SC_Compu
    ""
    TAB_VERB
    2
    0 "PORT"
    1 "AUX_IN"


/end COMPU_VTAB

/begin COMPU_METHOD

    MOCFC_NRCYCBLK_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    MOCFC_NRFASTCYCBLK_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MOCFC_POSTBLDCHKS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCFC_POSTBLDCHKS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCFC_POSTBLDCHKS_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCFC_SCCERRREACTN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCFC_SCCERRREACTN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCFC_SCCERRREACTN_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disable"
    1 "Enable"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_ABESHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_ABESHTOFFPAHTESTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_ABESHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_CANSHOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_CANSHOFFPAHTESTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_CANSHOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_FRSHOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_FRSHOFFPAHTESTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_FRSHOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_HWLAYOUT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_HWLAYOUT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_HWLAYOUT_SC_Compu
    ""
    TAB_VERB
    2
    1 "SOLUTION1"
    2 "SOLUTION2"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_MCUINJSHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_MCUINJSHTOFFPAHTESTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_MCUINJSHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MOCMM_NROKRESP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_NROKRESP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_NROKRESP_SC_Compu
    ""
    TAB_VERB
    4
    0 "NO"
    1 "ONE"
    2 "TWO"
    3 "THREE"


/end COMPU_VTAB

/begin COMPU_METHOD

    MOCMM_NRTRCV_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MOCMM_UCHIP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MOCMM_UCHIP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MOCMM_UCHIP_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stCheckStateCtrlline_mp_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stCheckStateCtrlline_mp_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stCheckStateCtrlline_mp_Compu
    ""
    TAB_VERB
    15
    0 "-"
    1 "MOCSOP_CO_OUT_OF_DRIVE"
    2 "MOCSOP_CO_POSITIVE_TEST_PREP"
    3 "MOCSOP_CO_POSITIVE_TEST_DIA"
    4 "MOCSOP_CO_WDA_TEST_PREP"
    5 "MOCSOP_CO_WDA_TEST_DIA"
    6 "MOCSOP_CO_ERRPIN_TEST_PREP"
    7 "MOCSOP_CO_ERRPIN_TEST_DIA"
    8 "MOCSOP_CO_CTRL_LINES_TEST_PREP"
    9 "MOCSOP_CO_CTRL_LINES_TEST_DIA"
    10 "MOCSOP_CO_OVERVOLTAGE_TEST_PREP"
    11 "MOCSOP_CO_OVERVOLTAGE_TEST_DIA"
    12 "MOCSOP_CO_ERR_CHECK"
    13 "MOCSOP_CO_ERR_REACTION"
    14 "MOCSOP_CO_TO_MOCCOM"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stCtrlLineErrReactn_C_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stCtrlLineErrReactn_C_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stCtrlLineErrReactn_C_Compu
    ""
    TAB_VERB
    2
    1 "MOCSOP_CO_REACTN_ICO"
    2 "MOCSOP_CO_REACTN_RESETLOOP"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stEmmStateIFX_MP_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stEmmStateIFX_MP_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stEmmStateIFX_MP_Compu
    ""
    TAB_VERB
    4
    0 "SSM_START"
    1 "SSM_RUN"
    2 "SSM_FAULT"
    32 "STATE_ERROR"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stErrPin_MP_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stErrPin_MP_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stErrPin_MP_Compu
    ""
    TAB_VERB
    2
    0 "ERRPIN_ACTIVE"
    1 "ERRPIN_NOT_ACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stErrReactn_CA_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stErrReactn_CA_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stErrReactn_CA_Compu
    ""
    TAB_VERB
    3
    0 "MOCSOP_CO_REACTN_NORMAL_RUN"
    1 "MOCSOP_CO_REACTN_ICO"
    2 "MOCSOP_CO_REACTN_RESETLOOP"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoCSOP_stOVErrReactn_C_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoCSOP_stOVErrReactn_C_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoCSOP_stOVErrReactn_C_Compu
    ""
    TAB_VERB
    2
    1 "MOCSOP_CO_REACTN_ICO"
    2 "MOCSOP_CO_REACTN_RESETLOOP"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoExe_Co_PFC_ID_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoExe_Co_PFC_ID_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoExe_Co_PFC_ID_Compu
    ""
    TAB_VERB
    35
    0 "-"
    16777471 "MOCEMM_CO_REQERRPIN_ID_HW"
    16777217 "MOCEMM_CO_REQERRPIN_ID_MOCMEM"
    16777216 "MOCEMM_CO_REQERRPIN_ID_MOCCOM"
    16777218 "MOCEMM_CO_REQERRPIN_ID_MOCSOP"
    16777225 "MOCEMM_CO_REQERRPIN_ID_MOCADC"
    16777220 "MOCEMM_CO_REQERRPIN_ID_MOFWDA"
    16777219 "MOCEMM_CO_REQERRPIN_ID_MOCEMM"
    16777221 "MOCEMM_CO_REQERRPIN_ID_OCWDATEST"
    16777222 "MOCEMM_CO_REQERRPIN_ID_SWSHRL2"
    16777223 "MOCEMM_CO_REQERRPIN_ID_MOCGTM"
    16777224 "MOCEMM_CO_REQERRPIN_ID_MOCSCC"
    16777226 "MOCEMM_CO_REQERRPIN_ID_MOCIWDH"
    15 "MO_GLBL_PROC_CORE1_10MS_NR1_PFC_ID"
    20 "MO_GLBL_PROC_MANYCORE_CORE1_10MS_NR1_PFC_ID"
    21 "MOCCOM_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    17 "MOCCPU_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    9 "MOCEMM_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    13 "MOCGTM_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    18 "MOCIWDH_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    4 "MOCMEM_CO_CHKCSA_PROC_CORE1_10MS_NR1_PFC_ID"
    11 "MOCMEM_CO_CHKRAM_PROC_CORE1_10MS_NR1_PFC_ID"
    12 "MOCMEM_CO_CHKROM_PROC_CORE1_10MS_NR1_PFC_ID"
    3 "MOCMEM_CO_CHKSTCK_PROC_CORE1_10MS_NR1_PFC_ID"
    14 "MOCMEM_CO_ERRHDL_PROC_CORE1_10MS_NR1_PFC_ID"
    19 "MOCPFC_CO_IWDH_PROC_CORE1_10MS_NR1_PFC_ID"
    16 "MOCPFC_CO_MANYCORE_PROC_CORE1_10MS_NR1_PFC_ID"
    10 "MOCSCC_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    22 "MOCSOP_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    8 "MOCSOP_CO_PROC_10MS_CORE1_10MS_NR1_PFC_ID"
    1 "MOEXE_CO_TASK_CORE1_TASK10MS_NR1_PFC_ID"
    5 "MOEXE_RBR_SLOTA_PROC_CORE1_10MS_NR1_PFC_ID"
    6 "MOFVAR_POSTBLDSEL_PROC_CORE1_10MS_NR1_PFC_ID"
    7 "MOFWDA_CO_PROC_CORE1_10MS_NR1_PFC_ID"
    2 "MOSYSCTRL_CO_PROC_CORE1_10MS_NR1_PFC_ID"


/end COMPU_VTAB

/begin COMPU_METHOD

    Molmass
    ""
    RAT_FUNC
    "%6.4"
    "g/mol"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Moment_Inertia
    ""
    RAT_FUNC
    "%6.4"
    "kg * m^2"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MoXEMM_HwLTErrorSimnCode_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoXEMM_HwLTErrorSimnCode_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoXEMM_HwLTErrorSimnCode_VERB
    ""
    TAB_VERB
    12
    0 "MoXEMM_NO_ERROR"
    1 "MoXEMMHwLTMCUFW"
    2 "MoXEMMHwLTStbySMUAlvTest"
    3 "MoXEMMHwLTMonBIST"
    4 "MoXEMMHwLTRegMonTest"
    5 "MoXEMMHwLTTempSens"
    6 "MoXEMMHwLTUCBCfg"
    7 "RESERVED_7"
    8 "RESERVED_8"
    9 "MoXEMMHwLTMBIST"
    10 "MoXEMMHwLTLBIST"
    65535 "MoXEMM_CLR_ERROR"


/end COMPU_VTAB

/begin COMPU_METHOD
    MoXEMM_SMUErrorSimnCode_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MoXEMM_SMUErrorSimnCode_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MoXEMM_SMUErrorSimnCode_VERB
    ""
    TAB_VERB
    450
    0 "MoXEMM_NO_ERROR"
    1 "MoXEMM_SMU_ALM_0_0"
    2 "MoXEMM_SMU_ALM_0_1"
    3 "MoXEMM_SMU_ALM_0_2"
    4 "MoXEMM_reserved_0_3"
    5 "MoXEMM_SMU_ALM_0_4"
    6 "MoXEMM_SMU_ALM_0_5"
    7 "MoXEMM_reserved_0_6"
    8 "MoXEMM_SMU_ALM_0_7"
    9 "MoXEMM_SMU_ALM_0_8"
    10 "MoXEMM_reserved_0_9"
    11 "MoXEMM_SMU_ALM_0_10"
    12 "MoXEMM_SMU_ALM_0_11"
    13 "MoXEMM_reserved_0_12"
    14 "MoXEMM_SMU_ALM_0_13"
    15 "MoXEMM_SMU_ALM_0_14"
    16 "MoXEMM_reserved_0_15"
    17 "MoXEMM_reserved_0_16"
    18 "MoXEMM_reserved_0_17"
    19 "MoXEMM_reserved_0_18"
    20 "MoXEMM_reserved_0_19"
    21 "MoXEMM_reserved_0_20"
    22 "MoXEMM_reserved_0_21"
    23 "MoXEMM_SMU_ALM_0_22"
    24 "MoXEMM_SMU_ALM_0_23"
    25 "MoXEMM_reserved_0_24"
    26 "MoXEMM_reserved_0_25"
    27 "MoXEMM_reserved_0_26"
    28 "MoXEMM_reserved_0_27"
    29 "MoXEMM_reserved_0_28"
    30 "MoXEMM_reserved_0_29"
    31 "MoXEMM_reserved_0_30"
    32 "MoXEMM_reserved_0_31"
    33 "MoXEMM_SMU_ALM_1_0"
    34 "MoXEMM_SMU_ALM_1_1"
    35 "MoXEMM_SMU_ALM_1_2"
    36 "MoXEMM_reserved_1_3"
    37 "MoXEMM_SMU_ALM_1_4"
    38 "MoXEMM_SMU_ALM_1_5"
    39 "MoXEMM_reserved_1_6"
    40 "MoXEMM_SMU_ALM_1_7"
    41 "MoXEMM_SMU_ALM_1_8"
    42 "MoXEMM_reserved_1_9"
    43 "MoXEMM_SMU_ALM_1_10"
    44 "MoXEMM_SMU_ALM_1_11"
    45 "MoXEMM_reserved_1_12"
    46 "MoXEMM_SMU_ALM_1_13"
    47 "MoXEMM_SMU_ALM_1_14"
    48 "MoXEMM_reserved_1_15"
    49 "MoXEMM_reserved_1_16"
    50 "MoXEMM_reserved_1_17"
    51 "MoXEMM_reserved_1_18"
    52 "MoXEMM_reserved_1_19"
    53 "MoXEMM_reserved_1_20"
    54 "MoXEMM_reserved_1_21"
    55 "MoXEMM_SMU_ALM_1_22"
    56 "MoXEMM_SMU_ALM_1_23"
    57 "MoXEMM_reserved_1_24"
    58 "MoXEMM_reserved_1_25"
    59 "MoXEMM_reserved_1_26"
    60 "MoXEMM_reserved_1_27"
    61 "MoXEMM_reserved_1_28"
    62 "MoXEMM_reserved_1_29"
    63 "MoXEMM_reserved_1_30"
    64 "MoXEMM_reserved_1_31"
    65 "MoXEMM_reserved_2_0"
    66 "MoXEMM_SMU_ALM_2_1"
    67 "MoXEMM_SMU_ALM_2_2"
    68 "MoXEMM_reserved_2_3"
    69 "MoXEMM_SMU_ALM_2_4"
    70 "MoXEMM_SMU_ALM_2_5"
    71 "MoXEMM_reserved_2_6"
    72 "MoXEMM_SMU_ALM_2_7"
    73 "MoXEMM_SMU_ALM_2_8"
    74 "MoXEMM_reserved_2_9"
    75 "MoXEMM_SMU_ALM_2_10"
    76 "MoXEMM_SMU_ALM_2_11"
    77 "MoXEMM_reserved_2_12"
    78 "MoXEMM_SMU_ALM_2_13"
    79 "MoXEMM_SMU_ALM_2_14"
    80 "MoXEMM_reserved_2_15"
    81 "MoXEMM_reserved_2_16"
    82 "MoXEMM_reserved_2_17"
    83 "MoXEMM_reserved_2_18"
    84 "MoXEMM_reserved_2_19"
    85 "MoXEMM_reserved_2_20"
    86 "MoXEMM_reserved_2_21"
    87 "MoXEMM_SMU_ALM_2_22"
    88 "MoXEMM_SMU_ALM_2_23"
    89 "MoXEMM_reserved_2_24"
    90 "MoXEMM_reserved_2_25"
    91 "MoXEMM_reserved_2_26"
    92 "MoXEMM_reserved_2_27"
    93 "MoXEMM_reserved_2_28"
    94 "MoXEMM_reserved_2_29"
    95 "MoXEMM_reserved_2_30"
    96 "MoXEMM_reserved_2_31"
    97 "MoXEMM_reserved_3_0"
    98 "MoXEMM_SMU_ALM_3_1"
    99 "MoXEMM_SMU_ALM_3_2"
    100 "MoXEMM_reserved_3_3"
    101 "MoXEMM_SMU_ALM_3_4"
    102 "MoXEMM_SMU_ALM_3_5"
    103 "MoXEMM_reserved_3_6"
    104 "MoXEMM_SMU_ALM_3_7"
    105 "MoXEMM_SMU_ALM_3_8"
    106 "MoXEMM_reserved_3_9"
    107 "MoXEMM_SMU_ALM_3_10"
    108 "MoXEMM_SMU_ALM_3_11"
    109 "MoXEMM_reserved_3_12"
    110 "MoXEMM_SMU_ALM_3_13"
    111 "MoXEMM_SMU_ALM_3_14"
    112 "MoXEMM_reserved_3_15"
    113 "MoXEMM_reserved_3_16"
    114 "MoXEMM_reserved_3_17"
    115 "MoXEMM_reserved_3_18"
    116 "MoXEMM_reserved_3_19"
    117 "MoXEMM_reserved_3_20"
    118 "MoXEMM_reserved_3_21"
    119 "MoXEMM_SMU_ALM_3_22"
    120 "MoXEMM_SMU_ALM_3_23"
    121 "MoXEMM_reserved_3_24"
    122 "MoXEMM_reserved_3_25"
    123 "MoXEMM_reserved_3_26"
    124 "MoXEMM_reserved_3_27"
    125 "MoXEMM_reserved_3_28"
    126 "MoXEMM_reserved_3_29"
    127 "MoXEMM_reserved_3_30"
    128 "MoXEMM_reserved_3_31"
    129 "MoXEMM_reserved_4_0"
    130 "MoXEMM_reserved_4_1"
    131 "MoXEMM_reserved_4_2"
    132 "MoXEMM_reserved_4_3"
    133 "MoXEMM_reserved_4_4"
    134 "MoXEMM_reserved_4_5"
    135 "MoXEMM_reserved_4_6"
    136 "MoXEMM_reserved_4_7"
    137 "MoXEMM_reserved_4_8"
    138 "MoXEMM_reserved_4_9"
    139 "MoXEMM_reserved_4_10"
    140 "MoXEMM_reserved_4_11"
    141 "MoXEMM_reserved_4_12"
    142 "MoXEMM_reserved_4_13"
    143 "MoXEMM_reserved_4_14"
    144 "MoXEMM_reserved_4_15"
    145 "MoXEMM_reserved_4_16"
    146 "MoXEMM_reserved_4_17"
    147 "MoXEMM_reserved_4_18"
    148 "MoXEMM_reserved_4_19"
    149 "MoXEMM_reserved_4_20"
    150 "MoXEMM_reserved_4_21"
    151 "MoXEMM_reserved_4_22"
    152 "MoXEMM_reserved_4_23"
    153 "MoXEMM_reserved_4_24"
    154 "MoXEMM_reserved_4_25"
    155 "MoXEMM_reserved_4_26"
    156 "MoXEMM_reserved_4_27"
    157 "MoXEMM_reserved_4_28"
    158 "MoXEMM_reserved_4_29"
    159 "MoXEMM_reserved_4_30"
    160 "MoXEMM_reserved_4_31"
    161 "MoXEMM_reserved_5_0"
    162 "MoXEMM_reserved_5_1"
    163 "MoXEMM_reserved_5_2"
    164 "MoXEMM_reserved_5_3"
    165 "MoXEMM_reserved_5_4"
    166 "MoXEMM_reserved_5_5"
    167 "MoXEMM_reserved_5_6"
    168 "MoXEMM_reserved_5_7"
    169 "MoXEMM_reserved_5_8"
    170 "MoXEMM_reserved_5_9"
    171 "MoXEMM_reserved_5_10"
    172 "MoXEMM_reserved_5_11"
    173 "MoXEMM_reserved_5_12"
    174 "MoXEMM_reserved_5_13"
    175 "MoXEMM_reserved_5_14"
    176 "MoXEMM_reserved_5_15"
    177 "MoXEMM_reserved_5_16"
    178 "MoXEMM_reserved_5_17"
    179 "MoXEMM_reserved_5_18"
    180 "MoXEMM_reserved_5_19"
    181 "MoXEMM_reserved_5_20"
    182 "MoXEMM_reserved_5_21"
    183 "MoXEMM_reserved_5_22"
    184 "MoXEMM_reserved_5_23"
    185 "MoXEMM_reserved_5_24"
    186 "MoXEMM_reserved_5_25"
    187 "MoXEMM_reserved_5_26"
    188 "MoXEMM_reserved_5_27"
    189 "MoXEMM_reserved_5_28"
    190 "MoXEMM_reserved_5_29"
    191 "MoXEMM_reserved_5_30"
    192 "MoXEMM_reserved_5_31"
    193 "MoXEMM_SMU_ALM_6_0"
    194 "MoXEMM_reserved_6_1"
    195 "MoXEMM_SMU_ALM_6_2"
    196 "MoXEMM_reserved_6_3"
    197 "MoXEMM_SMU_ALM_6_4"
    198 "MoXEMM_SMU_ALM_6_5"
    199 "MoXEMM_reserved_6_6"
    200 "MoXEMM_SMU_ALM_6_7"
    201 "MoXEMM_SMU_ALM_6_8"
    202 "MoXEMM_reserved_6_9"
    203 "MoXEMM_reserved_6_10"
    204 "MoXEMM_SMU_ALM_6_11"
    205 "MoXEMM_SMU_ALM_6_12"
    206 "MoXEMM_reserved_6_13"
    207 "MoXEMM_SMU_ALM_6_14"
    208 "MoXEMM_SMU_ALM_6_15"
    209 "MoXEMM_reserved_6_16"
    210 "MoXEMM_SMU_ALM_6_17"
    211 "MoXEMM_SMU_ALM_6_18"
    212 "MoXEMM_reserved_6_19"
    213 "MoXEMM_SMU_ALM_6_20"
    214 "MoXEMM_SMU_ALM_6_21"
    215 "MoXEMM_reserved_6_22"
    216 "MoXEMM_reserved_6_23"
    217 "MoXEMM_reserved_6_24"
    218 "MoXEMM_SMU_ALM_6_25"
    219 "MoXEMM_reserved_6_26"
    220 "MoXEMM_reserved_6_27"
    221 "MoXEMM_reserved_6_28"
    222 "MoXEMM_reserved_6_29"
    223 "MoXEMM_reserved_6_30"
    224 "MoXEMM_reserved_6_31"
    225 "MoXEMM_reserved_7_0"
    226 "MoXEMM_SMU_ALM_7_1"
    227 "MoXEMM_SMU_ALM_7_2"
    228 "MoXEMM_reserved_7_3"
    229 "MoXEMM_reserved_7_4"
    230 "MoXEMM_reserved_7_5"
    231 "MoXEMM_reserved_7_6"
    232 "MoXEMM_reserved_7_7"
    233 "MoXEMM_reserved_7_8"
    234 "MoXEMM_reserved_7_9"
    235 "MoXEMM_reserved_7_10"
    236 "MoXEMM_reserved_7_11"
    237 "MoXEMM_SMU_ALM_7_12"
    238 "MoXEMM_SMU_ALM_7_13"
    239 "MoXEMM_SMU_ALM_7_14"
    240 "MoXEMM_SMU_ALM_7_15"
    241 "MoXEMM_SMU_ALM_7_16"
    242 "MoXEMM_SMU_ALM_7_17"
    243 "MoXEMM_reserved_7_18"
    244 "MoXEMM_reserved_7_19"
    245 "MoXEMM_SMU_ALM_7_20"
    246 "MoXEMM_reserved_7_21"
    247 "MoXEMM_reserved_7_22"
    248 "MoXEMM_reserved_7_23"
    249 "MoXEMM_reserved_7_24"
    250 "MoXEMM_SMU_ALM_7_25"
    251 "MoXEMM_SMU_ALM_7_26"
    252 "MoXEMM_reserved_7_27"
    253 "MoXEMM_SMU_ALM_7_28"
    254 "MoXEMM_SMU_ALM_7_29"
    255 "MoXEMM_SMU_ALM_7_30"
    256 "MoXEMM_SMU_ALM_7_31"
    257 "MoXEMM_SMU_ALM_8_0"
    258 "MoXEMM_SMU_ALM_8_1"
    259 "MoXEMM_SMU_ALM_8_2"
    260 "MoXEMM_SMU_ALM_8_3"
    261 "MoXEMM_SMU_ALM_8_4"
    262 "MoXEMM_reserved_8_5"
    263 "MoXEMM_reserved_8_6"
    264 "MoXEMM_reserved_8_7"
    265 "MoXEMM_SMU_ALM_8_8"
    266 "MoXEMM_SMU_ALM_8_9"
    267 "MoXEMM_SMU_ALM_8_10"
    268 "MoXEMM_SMU_ALM_8_11"
    269 "MoXEMM_SMU_ALM_8_12"
    270 "MoXEMM_SMU_ALM_8_13"
    271 "MoXEMM_reserved_8_14"
    272 "MoXEMM_reserved_8_15"
    273 "MoXEMM_SMU_ALM_8_16"
    274 "MoXEMM_reserved_8_17"
    275 "MoXEMM_SMU_ALM_8_18"
    276 "MoXEMM_reserved_8_19"
    277 "MoXEMM_reserved_8_20"
    278 "MoXEMM_reserved_8_21"
    279 "MoXEMM_reserved_8_22"
    280 "MoXEMM_reserved_8_23"
    281 "MoXEMM_reserved_8_24"
    282 "MoXEMM_reserved_8_25"
    283 "MoXEMM_reserved_8_26"
    284 "MoXEMM_reserved_8_27"
    285 "MoXEMM_reserved_8_28"
    286 "MoXEMM_reserved_8_29"
    287 "MoXEMM_SMU_ALM_8_30"
    288 "MoXEMM_SMU_ALM_8_31"
    289 "MoXEMM_SMU_ALM_9_0"
    290 "MoXEMM_SMU_ALM_9_1"
    291 "MoXEMM_reserved_9_2"
    292 "MoXEMM_SMU_ALM_9_3"
    293 "MoXEMM_reserved_9_4"
    294 "MoXEMM_reserved_9_5"
    295 "MoXEMM_reserved_9_6"
    296 "MoXEMM_reserved_9_7"
    297 "MoXEMM_reserved_9_8"
    298 "MoXEMM_reserved_9_9"
    299 "MoXEMM_reserved_9_10"
    300 "MoXEMM_reserved_9_11"
    301 "MoXEMM_reserved_9_12"
    302 "MoXEMM_reserved_9_13"
    303 "MoXEMM_reserved_9_14"
    304 "MoXEMM_SMU_ALM_9_15"
    305 "MoXEMM_reserved_9_16"
    306 "MoXEMM_reserved_9_17"
    307 "MoXEMM_reserved_9_18"
    308 "MoXEMM_reserved_9_19"
    309 "MoXEMM_reserved_9_20"
    310 "MoXEMM_reserved_9_21"
    311 "MoXEMM_reserved_9_22"
    312 "MoXEMM_reserved_9_23"
    313 "MoXEMM_reserved_9_24"
    314 "MoXEMM_reserved_9_25"
    315 "MoXEMM_reserved_9_26"
    316 "MoXEMM_reserved_9_27"
    317 "MoXEMM_reserved_9_28"
    318 "MoXEMM_reserved_9_29"
    319 "MoXEMM_reserved_9_30"
    320 "MoXEMM_reserved_9_31"
    321 "MoXEMM_reserved_10_0"
    322 "MoXEMM_reserved_10_1"
    323 "MoXEMM_reserved_10_2"
    324 "MoXEMM_reserved_10_3"
    325 "MoXEMM_reserved_10_4"
    326 "MoXEMM_reserved_10_5"
    327 "MoXEMM_reserved_10_6"
    328 "MoXEMM_reserved_10_7"
    329 "MoXEMM_reserved_10_8"
    330 "MoXEMM_reserved_10_9"
    331 "MoXEMM_reserved_10_10"
    332 "MoXEMM_reserved_10_11"
    333 "MoXEMM_reserved_10_12"
    334 "MoXEMM_reserved_10_13"
    335 "MoXEMM_reserved_10_14"
    336 "MoXEMM_reserved_10_15"
    337 "MoXEMM_SMU_ALM_10_16"
    338 "MoXEMM_SMU_ALM_10_17"
    339 "MoXEMM_reserved_10_18"
    340 "MoXEMM_reserved_10_19"
    341 "MoXEMM_reserved_10_20"
    342 "MoXEMM_SMU_ALM_10_21"
    343 "MoXEMM_reserved_10_22"
    344 "MoXEMM_reserved_10_23"
    345 "MoXEMM_reserved_10_24"
    346 "MoXEMM_reserved_10_25"
    347 "MoXEMM_reserved_10_26"
    348 "MoXEMM_reserved_10_27"
    349 "MoXEMM_reserved_10_28"
    350 "MoXEMM_reserved_10_29"
    351 "MoXEMM_reserved_10_30"
    352 "MoXEMM_reserved_10_31"
    353 "MoXEMM_SMU_ALM_11_0"
    354 "MoXEMM_SMU_ALM_11_1"
    355 "MoXEMM_SMU_ALM_11_2"
    356 "MoXEMM_SMU_ALM_11_3"
    357 "MoXEMM_SMU_ALM_11_4"
    358 "MoXEMM_SMU_ALM_11_5"
    359 "MoXEMM_reserved_11_6"
    360 "MoXEMM_reserved_11_7"
    361 "MoXEMM_SMU_ALM_11_8"
    362 "MoXEMM_SMU_ALM_11_9"
    363 "MoXEMM_reserved_11_10"
    364 "MoXEMM_reserved_11_11"
    365 "MoXEMM_reserved_11_12"
    366 "MoXEMM_reserved_11_13"
    367 "MoXEMM_reserved_11_14"
    368 "MoXEMM_reserved_11_15"
    369 "MoXEMM_reserved_11_16"
    370 "MoXEMM_reserved_11_17"
    371 "MoXEMM_reserved_11_18"
    372 "MoXEMM_reserved_11_19"
    373 "MoXEMM_reserved_11_20"
    374 "MoXEMM_reserved_11_21"
    375 "MoXEMM_reserved_11_22"
    376 "MoXEMM_reserved_11_23"
    377 "MoXEMM_reserved_11_24"
    378 "MoXEMM_reserved_11_25"
    379 "MoXEMM_reserved_11_26"
    380 "MoXEMM_reserved_11_27"
    381 "MoXEMM_reserved_11_28"
    382 "MoXEMM_reserved_11_29"
    383 "MoXEMM_reserved_11_30"
    384 "MoXEMM_reserved_11_31"
    641 "MoXEMM_reserved_20_0"
    642 "MoXEMM_reserved_20_1"
    643 "MoXEMM_reserved_20_2"
    644 "MoXEMM_reserved_20_3"
    645 "MoXEMM_reserved_20_4"
    646 "MoXEMM_reserved_20_5"
    647 "MoXEMM_reserved_20_6"
    648 "MoXEMM_reserved_20_7"
    649 "MoXEMM_reserved_20_8"
    650 "MoXEMM_reserved_20_9"
    651 "MoXEMM_reserved_20_10"
    652 "MoXEMM_reserved_20_11"
    653 "MoXEMM_reserved_20_12"
    654 "MoXEMM_reserved_20_13"
    655 "MoXEMM_reserved_20_14"
    656 "MoXEMM_reserved_20_15"
    657 "MoXEMM_reserved_20_16"
    658 "MoXEMM_reserved_20_17"
    659 "MoXEMM_reserved_20_18"
    660 "MoXEMM_reserved_20_19"
    661 "MoXEMM_reserved_20_20"
    662 "MoXEMM_reserved_20_21"
    663 "MoXEMM_reserved_20_22"
    664 "MoXEMM_reserved_20_23"
    665 "MoXEMM_reserved_20_24"
    666 "MoXEMM_reserved_20_25"
    667 "MoXEMM_reserved_20_26"
    668 "MoXEMM_reserved_20_27"
    669 "MoXEMM_reserved_20_28"
    670 "MoXEMM_reserved_20_29"
    671 "MoXEMM_reserved_20_30"
    672 "MoXEMM_reserved_20_31"
    673 "MoXEMM_SMU_ALM_21_0"
    674 "MoXEMM_reserved_21_1"
    675 "MoXEMM_reserved_21_2"
    676 "MoXEMM_SMU_ALM_21_3"
    677 "MoXEMM_reserved_21_4"
    678 "MoXEMM_reserved_21_5"
    679 "MoXEMM_reserved_21_6"
    680 "MoXEMM_reserved_21_7"
    681 "MoXEMM_reserved_21_8"
    682 "MoXEMM_reserved_21_9"
    683 "MoXEMM_reserved_21_10"
    684 "MoXEMM_reserved_21_11"
    685 "MoXEMM_reserved_21_12"
    686 "MoXEMM_reserved_21_13"
    687 "MoXEMM_reserved_21_14"
    688 "MoXEMM_reserved_21_15"
    689 "MoXEMM_SMU_ALM_21_16"
    690 "MoXEMM_reserved_21_17"
    691 "MoXEMM_reserved_21_18"
    692 "MoXEMM_reserved_21_19"
    693 "MoXEMM_reserved_21_20"
    694 "MoXEMM_reserved_21_21"
    695 "MoXEMM_reserved_21_22"
    696 "MoXEMM_reserved_21_23"
    697 "MoXEMM_reserved_21_24"
    698 "MoXEMM_reserved_21_25"
    699 "MoXEMM_reserved_21_26"
    700 "MoXEMM_reserved_21_27"
    701 "MoXEMM_reserved_21_28"
    702 "MoXEMM_reserved_21_29"
    703 "MoXEMM_reserved_21_30"
    704 "MoXEMM_reserved_21_31"
    65535 "MoXEMM_CLR_ERROR"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_CMNDSLGSLSW_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_CMNDSLGSLSW_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_CMNDSLGSLSW_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_EXTDTSK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_EXTDTSK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_EXTDTSK_SC_Compu
    ""
    TAB_VERB
    4
    0 "Disabled"
    2 "2ms"
    4 "4ms"
    5 "5ms"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_FRDMINTFRMETHOD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_FRDMINTFRMETHOD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_FRDMINTFRMETHOD_SC_Compu
    ""
    TAB_VERB
    3
    0 "CPL"
    1 "MPU"
    2 "CPL_MPU"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_LBISTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_LBISTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_LBISTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_MAXVALINDCR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_MAXVALINDCR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_MAXVALINDCR_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD

    MO_NRSLOTS_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MO_NRUSEDCORESFTY_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_NRUSEDCORESFTY_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_NRUSEDCORESFTY_SC_Compu
    ""
    TAB_VERB
    15
    1 "Core0"
    2 "Core1"
    3 "Core0_and_Core1"
    4 "Core2"
    5 "Core0_and_Core2"
    6 "Core1_and_Core2"
    7 "Core0_Core1_and_Core2"
    8 "Core3"
    9 "Core0_and_Core3"
    10 "Core1_and_Core3"
    11 "Core0_Core1_and_Core3"
    12 "Core2_and_Core3"
    13 "Core0_Core2_and_Core3"
    14 "Core1_Core2_and_Core3"
    15 "Core0_Core1_Core2_and_Core3"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_RAMCHKTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_RAMCHKTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_RAMCHKTYP_SC_Compu
    ""
    TAB_VERB
    2
    1 "Default"
    2 "MBIST"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_ROM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_ROM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_ROM_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    MO_VDD5MONHWTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MO_VDD5MONHWTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MO_VDD5MONHWTYP_SC_Compu
    ""
    TAB_VERB
    2
    0 "ASIC"
    1 "DIPO_CIRC"


/end COMPU_VTAB

/begin COMPU_METHOD
    MRLY_STACTDSQENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MRLY_STACTDSQENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MRLY_STACTDSQENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD

    mSoot_g
    ""
    RAT_FUNC
    "%6.4"
    "g"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    MsPerVol
    ""
    RAT_FUNC
    "%6.5"
    "g/l"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_O2
    ""
    RAT_FUNC
    "%6.5"
    "g"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_SOx
    ""
    RAT_FUNC
    "%6.5"
    "g"

    COEFFS 0 3278.68852459016 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_SOxLdTot
    ""
    RAT_FUNC
    "%6.3"
    "mg"

    COEFFS 0 2 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Ms_SOxNOx
    ""
    RAT_FUNC
    "%8.7"
    "g"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    MULTIHSS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF MULTIHSS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    MULTIHSS_SC_Compu
    ""
    TAB_VERB
    7
    0 "no_MultiHss"
    1 "one_MultiHss"
    2 "two_MultiHss"
    3 "three_MultiHss"
    4 "four_MultiHss"
    5 "five_MultiHss"
    6 "six_MultiHss"


/end COMPU_VTAB

/begin COMPU_METHOD

    M_NOxLd_LoRes
    ""
    RAT_FUNC
    "%6.4"
    "g"

    COEFFS 0 250 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    NOINIDRV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NOINIDRV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NOINIDRV_SC_Compu
    ""
    TAB_VERB
    2
    0 "IniDrv"
    1 "NoIniDrv"


/end COMPU_VTAB

/begin COMPU_METHOD
    NOREINI_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NOREINI_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NOREINI_SC_Compu
    ""
    TAB_VERB
    2
    0 "Reini"
    1 "NoReini"


/end COMPU_VTAB

/begin COMPU_METHOD

    nox
    ""
    RAT_FUNC
    "%6.2"
    "ppm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NOxFlwEG
    ""
    RAT_FUNC
    "%6.4"
    "Gram/s"

    COEFFS 0 40 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NOxMassFlw
    ""
    RAT_FUNC
    "%6.5"
    "mg/s"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    NSCRgn_Time_S
    ""
    RAT_FUNC
    "%6.4"
    "s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    NSC_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NSC_CT_SENSORS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NSC_CT_SENSORS_SY_Compu
    ""
    TAB_VERB
    5
    0 "ZERO"
    1 "ONE"
    2 "TWO"
    3 "THREE"
    4 "FOUR"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUMCYLACT_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMCYLACT_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMCYLACT_SY_Compu
    ""
    TAB_VERB
    11
    1 "ONE_CLYL"
    2 "TWO_CYL"
    3 "THREE_CYL"
    4 "FOUR_CYL"
    5 "FIVE_CYL"
    6 "SIX_CYL"
    7 "SEVEN_CYL"
    8 "EIGHT_CYL"
    10 "TEN_CYL"
    12 "TWELVE_CYL"
    16 "SIXTEEN_CYL"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUMCYLCAL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMCYLCAL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMCYLCAL_SY_Compu
    ""
    TAB_VERB
    2
    0 "FIX"
    1 "CAL"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUMCYLMAX_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMCYLMAX_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMCYLMAX_SY_Compu
    ""
    TAB_VERB
    11
    1 "ONE_CLYL"
    2 "TWO_CYL"
    3 "THREE_CYL"
    4 "FOUR_CYL"
    5 "FIVE_CYL"
    6 "SIX_CYL"
    7 "SEVEN_CYL"
    8 "EIGHT_CYL"
    10 "TEN_CYL"
    12 "TWELVE_CYL"
    16 "SIXTEEN_CYL"


/end COMPU_VTAB

/begin COMPU_METHOD
    NUMPSICCHP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF NUMPSICCHP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    NUMPSICCHP_SY_Compu
    ""
    TAB_VERB
    5
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"


/end COMPU_VTAB

/begin COMPU_METHOD

    O2
    ""
    RAT_FUNC
    "%8.7"
    "-"

    COEFFS 0 100000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    OBD_PHYSMEDM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OBD_PHYSMEDM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OBD_PHYSMEDM_SY_Compu
    ""
    TAB_VERB
    2
    0 "OBD_PHYSMEDM_CAN"
    1 "OBD_PHYSMEDM_KLINE"


/end COMPU_VTAB

/begin COMPU_METHOD
    OBS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OBS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OBS_SY_Compu
    ""
    TAB_VERB
    2
    0 "NOOBS"
    1 "SMP480"


/end COMPU_VTAB

/begin COMPU_METHOD
    OCWDA_stErrSimn_C_compu_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OCWDA_stErrSimn_C_compu_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OCWDA_stErrSimn_C_compu_VERB
    ""
    TAB_VERB
    9
    0 "OCWDA_CO_SIMN_OFF"
    1 "OCWDA_CO_SIMNERRPINON"
    2 "OCWDA_CO_SIMNERRPINOFF"
    3 "OCWDA_CO_SIMNWDAACTV"
    4 "OCWDA_CO_SIMNWDAOFF"
    5 "OCWDA_CO_SIMNOVRVLTG"
    6 "OCWDA_CO_SIMNNORMVLTG"
    7 "OCWDA_CO_SIMNABEACTV"
    8 "OCWDA_CO_SIMNABEOFF"


/end COMPU_VTAB

/begin COMPU_METHOD
    OCWDA_swtOffRst_C_compu_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OCWDA_swtOffRst_C_compu_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OCWDA_swtOffRst_C_compu_VERB
    ""
    TAB_VERB
    2
    0 "OCWDA_RESET_ACTIVE"
    1 "OCWDA_RESET_INACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    OILCOOLRDST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OILCOOLRDST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OILCOOLRDST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    OilMFl_mgps_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "mg/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMsPrc_q0p01
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMs_mg
    ""
    RAT_FUNC
    "%6.2"
    "mg"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMs_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "g"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OilMs_q10
    ""
    RAT_FUNC
    "%6.1"
    "g"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    OILP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OILP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OILP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    OILSWMPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OILSWMPT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OILSWMPT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    OILT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF OILT_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    OILT_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Oil_lvl_mm_q0p004
    ""
    RAT_FUNC
    "%6.4"
    "mm"

    COEFFS 0 250 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OneToOne
    ""
    RAT_FUNC
    "%6.2"
    "-"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    OneToTenCarb
    ""
    RAT_FUNC
    "%6.1"
    "-"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PAIRFLTDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PAIRFLTDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PAIRFLTDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PASSDOORRDNT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PASSDOORRDNT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PASSDOORRDNT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PERMSPLYSYS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PERMSPLYSYS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PERMSPLYSYS_SY_Compu
    ""
    TAB_VERB
    2
    0 "non-permanently supplied system"
    1 "permanently supplied system"


/end COMPU_VTAB

/begin COMPU_METHOD
    PEXHMNFLD_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PEXHMNFLD_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PEXHMNFLD_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    PFltPOpPrcPerSec_COMPU
    ""
    RAT_FUNC
    "%6.3"
    "%/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PiIClb_InjMassS32
    ""
    RAT_FUNC
    "%9.8"
    "mg/hub"

    COEFFS 0 6553600 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PINTKVUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PINTKVUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PINTKVUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    PmpQnt
    ""
    RAT_FUNC
    "%6.3"
    "mm^3/rev"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    POILVT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF POILVT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    POILVT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    POSTDRV_SOFTRST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF POSTDRV_SOFTRST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    POSTDRV_SOFTRST_SY_Compu
    ""
    TAB_VERB
    2
    0 "false"
    1 "true"


/end COMPU_VTAB

/begin COMPU_METHOD
    POUTLVLVDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF POUTLVLVDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    POUTLVLVDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDIFFASICT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDIFFASICT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDIFFASICT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDIFFCH1_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDIFFCH1_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDIFFCH1_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDIFFCH2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDIFFCH2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDIFFCH2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDIFF_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDIFF_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDIFF_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDIFF_TYPTWINFLW_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDIFF_TYPTWINFLW_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDIFF_TYPTWINFLW_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PPFLTUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PPFLTUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PPFLTUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Prc
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 81.92 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PrcPerSec_4ms
    ""
    RAT_FUNC
    "%6.2"
    "%/s"

    COEFFS 0 0.32768 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Prc_Fact100
    ""
    RAT_FUNC
    "%6.4"
    "%"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Prc_trq
    ""
    RAT_FUNC
    "%6.2"
    "%"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PresRail_sec
    ""
    RAT_FUNC
    "%6.0"
    "hPa/s"

    COEFFS 0 0.0025 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pres_hPa
    ""
    RAT_FUNC
    "%6.2"
    "hPa"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pres_Rail
    ""
    RAT_FUNC
    "%6.0"
    "hPa"

    COEFFS 0 0.01 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PRKGHEATR_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PRKGHEATR_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PRKGHEATR_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PSSCP1481VAR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PSSCP1481VAR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PSSCP1481VAR_SC_Compu
    ""
    TAB_VERB
    4
    0 "None"
    1 "MD1CE100"
    2 "MD1CE101"
    3 "MD1CE108"


/end COMPU_VTAB

/begin COMPU_METHOD
    PSSC_FIATCV_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PSSC_FIATCV_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PSSC_FIATCV_SY_Compu
    ""
    TAB_VERB
    9
    0 "None"
    1 "P1168"
    2 "P842"
    3 "P662"
    4 "P826"
    5 "P1208"
    6 "P1096"
    7 "P1291"
    8 "P1369"


/end COMPU_VTAB

/begin COMPU_METHOD

    PS_NUMSENS_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    PTACTVN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PTACTVN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PTACTVN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PTHRVLVDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PTHRVLVDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PTHRVLVDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PTRBNABSLTUS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PTRBNABSLTUS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PTRBNABSLTUS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PTRBNDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PTRBNDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PTRBNDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    PTRBNUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF PTRBNUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    PTRBNUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Pwr
    ""
    RAT_FUNC
    "%6.2"
    "W"

    COEFFS 0 0.10610329539459 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr2
    ""
    RAT_FUNC
    "%6.1"
    "W"

    COEFFS 0 0.0530516476972949 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr2Temp_q0p001
    ""
    RAT_FUNC
    "%6.4"
    "W/K"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr2Temp_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "W/K"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    PwrSq2TempSq_q0p01
    ""
    RAT_FUNC
    "%6.4"
    "W^2/K^2"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr_50
    ""
    RAT_FUNC
    "%6.1"
    "W"

    COEFFS 0 1 0 0 0 50 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr_kW
    ""
    RAT_FUNC
    "%6.4"
    "kW"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Pwr_q1
    ""
    RAT_FUNC
    "%6.2"
    "W"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    P_hPa_q0p078125_COMPU
    ""
    RAT_FUNC
    "%6.4"
    "hPa"

    COEFFS 0 12.8 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    p_q1_Pa
    ""
    RAT_FUNC
    "%6.2"
    "Pa"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    QCKSTRTSPCVERS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF QCKSTRTSPCVERS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    QCKSTRTSPCVERS_SC_Compu
    ""
    TAB_VERB
    3
    0 "SHTRP_ACTV"
    1 "QUICKSTART_INITIAL"
    2 "QUICKSTART_FULL"


/end COMPU_VTAB

/begin COMPU_METHOD

    QntR
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1024 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Qp_mm3_sec
    ""
    RAT_FUNC
    "%6.1"
    "mm3/s"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatAirMass
    ""
    RAT_FUNC
    "%6.4"
    "-"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatAirMassHigh
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatAirPres_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatCOMass
    ""
    RAT_FUNC
    "%9.8"
    "-"

    COEFFS 0 1000000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatHiRes_COMPU
    ""
    RAT_FUNC
    "%6.5"
    "-"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RatHiRes_CPP_COMPU
    ""
    RAT_FUNC
    "%7.6"
    "-"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    RBANDSTYPE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF RBANDSTYPE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    RBANDSTYPE_SC_Compu
    ""
    TAB_VERB
    4
    0 "NO_RBANDS"
    1 "ONLY_RBANDS"
    2 "MIXED_RBANDS"
    3 "MSR_RBANDS"


/end COMPU_VTAB

/begin COMPU_METHOD
    rba_SvbbEtk_SpName
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF rba_SvbbEtk_SpName
    
/end COMPU_METHOD

/begin COMPU_VTAB

    rba_SvbbEtk_SpName
    ""
    TAB_VERB
    5
    0 "Disable"
    1 "rba_Svbb_DummyActivate"
    2 "rba_SvbbEtk_Seg1Byp"
    3 "rba_SvbbEtk_T10msByp"
    4 "test_bypass_rba_Svbb_10ms_Proc"


/end COMPU_VTAB

/begin COMPU_METHOD

    rba_Svbb_Time_us
    ""
    RAT_FUNC
    "%6.4"
    ""

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    RBA_SWTRACEENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF RBA_SWTRACEENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    RBA_SWTRACEENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    RBPtCel_a_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "m/s^2"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_dst_1p0_4
    ""
    RAT_FUNC
    "%6.2"
    "km"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_fac_1p0_8
    ""
    RAT_FUNC
    "%6.2"
    "%/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_fPerp_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "N/Bar"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_frq_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "1/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_fti_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "Ns"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_f_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "N"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_i_1p0_2
    ""
    RAT_FUNC
    "%6.2"
    "A"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_nGrdt_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "rpm/s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_n_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "rpm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_Perc_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "%"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_p_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "hPa"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_p_1p0_2
    ""
    RAT_FUNC
    "%6.2"
    "Bar"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_ti_0p4_1
    ""
    RAT_FUNC
    "%6.3"
    "us"

    COEFFS 0 5 0 0 0 2 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_ti_1p0_2
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_tq_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "Nm"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_t_0p1om273p14_1
    ""
    RAT_FUNC
    "%6.1"
    "Deg C"

    COEFFS 0 10 2731.4 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_t_1p0_3
    ""
    RAT_FUNC
    "%6.2"
    "Deg C"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_u_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "V"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_vf_1p0_2
    ""
    RAT_FUNC
    "%6.2"
    "l/min"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RBPtCel_v_1p0_1
    ""
    RAT_FUNC
    "%6.2"
    "km/h"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Resist
    ""
    RAT_FUNC
    "%6.3"
    "Ohm"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Res_hPaSPerCM
    ""
    RAT_FUNC
    "%6.5"
    "hPa/(m^3*s/h)"

    COEFFS 0 1000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    RhoFuel
    ""
    RAT_FUNC
    "%6.3"
    "kg/m^3"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    RHUSTGYPRS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF RHUSTGYPRS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    RHUSTGYPRS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    RMTAPP_ENBL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF RMTAPP_ENBL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    RMTAPP_ENBL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SCR_DCU17SASW_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SCR_DCU17SASW_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SCR_DCU17SASW_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    SCR_kPa_10
    ""
    RAT_FUNC
    "%6.1"
    "kPa"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SCR_kPa_100
    ""
    RAT_FUNC
    "%6.0"
    "kPa"

    COEFFS 0 0.01 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SCR_SYSVRNT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SCR_SYSVRNT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SCR_SYSVRNT_SC_Compu
    ""
    TAB_VERB
    8
    51 "DNOX 5.1"
    52 "DNOX 5.2"
    61 "DNOX 6.1"
    62 "DNOX 6.2"
    63 "DNOX 6.3"
    65 "DNOX 6.5"
    66 "DNOX 6-HD 2.2 (evo)"
    69 "DNOX_6_9"


/end COMPU_VTAB

/begin COMPU_METHOD
    SCR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SCR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SCR_SY_Compu
    ""
    TAB_VERB
    4
    0 "NOSCR"
    1 "RBSCR"
    2 "INERGYSCR"
    3 "AGKSCR"


/end COMPU_VTAB

/begin COMPU_METHOD

    SCR_Volt_q0p0001227
    ""
    RAT_FUNC
    "%6.5"
    "V"

    COEFFS 0 8192 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SCTPMP1T_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SCTPMP1T_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SCTPMP1T_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SD_SC_Compu
    ""
    TAB_VERB
    2
    0 "INACTIVE"
    1 "ACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    SEAWTRP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SEAWTRP_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SEAWTRP_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SEAWTRT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SEAWTRT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SEAWTRT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SECULIBS_VAR_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SECULIBS_VAR_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SECULIBS_VAR_SY_Compu
    ""
    TAB_VERB
    3
    3 "VWW"
    5 "AUD"
    999 "ALL"


/end COMPU_VTAB

/begin COMPU_METHOD
    SECUPCK_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SECUPCK_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SECUPCK_SC_Compu
    ""
    TAB_VERB
    4
    0 "None"
    1 "SecuMgr"
    2 "EcuSecu_HSM"
    3 "EcuSecu_SSM"


/end COMPU_VTAB

/begin COMPU_METHOD
    SENTIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SENTIPCORETYPE_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SENTIPCORETYPE_SC_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    SENT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SENT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SENT_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SETPOINTCALC_TRQBASED_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SETPOINTCALC_TRQBASED_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SETPOINTCALC_TRQBASED_SY_Compu
    ""
    TAB_VERB
    2
    0 "QUANTITY"
    1 "TORQUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    SFTYHW_ETHSHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SFTYHW_ETHSHTOFFPAHTESTENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SFTYHW_ETHSHTOFFPAHTESTENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    Signals_IntSigNumVerb
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF Signals_IntSigNumVerb
    
/end COMPU_METHOD

/begin COMPU_VTAB

    Signals_IntSigNumVerb
    ""
    TAB_VERB
    113
    0 "SIGNALS_Signals_Default"
    1 "SIGNALS_APP1_uRaw_s"
    2 "SIGNALS_BattU_u"
    3 "SIGNALS_BattU_uRaw_s"
    4 "SIGNALS_BrkP_uRaw_s"
    5 "SIGNALS_Dummy_signal"
    6 "SIGNALS_Dummy_signal_02"
    7 "SIGNALS_EngDa_tEng_s"
    8 "SIGNALS_EnvCustomer_Parameter_0"
    9 "SIGNALS_EnvCustomer_Parameter_1"
    10 "SIGNALS_EnvCustomer_Parameter_2"
    11 "SIGNALS_EnvCustomer_Parameter_3"
    12 "SIGNALS_EnvCustomer_Parameter_4"
    13 "SIGNALS_EnvCustomer_Parameter_5"
    14 "SIGNALS_EnvT_uRaw_s"
    15 "SIGNALS_EpmCrS_tiIncPer_s"
    16 "SIGNALS_Epm_nEng_s"
    17 "SIGNALS_Epm_tiSpd2Zero_s"
    18 "SIGNALS_I15031_PID13h"
    19 "SIGNALS_I15031_PID1Dh"
    20 "SIGNALS_I15031_PID65Ah"
    21 "SIGNALS_I15031_PID66Ah"
    22 "SIGNALS_I15031_PID67Ah"
    23 "SIGNALS_I15031_PID68Ah"
    24 "SIGNALS_I15031_PID69Ah"
    25 "SIGNALS_I15031_PID6AAh"
    26 "SIGNALS_I15031_PID6BAh"
    27 "SIGNALS_I15031_PID6CAh"
    28 "SIGNALS_I15031_PID6DAh"
    29 "SIGNALS_I15031_PID6EAh"
    30 "SIGNALS_I15031_PID6FAh"
    31 "SIGNALS_I15031_PID70Ah"
    32 "SIGNALS_I15031_PID71Ah"
    33 "SIGNALS_I15031_PID72Ah"
    34 "SIGNALS_I15031_PID73Ah"
    35 "SIGNALS_I15031_PID74Ah"
    36 "SIGNALS_I15031_PID75Ah"
    37 "SIGNALS_I15031_PID76Ah"
    38 "SIGNALS_I15031_PID77Ah"
    39 "SIGNALS_I15031_PID78Ah"
    40 "SIGNALS_I15031_PID79Ah"
    41 "SIGNALS_I15031_PID7AAh"
    42 "SIGNALS_I15031_PID7BAh"
    43 "SIGNALS_I15031_PID7CAh"
    44 "SIGNALS_I15031_PID7FAh"
    45 "SIGNALS_I15031_PID81Ah"
    46 "SIGNALS_I15031_PID82Ah"
    47 "SIGNALS_I15031_PID85Ah"
    48 "SIGNALS_I15031_PID86Ah"
    49 "SIGNALS_I15031_PID87Ah"
    50 "SIGNALS_I15031_PID89Ah"
    51 "SIGNALS_I15031_PID8AAh"
    52 "SIGNALS_I15031_PID8FAh"
    53 "SIGNALS_I15031_PID92Ah"
    54 "SIGNALS_I15031_PID93Ah"
    55 "SIGNALS_I15031_PID94Ah"
    56 "SIGNALS_I15031_PID97Ah"
    57 "SIGNALS_I15031_PID98Ah"
    58 "SIGNALS_I15031_PID99Ah"
    59 "SIGNALS_I15031_PID9CAh"
    60 "SIGNALS_I15031_PIDA3Ah"
    61 "SIGNALS_I15031_PIDA4Ah"
    62 "SIGNALS_I15031_PIDA5Ah"
    63 "SIGNALS_I15031_PIDA9Ah"
    64 "SIGNALS_I15031_PIDACAh"
    65 "SIGNALS_OilP_p_s"
    66 "SIGNALS_PID01h"
    67 "SIGNALS_PID1Ch"
    68 "SIGNALS_PID21h"
    69 "SIGNALS_PID30h"
    70 "SIGNALS_PID31h"
    71 "SIGNALS_PID4FAh"
    72 "SIGNALS_PID4FBh"
    73 "SIGNALS_PID4FCh"
    74 "SIGNALS_PID4FDh"
    75 "SIGNALS_PID50Ah"
    76 "SIGNALS_PID50Bh"
    77 "SIGNALS_PID50Ch"
    78 "SIGNALS_PID50Dh"
    79 "SIGNALS_PID5Fh"
    80 "SIGNALS_PID8BAh"
    81 "SIGNALS_PID8CAh"
    82 "SIGNALS_PID9AAh"
    83 "SIGNALS_PID9FAh"
    84 "SIGNALS_PID_FILLSIG_1BIT"
    85 "SIGNALS_PID_FILLSIG_1BITNZ"
    86 "SIGNALS_PID_FILLSIG_1BYTE"
    87 "SIGNALS_PID_FILLSIG_1BYTENZ"
    88 "SIGNALS_PID_FILLSIG_2BIT"
    89 "SIGNALS_PID_FILLSIG_2BITNZ"
    90 "SIGNALS_PID_FILLSIG_2BYTE"
    91 "SIGNALS_PID_FILLSIG_2BYTENZ"
    92 "SIGNALS_PID_FILLSIG_3BIT"
    93 "SIGNALS_PID_FILLSIG_3BITNZ"
    94 "SIGNALS_PID_FILLSIG_4BIT"
    95 "SIGNALS_PID_FILLSIG_4BITNZ"
    96 "SIGNALS_PID_FILLSIG_4BYTE"
    97 "SIGNALS_PID_FILLSIG_4BYTENZ"
    98 "SIGNALS_PID_FILLSIG_5BIT"
    99 "SIGNALS_PID_FILLSIG_5BITNZ"
    100 "SIGNALS_PID_FILLSIG_6BIT"
    101 "SIGNALS_PID_FILLSIG_6BITNZ"
    102 "SIGNALS_PID_FILLSIG_7BIT"
    103 "SIGNALS_PID_FILLSIG_7BITNZ"
    104 "SIGNALS_SyC_tiDrv_s"
    105 "SIGNALS_TECU_t_s"
    106 "SIGNALS_ExtFloat_SyC_tiDrv_l_s"
    107 "SIGNALS_PID83h_A_BitCombineSignal"
    108 "SIGNALS_PID9Bh_A_BitCombineSignal"
    109 "SIGNALS_PIDA1h_A_BitCombineSignal"
    110 "SIGNALS_PIDA7h_A_BitCombineSignal"
    111 "SIGNALS_PIDA8h_A_BitCombineSignal"
    112 "SIGNALS_Virtual_bitfield_1003"


/end COMPU_VTAB

/begin COMPU_METHOD
    SIGNALS_OBDDIDSUPRT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SIGNALS_OBDDIDSUPRT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SIGNALS_OBDDIDSUPRT_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD

    Signals_OneToOne
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SigQly_COMPU_VERB
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SigQly_COMPU_VERB
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SigQly_COMPU_VERB
    ""
    TAB_VERB
    16
    0 "SIGQLY_NOTCALC"
    1 "SIGQLY_INIT"
    2 "SIGQLY_OK"
    3 "SIGQLY_MODEL"
    4 "SIGQLY_REPLACEMENT"
    5 "SIGQLY_FROZEN"
    6 "SIGQLY_INVALID"
    7 "SIGQLY_RESERVED_7"
    8 "SIGQLY_RESERVED_8"
    9 "SIGQLY_RESERVED_9"
    10 "SIGQLY_RESERVED_10"
    11 "SIGQLY_RESERVED_11"
    12 "SIGQLY_RESERVED_12"
    13 "SIGQLY_RESERVED_13"
    14 "SIGQLY_RESERVED_14"
    15 "SIGQLY_RESERVED_15"


/end COMPU_VTAB

/begin COMPU_METHOD

    Sig_I15031_LeanAppl_SY_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SotMassPerSec
    ""
    RAT_FUNC
    "%6.3"
    "g/s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SpaVel
    ""
    RAT_FUNC
    "%6.1"
    "l/h"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SpecificHeat
    ""
    RAT_FUNC
    "%7.6"
    "J/g/K"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    spg_q0p00488
    ""
    RAT_FUNC
    "%6.4"
    "V"

    COEFFS 0 1024 0 0 0 5 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    spg_uw_q0p00488
    ""
    RAT_FUNC
    "%6.4"
    "V"

    COEFFS 0 1024 0 0 0 5 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    spg_uw_q0p00488_o1
    ""
    RAT_FUNC
    "%6.3"
    "V"

    COEFFS 0 1024 1024 0 0 5 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    STOPLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF STOPLMP_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    STOPLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    STOPLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF STOPLMP_PSPRS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    STOPLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    STOPLMP_REDSTOPLAMPENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF STOPLMP_REDSTOPLAMPENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    STOPLMP_REDSTOPLAMPENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    STSP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF STSP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    STSP_SY_Compu
    ""
    TAB_VERB
    2
    0 "FALSE"
    1 "TRUE"


/end COMPU_VTAB

/begin COMPU_METHOD
    SVS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SVS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SVS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_AFTRUNDIAG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_AFTRUNDIAG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_AFTRUNDIAG_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_CAL_PERMSPLYSYS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_CAL_PERMSPLYSYS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_CAL_PERMSPLYSYS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_CNTPOSTDRV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_CNTPOSTDRV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_CNTPOSTDRV_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_COORD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_COORD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_COORD_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_ENALCYPROLG_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_ENALCYPROLG_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_ENALCYPROLG_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_FSTSWOFF_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_FSTSWOFF_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_FSTSWOFF_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SyC_PostDrv_State
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SyC_PostDrv_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SyC_PostDrv_State
    ""
    TAB_VERB
    9
    0 "SYC_POSTDRV_INACTV"
    1 "SYC_POSTDRV_DSM_BGN"
    2 "SYC_POSTDRV_EEP_BGN"
    3 "SYC_POSTDRV_WAIT"
    4 "SYC_POSTDRV_NWM"
    5 "SYC_POSTDRV_DSM_END"
    6 "SYC_POSTDRV_EEP_END"
    7 "SYC_POSTDRV_MIN_TIME"
    8 "SYC_POSTDRV_DONE"


/end COMPU_VTAB

/begin COMPU_METHOD
    SyC_PreDrv_State
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SyC_PreDrv_State
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SyC_PreDrv_State
    ""
    TAB_VERB
    10
    0 "SYC_PREDRV_INI_DRV"
    1 "SYC_PREDRV_DONE"
    2 "SYC_PREDRV_INI_SHDWN"
    3 "SYC_PREDRV_PROLONG"
    4 "SYC_PREDRV_NWM"
    5 "SYC_PREDRV_EEP"
    6 "SYC_PREDRV_DSM"
    7 "SYC_PREDRV_MR"
    8 "SYC_PREDRV_MOM"
    9 "SYC_PREDRV_EXIT"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_PROLGPREDRV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_PROLGPREDRV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_PROLGPREDRV_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_SYSTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_SYSTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_SYSTYP_SC_Compu
    ""
    TAB_VERB
    2
    0 "SysB"
    1 "EcuCtrl"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYC_T15POSTPREDRV_SWRST_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYC_T15POSTPREDRV_SWRST_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYC_T15POSTPREDRV_SWRST_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYSA_DSQACTVT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYSA_DSQACTVT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYSA_DSQACTVT_SC_Compu
    ""
    TAB_VERB
    2
    0 "Inactive"
    1 "Active"


/end COMPU_VTAB

/begin COMPU_METHOD
    SYSB_PHYTERMINAL15_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SYSB_PHYTERMINAL15_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SYSB_PHYTERMINAL15_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    SYSDIAG_NRAFTRUNCOORRARRELEM_SC_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SY_ATMTURB_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_ATMTURB_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_ATMTURB_Compu
    ""
    TAB_VERB
    2
    0 "ATMTURB_NOPRES"
    1 "ATMTURB_PRES"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_CNG_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_CNG_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_CNG_Compu
    ""
    TAB_VERB
    6
    0 "Kein System mit CNG"
    1 "System mit CNG"
    2 "System mit CNG und EOBD"
    3 "System mit CNG Fehlerpfade ASV1...5"
    4 "System mit CNG Plattform"
    5 "System with customer options on CNG platform"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_DLDP_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_DLDP_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_DLDP_Compu
    ""
    TAB_VERB
    2
    0 "kein DLDP System"
    1 "DLDP System"


/end COMPU_VTAB

/begin COMPU_METHOD

    SY_DMDSTQ_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SY_DMTL_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_DMTL_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_DMTL_Compu
    ""
    TAB_VERB
    2
    0 "DMTL nicht vorhanden"
    1 "DMTL vorhanden"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_DSPACE_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_DSPACE_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_DSPACE_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_HEV_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_HEV_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_HEV_Compu
    ""
    TAB_VERB
    8
    0 "0"
    1 "HEVTYP_SER"
    2 "HEVTYP_SERPARL"
    3 "HEVTYP_PWRSPLT"
    4 "HEVTYP_PARL"
    5 "HEVTYP_EAD"
    6 "HEVTYP_EDCT"
    7 "HEVTYP_PARLSER"


/end COMPU_VTAB

/begin COMPU_METHOD

    SY_KORRZ_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SY_KT_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SY_LAYER_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_LAYER_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_LAYER_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_MDMXEXC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_MDMXEXC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_MDMXEXC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_NVLD_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_NVLD_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_NVLD_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_PTL_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_PTL_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_PTL_Compu
    ""
    TAB_VERB
    2
    0 "relative inner moment"
    1 "Physical Torque Levels"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_PTO_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_PTO_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_PTO_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_SGANZ_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_SGANZ_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_SGANZ_Compu
    ""
    TAB_VERB
    3
    1 "Ein Steuerger�te Motormanagement Konzept"
    2 "Zwei Steuerger�te Motormanagement Konzept"
    3 "Drei Steuerger�te Motormanagement Konzept"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_SVBB_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_SVBB_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_SVBB_Compu
    ""
    TAB_VERB
    2
    0 "NOSVBB"
    1 "SVBBETAS"


/end COMPU_VTAB

/begin COMPU_METHOD
    SY_TEETH_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_TEETH_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_TEETH_Compu
    ""
    TAB_VERB
    2
    36 "number of crankshaft wheel teeth is 36 minus x"
    60 "number of crankshaft wheel teeth is 60 minus x"


/end COMPU_VTAB

/begin COMPU_METHOD

    SY_UBSQ_W_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SY_WFS_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    SY_WNBM_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    SY_ZYLZA_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF SY_ZYLZA_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    SY_ZYLZA_Compu
    ""
    TAB_VERB
    11
    1 "1"
    2 "2"
    3 "3"
    4 "4"
    5 "5"
    6 "6"
    8 "8"
    10 "10"
    12 "12"
    16 "16"
    18 "18"


/end COMPU_VTAB

/begin COMPU_METHOD

    SY_ZYLZG_Compu
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    T15RAWDSQENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF T15RAWDSQENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    T15RAWDSQENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "Disabled"
    1 "Enabled"


/end COMPU_VTAB

/begin COMPU_METHOD
    T15_WKDETN_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF T15_WKDETN_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    T15_WKDETN_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TBLOWBYHEATR_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TBLOWBYHEATR_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TBLOWBYHEATR_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TDC_ADAP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TDC_ADAP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TDC_ADAP_SY_Compu
    ""
    TAB_VERB
    4
    0 "NO_TDC_ADAP"
    1 "TDC_ADAP"
    2 "TDC_ADAP_CPP"
    3 "STAT_TDC_ADAP"


/end COMPU_VTAB

/begin COMPU_METHOD
    TDC_UNEQLGEOM_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TDC_UNEQLGEOM_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TDC_UNEQLGEOM_SY_Compu
    ""
    TAB_VERB
    2
    0 "EQL_TDC"
    1 "UNEQL_TDC"


/end COMPU_VTAB

/begin COMPU_METHOD
    TECU_SMP480SENSPRS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TECU_SMP480SENSPRS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TECU_SMP480SENSPRS_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TECU_TMSGFMT_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TECU_TMSGFMT_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TECU_TMSGFMT_SC_Compu
    ""
    TAB_VERB
    2
    1 "MSG"
    2 "MSG_ARRAY"


/end COMPU_VTAB

/begin COMPU_METHOD
    TEGRCLR2DS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TEGRCLR2DS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TEGRCLR2DS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "0"
    1 "1"


/end COMPU_VTAB

/begin COMPU_METHOD
    TEGRCLRDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TEGRCLRDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TEGRCLRDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TEGRCLRLPDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TEGRCLRLPDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TEGRCLRLPDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TEGRCLRUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TEGRCLRUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TEGRCLRUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TEGRVLVHOTDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TEGRVLVHOTDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TEGRVLVHOTDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    TempC_float
    ""
    RAT_FUNC
    "%6.1"
    "deg C"

    COEFFS 0 1 273.14 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TempDiff_1Deg
    ""
    RAT_FUNC
    "%6.2"
    "deg C"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TempDiff_Kelv
    ""
    RAT_FUNC
    "%6.3"
    "K"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TempK_float
    ""
    RAT_FUNC
    "%6.2"
    "K"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Temp_Cels
    ""
    RAT_FUNC
    "%6.1"
    "deg C"

    COEFFS 0 10 2731.4 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    THRVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF THRVLVI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    THRVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    THRVLVUST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF THRVLVUST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    THRVLVUST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    TimeDelay_s_2
    ""
    RAT_FUNC
    "%13.6"
    "s"

    COEFFS 0 0 1 0 0.0596046447753906 0 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeDT
    ""
    RAT_FUNC
    "%6.2"
    "us"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    TimeEngOn
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_ms
    ""
    RAT_FUNC
    "%6.1"
    "ms"

    COEFFS 0 0.1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_msec_q10_COMPU
    ""
    RAT_FUNC
    "%6.1"
    "ms"

    COEFFS 0 1 0 0 0 10 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_msec_q1_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "ms"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_s
    ""
    RAT_FUNC
    "%6.4"
    "s"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_sec_q1_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_s_LoRes
    ""
    RAT_FUNC
    "%6.2"
    "s"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Time_usec_q1_COMPU
    ""
    RAT_FUNC
    "%6.2"
    "us"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    TINTKVUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TINTKVUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TINTKVUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TLE7244_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TLE7244_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TLE7244_SC_Compu
    ""
    TAB_VERB
    3
    0 "No_TLE7244"
    1 "One_TLE7244"
    2 "Two_TLE7244"


/end COMPU_VTAB

/begin COMPU_METHOD
    TLE75602_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TLE75602_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TLE75602_SC_Compu
    ""
    TAB_VERB
    4
    0 "no Tle75602"
    1 "one Tle75602"
    2 "two Tle75602"
    3 "three Tle75602"


/end COMPU_VTAB

/begin COMPU_METHOD
    TOTENGREV_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TOTENGREV_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TOTENGREV_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TOXDCAT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TOXDCAT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TOXDCAT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TOXICATDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TOXICATDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TOXICATDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TOXICATUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TOXICATUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TOXICATUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TPFLTDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TPFLTDS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TPFLTDS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TPFLTUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TPFLTUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TPFLTUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TPS65917_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TPS65917_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TPS65917_SC_Compu
    ""
    TAB_VERB
    2
    0 "no_device"
    1 "one_device"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBCHINSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBCHINSDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBCHINSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBHP2I_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBHP2I_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBHP2I_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBHPBYPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBHPBYPI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBHPBYPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBHPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBHPI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBHPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBLPI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBLPI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBNBYVLV1INSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBNBYVLV1INSDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBNBYVLV1INSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TRBNBYVLV2INSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TRBNBYVLV2INSDT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TRBNBYVLV2INSDT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    Trq
    ""
    RAT_FUNC
    "%6.3"
    "Nm"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Trq_PrcHi
    ""
    RAT_FUNC
    "%6.3"
    ""

    COEFFS 0 8 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    TTRBNUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TTRBNUS_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TTRBNUS_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TTRBUSASICT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TTRBUSASICT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TTRBUSASICT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TWALLTC_MDLAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TWALLTC_MDLAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TWALLTC_MDLAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    TWCOR_HIRES_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TWCOR_HIRES_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TWCOR_HIRES_SC_Compu
    ""
    TAB_VERB
    2
    0 "RES_S8"
    1 "RES_S16"


/end COMPU_VTAB

/begin COMPU_METHOD
    TWTRCOOLRDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF TWTRCOOLRDS_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    TWTRCOOLRDS_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    t_q0p1
    ""
    RAT_FUNC
    "%6.3"
    "s"

    COEFFS 0 10 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    UART_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UART_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UART_SY_Compu
    ""
    TAB_VERB
    2
    0 "UART not used"
    1 "UART used"


/end COMPU_VTAB

/begin COMPU_METHOD
    UCATDST2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UCATDST2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UCATDST2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    UCATDST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UCATDST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UCATDST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    UCATUST2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UCATUST2_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UCATUST2_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    UCATUST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UCATUST_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UCATUST_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    UDPNM_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF UDPNM_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    UDPNM_SC_Compu
    ""
    TAB_VERB
    2
    0 "INACTIVE"
    1 "ACTIVE"


/end COMPU_VTAB

/begin COMPU_METHOD
    VCRTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VCRTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VCRTYP_SC_Compu
    ""
    TAB_VERB
    2
    0 "Fixed"
    1 "Continuous"


/end COMPU_VTAB

/begin COMPU_METHOD
    VEHTYP_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VEHTYP_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VEHTYP_SC_Compu
    ""
    TAB_VERB
    2
    1 "Two_Wheeler"
    2 "Four_Wheeler"


/end COMPU_VTAB

/begin COMPU_METHOD

    Vel
    ""
    RAT_FUNC
    "%6.4"
    "km/h"

    COEFFS 0 100 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    VIRTETH_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VIRTETH_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VIRTETH_SC_Compu
    ""
    TAB_VERB
    2
    0 "NO_VIRTETH"
    1 "VIRTETH_USED"


/end COMPU_VTAB

/begin COMPU_METHOD
    VLVLFTI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VLVLFTI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VLVLFTI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    VNQ6040_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VNQ6040_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VNQ6040_SC_Compu
    ""
    TAB_VERB
    4
    0 "NoneASIC"
    1 "OneASIC"
    2 "TwoASICs"
    3 "ThreeASICs"


/end COMPU_VTAB

/begin COMPU_METHOD

    Vol1
    ""
    RAT_FUNC
    "%9.8"
    "l"

    COEFFS 0 3600000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    volFilgLvl_ml
    ""
    RAT_FUNC
    "%6.2"
    "ml"

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt
    ""
    RAT_FUNC
    "%6.3"
    "mV"

    COEFFS 0 5 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Volt_Batt
    ""
    RAT_FUNC
    "%6.1"
    "mV"

    COEFFS 0 0.05 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    Vol_NSC
    ""
    RAT_FUNC
    "%7.6"
    "L"

    COEFFS 0 10000 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD
    VSWVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF VSWVLVI_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    VSWVLVI_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WDGS_CFGADPR_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WDGS_CFGADPR_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WDGS_CFGADPR_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WHRCOOLTPDIF_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WHRCOOLTPDIF_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WHRCOOLTPDIF_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WRNLMP_AMBERWARNLAMPENA_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WRNLMP_AMBERWARNLAMPENA_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WRNLMP_AMBERWARNLAMPENA_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WRNLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WRNLMP_ATSINTVMOD_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WRNLMP_ATSINTVMOD_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WRNLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WRNLMP_PSPRS_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WRNLMP_PSPRS_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WTRCACT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WTRCACT_TYPAVL_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WTRCACT_TYPAVL_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WTRCOOLTP1_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WTRCOOLTP1_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WTRCOOLTP1_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    WTRCOOLTP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF WTRCOOLTP_TYPAVL_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    WTRCOOLTP_TYPAVL_SY_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    XCORECDD_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF XCORECDD_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    XCORECDD_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD
    XCPVERS_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF XCPVERS_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    XCPVERS_SC_Compu
    ""
    TAB_VERB
    3
    1 "XCP_1_0"
    2 "XCP_1_1"
    3 "XCP_1_2"


/end COMPU_VTAB

/begin COMPU_METHOD
    XCP_SY_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF XCP_SY_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    XCP_SY_Compu
    ""
    TAB_VERB
    2
    0 "No XCP"
    1 "XCP"


/end COMPU_VTAB

/begin COMPU_METHOD
    XDI_SC_Compu
    ""
    TAB_VERB
    "%6.3"
    ""
    COMPU_TAB_REF XDI_SC_Compu
    
/end COMPU_METHOD

/begin COMPU_VTAB

    XDI_SC_Compu
    ""
    TAB_VERB
    2
    0 "False"
    1 "True"


/end COMPU_VTAB

/begin COMPU_METHOD

    default
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD

/begin COMPU_METHOD

    defaultAscii
    ""
    RAT_FUNC
    "%6.2"
    ""

    COEFFS 0 1 0 0 0 1 
    
/end COMPU_METHOD



/***********   Start of merged RECORD_LAYOUT blocks    ***********/


/begin RECORD_LAYOUT    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_boolean
    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT
    STATIC_ADDRESS_OFFSETS

/end RECORD_LAYOUT


/begin RECORD_LAYOUT    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT
    STATIC_ADDRESS_OFFSETS

/end RECORD_LAYOUT


/begin RECORD_LAYOUT    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT
    STATIC_ADDRESS_OFFSETS

/end RECORD_LAYOUT


/begin RECORD_LAYOUT    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    FNC_VALUES        1 ULONG COLUMN_DIR DIRECT
    STATIC_ADDRESS_OFFSETS

/end RECORD_LAYOUT

/***********   End of merged RECORD_LAYOUT blocks    ***********/
/begin RECORD_LAYOUT KwbUb

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT KwUb

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT KwWU16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT KwWU8

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Kw_Ws16

    FNC_VALUES        1 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT RB_Val_Ws16

    FNC_VALUES        1 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT RB_Val_Wu16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT RB_Val_Wu8

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Wu16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Wu32

    FNC_VALUES        1 ULONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Wu8

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Ws16

    FNC_VALUES        1 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Ws32

    FNC_VALUES        1 SLONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Wu16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Wu32

    FNC_VALUES        1 ULONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Wu8

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

  

/***********   Start of merged UNIT blocks    ***********/

/begin UNIT

    RB_RBA_Common_CentralElements_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_CanIf_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_CanSM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Com_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_ComM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_EthSM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_LinIf_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_LinSM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_PduR_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_TcpIp_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    Mcan_Can_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_BypDrv_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_CalWup_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Etks_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoDiagHlfBr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigHlfBr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_MRly_Units_NoUnit
    "No Unit"
    "nounit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_MRly_Units_ms
    "Millisecond"
    "ms"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_OsShell_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_OsMeasmt_Units_Perc
    "Percent"
    "%"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_OsMeasmt_Units_MicroSec
    "Micro Second"
    "us"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_OsShell_Units_MicroSec
    "Micro Second"
    "us"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_OsMeasmt_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_OsShell_Units_Perc
    "Percent"
    "%"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_Reset_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Runtime_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Runtime_Units_MicroSec
    "Micro Second"
    "us"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Runtime_Units_Perc
    "Percent"
    "%"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SvbbDrv_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SvbbEtk_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_States_Units_rba_SyC_States_NoUnit
    "No Unit"
    "nounit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_States_Units_rba_SyC_States_1second
    "Seconds"
    "s"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_T15_Units_NoUnit
    "No Unit"
    "nounit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_T15_Units_ms
    "Millisecond"
    "ms"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Rpm
    "Rpm"
    "rpm"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_CanNm_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_CanTrcv_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Eth_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_EthIf_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_EthTrcv_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Fee_Units_Fee_NoUnit
    "Fee No Unit"
    "Fee_NoUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_IpduM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Lin_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_LinTrcv_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Nm_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_NvM_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Bar
    "Bar"
    "bar"
    EXTENDED_SI
    SI_EXPONENTS -1 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_DegCgrd
    "Degree Centigrade"
    "degC"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 1 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_HectoPa
    "Hecto Pascal"
    "hPa"
    EXTENDED_SI
    SI_EXPONENTS -1 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Hz
    "Hertz"
    "Hz"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Kelvin
    "Kelvin"
    "K"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 1 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_KiloGr
    "Kilo Gram"
    "kg"
    EXTENDED_SI
    SI_EXPONENTS 0 1 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_KiloHz
    "Kilo Hertz"
    "kHz"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_KiloMtr
    "Kilo Meter"
    "km"
    EXTENDED_SI
    SI_EXPONENTS 1 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Mtr
    "Meter"
    "m"
    EXTENDED_SI
    SI_EXPONENTS 1 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_MtrPerSec
    "Meter per Second"
    "m/s"
    EXTENDED_SI
    SI_EXPONENTS 1 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_MtrPerSecCubd
    "Meter per Second Cubed"
    "m/s^3"
    EXTENDED_SI
    SI_EXPONENTS 1 0 -3 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_MtrPerSecSqd
    "Meter per Second Squared"
    "m/s^2"
    EXTENDED_SI
    SI_EXPONENTS 1 0 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_MtrRecpr
    "Meter Reciprocal"
    "1/m"
    EXTENDED_SI
    SI_EXPONENTS -1 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_NoUnit
    "No Unit"
    "-"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Nwt
    "Newton"
    "N"
    EXTENDED_SI
    SI_EXPONENTS 1 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_NwtMtr
    "Newton Meter"
    "Nm"
    EXTENDED_SI
    SI_EXPONENTS 2 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_NwtMtrPerSec
    "Newton Meter per Second"
    "Nm/s"
    EXTENDED_SI
    SI_EXPONENTS 2 1 -3 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_NwtPerMtr
    "Newton per Meter"
    "N/m"
    EXTENDED_SI
    SI_EXPONENTS 0 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_NwtSecPerMtr
    "Newton Second per Meter"
    "Ns/m"
    EXTENDED_SI
    SI_EXPONENTS 0 1 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Pa
    "Pascal"
    "Pa"
    EXTENDED_SI
    SI_EXPONENTS -1 1 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Perc
    "Percent"
    "%"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_PercPerSec
    "Percent per Second"
    "%/s"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Rad
    "Radian"
    "rad"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_RadPerSec
    "Radian per Second"
    "rad/s"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_RadPerSecSqd
    "Radian per Second Squared"
    "rad/s^2"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_RpmPerSec
    "Revolutions per minute per Second"
    "rpm/s"
    EXTENDED_SI
    SI_EXPONENTS 0 0 -2 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Sec
    "Second"
    "s"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_AISpecification_Units_Volt
    "Volt"
    "V"
    EXTENDED_SI
    SI_EXPONENTS 2 1 -3 -1 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_BypEtk_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_BypInt_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_BypXcp_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_ComScl_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Dme_Units_NoUnit
    ""
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_FrOsSync_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoDiagHbr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoDiagPs_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoDiagPwr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoExtCy326_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoExtDipo_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoExtLib_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigAdc_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigDio_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigFsc_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigHbr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigIcu_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigObs_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigPwm_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigPwm_Units_MicroSeconds
    ""
    "us"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigPwr_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_IoSigRtc_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_LtcySpy_Units_MicroSec
    "Micro Second"
    "us"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_LtcySpy_Units_MilliSec
    "Milli Second"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_LtcySpy_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_MRly_Units_mV
    "Millivolt"
    "mV"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SentIf_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_Svbb_Units_MicroSec
    "Micro Second"
    "us"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SvbbXcp_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Units_rba_SyC_1millisecond
    "Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Units_rba_SyC_10millisecond
    "10 Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Units_NoUnit
    "No Unit"
    "nounit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Units_rba_SyC_100millisecond
    "100 Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Units_rba_SyC_1second
    "Seconds"
    "s"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Rtc_Units_rba_SyC_Rtc_1millisecond
    "Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Rtc_Units_rba_SyC_Rtc_10millisecond
    "10 Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Rtc_Units_NoUnit
    "No Unit"
    "nounit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Rtc_Units_rba_SyC_Rtc_100millisecond
    "100 Milliseconds"
    "ms"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_Rtc_Units_rba_SyC_Rtc_1second
    "Seconds"
    "s"
    EXTENDED_SI

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_States_Units_rba_SyC_States_1millisecond
    "Milliseconds"
    "ms"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_States_Units_rba_SyC_States_10millisecond
    "10 Milliseconds"
    "ms"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    RB_RBA_rba_SyC_States_Units_rba_SyC_States_100millisecond
    "100 Milliseconds"
    "ms"
    EXTENDED_SI
    SI_EXPONENTS 0 0 1 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_SoAd_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/begin UNIT

    AUTOSAR_Xcp_Units_NoUnit
    "No Unit"
    "noUnit"
    EXTENDED_SI
    SI_EXPONENTS 0 0 0 0 0 0 0

/end UNIT

/***********   End of merged UNIT blocks    ***********/

/***********   Start of merged MEASUREMENT blocks    ***********/


/begin MEASUREMENT st_InitDone_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER st_InitDone_b
	ECU_ADDRESS 0x70013A97
	SYMBOL_LINK "st_InitDone_b" 0
/end MEASUREMENT


/begin MEASUREMENT ResetInfo_struc.rbr_UserDefined_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER ResetInfo_struc.rbr_UserDefined_u32
	ECU_ADDRESS 0x70013A98
	SYMBOL_LINK "ResetInfo_struc.rbr_UserDefined_u32" 0
/end MEASUREMENT


/begin MEASUREMENT ResetInfo_struc.rbr_Type_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER ResetInfo_struc.rbr_Type_u16
	ECU_ADDRESS 0x70013A9C
	SYMBOL_LINK "ResetInfo_struc.rbr_Type_u16" 0
/end MEASUREMENT


/begin MEASUREMENT ResetInfo_struc.rbr_Grp_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER ResetInfo_struc.rbr_Grp_u16
	ECU_ADDRESS 0x70013A9E
	SYMBOL_LINK "ResetInfo_struc.rbr_Grp_u16" 0
/end MEASUREMENT


/begin MEASUREMENT ResetInfo_struc.rbr_TiStampCurr_u64 ""
	A_UINT64 CnvRule_NumberOneToOne 1 0 0 18446744073709551615
	DISPLAY_IDENTIFIER ResetInfo_struc.rbr_TiStampCurr_u64
	ECU_ADDRESS 0x70013AA0
	SYMBOL_LINK "ResetInfo_struc.rbr_TiStampCurr_u64" 0
/end MEASUREMENT


/begin MEASUREMENT ResetInfoData_au32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER ResetInfoData_au32
	ECU_ADDRESS 0x70013AA8
	ARRAY_SIZE 8
	SYMBOL_LINK "ResetInfoData_au32" 0
/end MEASUREMENT


/begin MEASUREMENT ApplSwName_str ""
	 CnvRule_NumberOneToOne 1 0  
	DISPLAY_IDENTIFIER ApplSwName_str
	ECU_ADDRESS 0x70013AB0
	SYMBOL_LINK "ApplSwName_str" 0
/end MEASUREMENT


/begin MEASUREMENT UDSUUID_no_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER UDSUUID_no_au8
	ECU_ADDRESS 0x70013AE3
	ARRAY_SIZE 18
	SYMBOL_LINK "UDSUUID_no_au8" 0
/end MEASUREMENT


/begin MEASUREMENT status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER status_u16
	ECU_ADDRESS 0x70013AF6
	SYMBOL_LINK "status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT StartRelease_st_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER StartRelease_st_b
	ECU_ADDRESS 0x700134AB
	SYMBOL_LINK "StartRelease_st_b" 0
/end MEASUREMENT


/begin MEASUREMENT PostRun_st_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER PostRun_st_b
	ECU_ADDRESS 0x70013578
	SYMBOL_LINK "PostRun_st_b" 0
/end MEASUREMENT


/begin MEASUREMENT CallPostRunNr_no_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER CallPostRunNr_no_u16
	ECU_ADDRESS 0x7001357A
	SYMBOL_LINK "CallPostRunNr_no_u16" 0
/end MEASUREMENT


/begin MEASUREMENT States_s.currentState_e ""
	SWORD CnvRule_NumberOneToOne 1 0 -32768 32767
	DISPLAY_IDENTIFIER States_s.currentState_e
	ECU_ADDRESS 0x7001357C
	SYMBOL_LINK "States_s.currentState_e" 0
/end MEASUREMENT


/begin MEASUREMENT States_s.prvState_e ""
	SWORD CnvRule_NumberOneToOne 1 0 -32768 32767
	DISPLAY_IDENTIFIER States_s.prvState_e
	ECU_ADDRESS 0x7001357E
	SYMBOL_LINK "States_s.prvState_e" 0
/end MEASUREMENT


/begin MEASUREMENT st_Startlock_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER st_Startlock_b
	ECU_ADDRESS 0x70013579
	SYMBOL_LINK "st_Startlock_b" 0
/end MEASUREMENT


/begin MEASUREMENT MainTaskState_enu ""
	SWORD CnvRule_NumberOneToOne 1 0 -32768 32767
	DISPLAY_IDENTIFIER MainTaskState_enu
	ECU_ADDRESS 0x70013580
	SYMBOL_LINK "MainTaskState_enu" 0
/end MEASUREMENT


/begin MEASUREMENT i_UPumpSensr_mV_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER i_UPumpSensr_mV_u16
	ECU_ADDRESS 0x70013600
	SYMBOL_LINK "i_UPumpSensr_mV_u16" 0
/end MEASUREMENT


/begin MEASUREMENT diagParam_s.diFullDiag_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER diagParam_s.diFullDiag_l
	ECU_ADDRESS 0x70013602
	SYMBOL_LINK "diagParam_s.diFullDiag_l" 0
/end MEASUREMENT


/begin MEASUREMENT diagParam_s.diCntlAndDiag_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER diagParam_s.diCntlAndDiag_l
	ECU_ADDRESS 0x70013603
	SYMBOL_LINK "diagParam_s.diCntlAndDiag_l" 0
/end MEASUREMENT


/begin MEASUREMENT diagParam_s.diOpenLoadDetn_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER diagParam_s.diOpenLoadDetn_l
	ECU_ADDRESS 0x70013604
	SYMBOL_LINK "diagParam_s.diOpenLoadDetn_l" 0
/end MEASUREMENT


/begin MEASUREMENT diagParam_s.diNonHotSCDetn_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER diagParam_s.diNonHotSCDetn_l
	ECU_ADDRESS 0x70013605
	SYMBOL_LINK "diagParam_s.diNonHotSCDetn_l" 0
/end MEASUREMENT


/begin MEASUREMENT bds_outPwm_retGet_s.iSet_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER bds_outPwm_retGet_s.iSet_u16
	ECU_ADDRESS 0x70013606
	SYMBOL_LINK "bds_outPwm_retGet_s.iSet_u16" 0
/end MEASUREMENT


/begin MEASUREMENT bds_outPwm_retGet_s.iAct_mA_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER bds_outPwm_retGet_s.iAct_mA_u16
	ECU_ADDRESS 0x70013608
	SYMBOL_LINK "bds_outPwm_retGet_s.iAct_mA_u16" 0
/end MEASUREMENT


/begin MEASUREMENT bds_outPwm_retGet_s.ratDutyCycle_permil_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER bds_outPwm_retGet_s.ratDutyCycle_permil_u16
	ECU_ADDRESS 0x7001360A
	SYMBOL_LINK "bds_outPwm_retGet_s.ratDutyCycle_permil_u16" 0
/end MEASUREMENT


/begin MEASUREMENT bds_outPwm_retGet_s.statusApi_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER bds_outPwm_retGet_s.statusApi_e
	ECU_ADDRESS 0x70013612
	SYMBOL_LINK "bds_outPwm_retGet_s.statusApi_e" 0
/end MEASUREMENT


/begin MEASUREMENT no_UBatt_mV_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER no_UBatt_mV_u16
	ECU_ADDRESS 0x70013614
	SYMBOL_LINK "no_UBatt_mV_u16" 0
/end MEASUREMENT


/begin MEASUREMENT st_FlgInhActive_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER st_FlgInhActive_b
	ECU_ADDRESS 0x70013616
	SYMBOL_LINK "st_FlgInhActive_b" 0
/end MEASUREMENT


/begin MEASUREMENT st_FlgUBatLowDetd_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER st_FlgUBatLowDetd_b
	ECU_ADDRESS 0x70013617
	SYMBOL_LINK "st_FlgUBatLowDetd_b" 0
/end MEASUREMENT


/begin MEASUREMENT st_FlgUBatLowDetdPrev_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER st_FlgUBatLowDetdPrev_b
	ECU_ADDRESS 0x70013618
	SYMBOL_LINK "st_FlgUBatLowDetdPrev_b" 0
/end MEASUREMENT


/begin MEASUREMENT st_FlgOutpLocked_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER st_FlgOutpLocked_b
	ECU_ADDRESS 0x70013619
	SYMBOL_LINK "st_FlgOutpLocked_b" 0
/end MEASUREMENT


/begin MEASUREMENT st_FlgUnderUbat_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER st_FlgUnderUbat_b
	ECU_ADDRESS 0x7001361A
	SYMBOL_LINK "st_FlgUnderUbat_b" 0
/end MEASUREMENT


/begin MEASUREMENT st_FlgRstInh_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER st_FlgRstInh_b
	ECU_ADDRESS 0x7001361B
	SYMBOL_LINK "st_FlgRstInh_b" 0
/end MEASUREMENT


/begin MEASUREMENT st_FlgRstLowBatt_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER st_FlgRstLowBatt_b
	ECU_ADDRESS 0x7001361C
	SYMBOL_LINK "st_FlgRstLowBatt_b" 0
/end MEASUREMENT


/begin MEASUREMENT no_NrCycDebRst_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER no_NrCycDebRst_u16
	ECU_ADDRESS 0x7001361E
	SYMBOL_LINK "no_NrCycDebRst_u16" 0
/end MEASUREMENT


/begin MEASUREMENT no_CurrentK07_mA_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER no_CurrentK07_mA_u16
	ECU_ADDRESS 0x70013620
	SYMBOL_LINK "no_CurrentK07_mA_u16" 0
/end MEASUREMENT


/begin MEASUREMENT iPmpFwdSet_mA_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER iPmpFwdSet_mA_u16
	ECU_ADDRESS 0x70013622
	SYMBOL_LINK "iPmpFwdSet_mA_u16" 0
/end MEASUREMENT


/begin MEASUREMENT st_CurStK07_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER st_CurStK07_u8
	ECU_ADDRESS 0x7001361D
	SYMBOL_LINK "st_CurStK07_u8" 0
/end MEASUREMENT


/begin MEASUREMENT no_UPumpSensr_mV_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER no_UPumpSensr_mV_u16
	ECU_ADDRESS 0x70013624
	SYMBOL_LINK "no_UPumpSensr_mV_u16" 0
/end MEASUREMENT


/begin MEASUREMENT st_CtrlValve_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER st_CtrlValve_u8
	ECU_ADDRESS 0x70013626
	SYMBOL_LINK "st_CtrlValve_u8" 0
/end MEASUREMENT


/begin MEASUREMENT st_BrkSwt_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER st_BrkSwt_u8
	ECU_ADDRESS 0x70013627
	SYMBOL_LINK "st_BrkSwt_u8" 0
/end MEASUREMENT


/begin MEASUREMENT MngInh_struc.st_flgUBattLowDetd_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER MngInh_struc.st_flgUBattLowDetd_b
	ECU_ADDRESS 0x70013628
	SYMBOL_LINK "MngInh_struc.st_flgUBattLowDetd_b" 0
/end MEASUREMENT


/begin MEASUREMENT MngInh_struc.st_flgInhbActv_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER MngInh_struc.st_flgInhbActv_b
	ECU_ADDRESS 0x70013629
	SYMBOL_LINK "MngInh_struc.st_flgInhbActv_b" 0
/end MEASUREMENT


/begin MEASUREMENT MngInh_struc.st_flgOutpLockd_b ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER MngInh_struc.st_flgOutpLockd_b
	ECU_ADDRESS 0x7001362A
	SYMBOL_LINK "MngInh_struc.st_flgOutpLockd_b" 0
/end MEASUREMENT


/begin MEASUREMENT MngInh_struc.UBatt_mV_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER MngInh_struc.UBatt_mV_u16
	ECU_ADDRESS 0x7001362C
	SYMBOL_LINK "MngInh_struc.UBatt_mV_u16" 0
/end MEASUREMENT


/begin MEASUREMENT MngInh_struc.NrCycDebRst_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER MngInh_struc.NrCycDebRst_u16
	ECU_ADDRESS 0x7001362E
	SYMBOL_LINK "MngInh_struc.NrCycDebRst_u16" 0
/end MEASUREMENT


/begin MEASUREMENT PHMDL_CHNL1 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PHMDL_CHNL1
	ECU_ADDRESS 0x70013630
	SYMBOL_LINK "PHMDL_CHNL1" 0
/end MEASUREMENT


/begin MEASUREMENT PHMDL_CHNL1 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PHMDL_CHNL1
	ECU_ADDRESS 0x70013B08
	SYMBOL_LINK "PHMDL_CHNL1" 0
/end MEASUREMENT


/begin MEASUREMENT i_TaskCycleTime_ms_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER i_TaskCycleTime_ms_u16
	ECU_ADDRESS 0x70013682
	SYMBOL_LINK "i_TaskCycleTime_ms_u16" 0
/end MEASUREMENT


/begin MEASUREMENT st_K21Inh_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER st_K21Inh_u8
	ECU_ADDRESS 0x70013681
	SYMBOL_LINK "st_K21Inh_u8" 0
/end MEASUREMENT


/begin MEASUREMENT st_K22Inh_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER st_K22Inh_u8
	ECU_ADDRESS 0x70013684
	SYMBOL_LINK "st_K22Inh_u8" 0
/end MEASUREMENT


/begin MEASUREMENT st_FlgStInhb_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER st_FlgStInhb_u8
	ECU_ADDRESS 0x70013685
	SYMBOL_LINK "st_FlgStInhb_u8" 0
/end MEASUREMENT


/begin MEASUREMENT bds_inPwm_getFrqPwm_s.frq_dHz_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER bds_inPwm_getFrqPwm_s.frq_dHz_u32
	ECU_ADDRESS 0x70013688
	SYMBOL_LINK "bds_inPwm_getFrqPwm_s.frq_dHz_u32" 0
/end MEASUREMENT


/begin MEASUREMENT bds_inPwm_getFrqPwm_s.dutyCyc_perml_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER bds_inPwm_getFrqPwm_s.dutyCyc_perml_u16
	ECU_ADDRESS 0x7001368C
	SYMBOL_LINK "bds_inPwm_getFrqPwm_s.dutyCyc_perml_u16" 0
/end MEASUREMENT


/begin MEASUREMENT bds_inPwm_getFrqPwm_s.cntPls_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER bds_inPwm_getFrqPwm_s.cntPls_u32
	ECU_ADDRESS 0x70013690
	SYMBOL_LINK "bds_inPwm_getFrqPwm_s.cntPls_u32" 0
/end MEASUREMENT


/begin MEASUREMENT bds_inPwm_getFrqPwm_s.status_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER bds_inPwm_getFrqPwm_s.status_e
	ECU_ADDRESS 0x70013694
	SYMBOL_LINK "bds_inPwm_getFrqPwm_s.status_e" 0
/end MEASUREMENT


/begin MEASUREMENT FrqP_Hz_10_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER FrqP_Hz_10_u32
	ECU_ADDRESS 0x70013698
	SYMBOL_LINK "FrqP_Hz_10_u32" 0
/end MEASUREMENT


/begin MEASUREMENT Tmp_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER Tmp_u32
	ECU_ADDRESS 0x7001369C
	SYMBOL_LINK "Tmp_u32" 0
/end MEASUREMENT


/begin MEASUREMENT stPmpSnsrU_struc.status_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER stPmpSnsrU_struc.status_e
	ECU_ADDRESS 0x700136A0
	SYMBOL_LINK "stPmpSnsrU_struc.status_e" 0
/end MEASUREMENT


/begin MEASUREMENT stPmpSnsrU_struc.u_mV_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER stPmpSnsrU_struc.u_mV_u16
	ECU_ADDRESS 0x700136A2
	SYMBOL_LINK "stPmpSnsrU_struc.u_mV_u16" 0
/end MEASUREMENT


/begin MEASUREMENT uPmpSnsr_mV_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER uPmpSnsr_mV_u16
	ECU_ADDRESS 0x70013686
	SYMBOL_LINK "uPmpSnsr_mV_u16" 0
/end MEASUREMENT


/begin MEASUREMENT stPmpSnsrSigInvldErr_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER stPmpSnsrSigInvldErr_e
	ECU_ADDRESS 0x700136A4
	SYMBOL_LINK "stPmpSnsrSigInvldErr_e" 0
/end MEASUREMENT


/begin MEASUREMENT stBrkSwtU_struc.status_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER stBrkSwtU_struc.status_e
	ECU_ADDRESS 0x700136A6
	SYMBOL_LINK "stBrkSwtU_struc.status_e" 0
/end MEASUREMENT


/begin MEASUREMENT stBrkSwtU_struc.u_mV_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER stBrkSwtU_struc.u_mV_u16
	ECU_ADDRESS 0x700136A8
	SYMBOL_LINK "stBrkSwtU_struc.u_mV_u16" 0
/end MEASUREMENT


/begin MEASUREMENT uBrkSwt_mV_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER uBrkSwt_mV_u16
	ECU_ADDRESS 0x700136AA
	SYMBOL_LINK "uBrkSwt_mV_u16" 0
/end MEASUREMENT


/begin MEASUREMENT stBrkSwt_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER stBrkSwt_u8
	ECU_ADDRESS 0x700136A5
	SYMBOL_LINK "stBrkSwt_u8" 0
/end MEASUREMENT


/begin MEASUREMENT stBrkSwtSigInvldErr_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER stBrkSwtSigInvldErr_e
	ECU_ADDRESS 0x700136AC
	SYMBOL_LINK "stBrkSwtSigInvldErr_e" 0
/end MEASUREMENT


/begin MEASUREMENT stVehSnsrFrq_struc.frq_dHz_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER stVehSnsrFrq_struc.frq_dHz_u32
	ECU_ADDRESS 0x700136B0
	SYMBOL_LINK "stVehSnsrFrq_struc.frq_dHz_u32" 0
/end MEASUREMENT


/begin MEASUREMENT stVehSnsrFrq_struc.dutyCyc_perml_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER stVehSnsrFrq_struc.dutyCyc_perml_u16
	ECU_ADDRESS 0x700136B4
	SYMBOL_LINK "stVehSnsrFrq_struc.dutyCyc_perml_u16" 0
/end MEASUREMENT


/begin MEASUREMENT stVehSnsrFrq_struc.cntPls_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER stVehSnsrFrq_struc.cntPls_u32
	ECU_ADDRESS 0x700136B8
	SYMBOL_LINK "stVehSnsrFrq_struc.cntPls_u32" 0
/end MEASUREMENT


/begin MEASUREMENT stVehSnsrFrq_struc.status_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER stVehSnsrFrq_struc.status_e
	ECU_ADDRESS 0x700136BC
	SYMBOL_LINK "stVehSnsrFrq_struc.status_e" 0
/end MEASUREMENT


/begin MEASUREMENT frqVehSnsr_Hz_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER frqVehSnsr_Hz_u32
	ECU_ADDRESS 0x700136C0
	SYMBOL_LINK "frqVehSnsr_Hz_u32" 0
/end MEASUREMENT


/begin MEASUREMENT vWhlSpd_kph_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER vWhlSpd_kph_u16
	ECU_ADDRESS 0x700136AE
	SYMBOL_LINK "vWhlSpd_kph_u16" 0
/end MEASUREMENT


/begin MEASUREMENT SpdSnsrDST1_struc.spd_dRpm_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER SpdSnsrDST1_struc.spd_dRpm_u32
	ECU_ADDRESS 0x700136C8
	SYMBOL_LINK "SpdSnsrDST1_struc.spd_dRpm_u32" 0
/end MEASUREMENT


/begin MEASUREMENT SpdSnsrDST1_struc.dir_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER SpdSnsrDST1_struc.dir_e
	ECU_ADDRESS 0x700136CC
	SYMBOL_LINK "SpdSnsrDST1_struc.dir_e" 0
/end MEASUREMENT


/begin MEASUREMENT SpdSnsrDST1_struc.statusApi_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER SpdSnsrDST1_struc.statusApi_e
	ECU_ADDRESS 0x700136CD
	SYMBOL_LINK "SpdSnsrDST1_struc.statusApi_e" 0
/end MEASUREMENT


/begin MEASUREMENT SpdSnsrDST1_inst_enu ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER SpdSnsrDST1_inst_enu
	ECU_ADDRESS 0x700136AD
	SYMBOL_LINK "SpdSnsrDST1_inst_enu" 0
/end MEASUREMENT


/begin MEASUREMENT SpdSnsrDST1_dRpm_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER SpdSnsrDST1_dRpm_u32
	ECU_ADDRESS 0x700136D0
	SYMBOL_LINK "SpdSnsrDST1_dRpm_u32" 0
/end MEASUREMENT


/begin MEASUREMENT SpdSnsrDST1_rotDir_enu ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER SpdSnsrDST1_rotDir_enu
	ECU_ADDRESS 0x700136D4
	SYMBOL_LINK "SpdSnsrDST1_rotDir_enu" 0
/end MEASUREMENT


/begin MEASUREMENT SpdSnsrDST1Temp_struc.statusApi_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER SpdSnsrDST1Temp_struc.statusApi_e
	ECU_ADDRESS 0x700136D8
	SYMBOL_LINK "SpdSnsrDST1Temp_struc.statusApi_e" 0
/end MEASUREMENT


/begin MEASUREMENT SpdSnsrDST1Temp_struc.temp_degC_s32 ""
	SLONG CnvRule_NumberOneToOne 1 0 -2147483648 2147483647
	DISPLAY_IDENTIFIER SpdSnsrDST1Temp_struc.temp_degC_s32
	ECU_ADDRESS 0x700136E0
	SYMBOL_LINK "SpdSnsrDST1Temp_struc.temp_degC_s32" 0
/end MEASUREMENT


/begin MEASUREMENT SpdSnsrDST1_temp_degC_s32 ""
	SLONG CnvRule_NumberOneToOne 1 0 -2147483648 2147483647
	DISPLAY_IDENTIFIER SpdSnsrDST1_temp_degC_s32
	ECU_ADDRESS 0x700136E4
	SYMBOL_LINK "SpdSnsrDST1_temp_degC_s32" 0
/end MEASUREMENT


/begin MEASUREMENT PR4Snsr_getP_struc.stsApi_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PR4Snsr_getP_struc.stsApi_e
	ECU_ADDRESS 0x700136E8
	SYMBOL_LINK "PR4Snsr_getP_struc.stsApi_e" 0
/end MEASUREMENT


/begin MEASUREMENT PR4Snsr_getP_struc.pressureMeasmtRng_dBar_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PR4Snsr_getP_struc.pressureMeasmtRng_dBar_u16
	ECU_ADDRESS 0x700136EA
	SYMBOL_LINK "PR4Snsr_getP_struc.pressureMeasmtRng_dBar_u16" 0
/end MEASUREMENT


/begin MEASUREMENT PR4Snsr_getP_struc.pressure_dBar_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PR4Snsr_getP_struc.pressure_dBar_u16
	ECU_ADDRESS 0x700136F0
	SYMBOL_LINK "PR4Snsr_getP_struc.pressure_dBar_u16" 0
/end MEASUREMENT


/begin MEASUREMENT PR4Snsr_getP_struc.padding ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PR4Snsr_getP_struc.padding
	ECU_ADDRESS 0x700136F2
	ARRAY_SIZE 2
	SYMBOL_LINK "PR4Snsr_getP_struc.padding" 0
/end MEASUREMENT


/begin MEASUREMENT PR4SnsrP_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PR4SnsrP_u16
	ECU_ADDRESS 0x700136D6
	SYMBOL_LINK "PR4SnsrP_u16" 0
/end MEASUREMENT


/begin MEASUREMENT PR4Snsr_getT_struc.stsApi_e ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER PR4Snsr_getT_struc.stsApi_e
	ECU_ADDRESS 0x700136F4
	SYMBOL_LINK "PR4Snsr_getT_struc.stsApi_e" 0
/end MEASUREMENT


/begin MEASUREMENT PR4Snsr_getT_struc.temp_degC_s32 ""
	SLONG CnvRule_NumberOneToOne 1 0 -2147483648 2147483647
	DISPLAY_IDENTIFIER PR4Snsr_getT_struc.temp_degC_s32
	ECU_ADDRESS 0x700136FC
	SYMBOL_LINK "PR4Snsr_getT_struc.temp_degC_s32" 0
/end MEASUREMENT


/begin MEASUREMENT PR4SnsrT_s32 ""
	SLONG CnvRule_NumberOneToOne 1 0 -2147483648 2147483647
	DISPLAY_IDENTIFIER PR4SnsrT_s32
	ECU_ADDRESS 0x70013700
	SYMBOL_LINK "PR4SnsrT_s32" 0
/end MEASUREMENT


/begin MEASUREMENT o_T15_st_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER o_T15_st_u8
	ECU_ADDRESS 0x700136D5
	SYMBOL_LINK "o_T15_st_u8" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_gstruc.fctPmp_s16 ""
	SWORD CnvRule_NumberOneToOne 1 0 -32768 32767
	DISPLAY_IDENTIFIER PrmAsw_gstruc.fctPmp_s16
	ECU_ADDRESS 0x70018800
	SYMBOL_LINK "PrmAsw_gstruc.fctPmp_s16" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_gstruc.listCtrlVlv_enu ""
	SWORD CnvRule_NumberOneToOne 1 0 -32768 32767
	DISPLAY_IDENTIFIER PrmAsw_gstruc.listCtrlVlv_enu
	ECU_ADDRESS 0x70018802
	SYMBOL_LINK "PrmAsw_gstruc.listCtrlVlv_enu" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_gstruc.nrCogs_s16 ""
	SWORD CnvRule_NumberOneToOne 1 0 -32768 32767
	DISPLAY_IDENTIFIER PrmAsw_gstruc.nrCogs_s16
	ECU_ADDRESS 0x70018804
	SYMBOL_LINK "PrmAsw_gstruc.nrCogs_s16" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_gstruc.iSpSafout1_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PrmAsw_gstruc.iSpSafout1_u16
	ECU_ADDRESS 0x70018806
	SYMBOL_LINK "PrmAsw_gstruc.iSpSafout1_u16" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_gstruc.iSpSafout2_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PrmAsw_gstruc.iSpSafout2_u16
	ECU_ADDRESS 0x70018808
	SYMBOL_LINK "PrmAsw_gstruc.iSpSafout2_u16" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_gstruc.nEngSpd_rpm_au16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PrmAsw_gstruc.nEngSpd_rpm_au16
	ECU_ADDRESS 0x7001880A
	ARRAY_SIZE 6
	SYMBOL_LINK "PrmAsw_gstruc.nEngSpd_rpm_au16" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_gstruc.eff_perc_au16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PrmAsw_gstruc.eff_perc_au16
	ECU_ADDRESS 0x70018810
	ARRAY_SIZE 6
	SYMBOL_LINK "PrmAsw_gstruc.eff_perc_au16" 0
/end MEASUREMENT


/begin MEASUREMENT anValue_perc_gu8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER anValue_perc_gu8
	ECU_ADDRESS 0x70018818
	SYMBOL_LINK "anValue_perc_gu8" 0
/end MEASUREMENT


/begin MEASUREMENT swtStatus_gu8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER swtStatus_gu8
	ECU_ADDRESS 0x70018819
	SYMBOL_LINK "swtStatus_gu8" 0
/end MEASUREMENT


/begin MEASUREMENT can1RxDataboxCbkCntr_gu32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER can1RxDataboxCbkCntr_gu32
	ECU_ADDRESS 0x7001881C
	SYMBOL_LINK "can1RxDataboxCbkCntr_gu32" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_cgstruc.fctPmp_s16 ""
	SWORD CnvRule_NumberOneToOne 1 0 -32768 32767
	DISPLAY_IDENTIFIER PrmAsw_cgstruc.fctPmp_s16
	ECU_ADDRESS 0x802E01C0
	SYMBOL_LINK "PrmAsw_cgstruc.fctPmp_s16" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_cgstruc.listCtrlVlv_enu ""
	SWORD CnvRule_NumberOneToOne 1 0 -32768 32767
	DISPLAY_IDENTIFIER PrmAsw_cgstruc.listCtrlVlv_enu
	ECU_ADDRESS 0x802E01C2
	SYMBOL_LINK "PrmAsw_cgstruc.listCtrlVlv_enu" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_cgstruc.nrCogs_s16 ""
	SWORD CnvRule_NumberOneToOne 1 0 -32768 32767
	DISPLAY_IDENTIFIER PrmAsw_cgstruc.nrCogs_s16
	ECU_ADDRESS 0x802E01C4
	SYMBOL_LINK "PrmAsw_cgstruc.nrCogs_s16" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_cgstruc.iSpSafout1_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PrmAsw_cgstruc.iSpSafout1_u16
	ECU_ADDRESS 0x802E01C6
	SYMBOL_LINK "PrmAsw_cgstruc.iSpSafout1_u16" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_cgstruc.iSpSafout2_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PrmAsw_cgstruc.iSpSafout2_u16
	ECU_ADDRESS 0x802E01C8
	SYMBOL_LINK "PrmAsw_cgstruc.iSpSafout2_u16" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_cgstruc.nEngSpd_rpm_au16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PrmAsw_cgstruc.nEngSpd_rpm_au16
	ECU_ADDRESS 0x802E01CA
	ARRAY_SIZE 6
	SYMBOL_LINK "PrmAsw_cgstruc.nEngSpd_rpm_au16" 0
/end MEASUREMENT


/begin MEASUREMENT PrmAsw_cgstruc.eff_perc_au16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER PrmAsw_cgstruc.eff_perc_au16
	ECU_ADDRESS 0x802E01D0
	ARRAY_SIZE 6
	SYMBOL_LINK "PrmAsw_cgstruc.eff_perc_au16" 0
/end MEASUREMENT


/begin MEASUREMENT CAN1RxData_astruc[1].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN1RxData_astruc[1].data_au8
	ECU_ADDRESS 0x70013582
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN1RxData_astruc[1].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN1RxData_astruc[1].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN1RxData_astruc[1].numBytes_u8
	ECU_ADDRESS 0x7001358A
	SYMBOL_LINK "CAN1RxData_astruc[1].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN1RxData_astruc[2].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN1RxData_astruc[2].data_au8
	ECU_ADDRESS 0x7001358C
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN1RxData_astruc[2].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN1RxData_astruc[2].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN1RxData_astruc[2].numBytes_u8
	ECU_ADDRESS 0x70013594
	SYMBOL_LINK "CAN1RxData_astruc[2].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[1].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[1].data_au8
	ECU_ADDRESS 0x70013596
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN2RxData_astruc[1].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[1].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[1].numBytes_u8
	ECU_ADDRESS 0x7001359E
	SYMBOL_LINK "CAN2RxData_astruc[1].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[2].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[2].data_au8
	ECU_ADDRESS 0x700135A0
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN2RxData_astruc[2].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[2].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[2].numBytes_u8
	ECU_ADDRESS 0x700135A8
	SYMBOL_LINK "CAN2RxData_astruc[2].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[3].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[3].data_au8
	ECU_ADDRESS 0x700135AA
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN2RxData_astruc[3].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[3].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[3].numBytes_u8
	ECU_ADDRESS 0x700135B2
	SYMBOL_LINK "CAN2RxData_astruc[3].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[4].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[4].data_au8
	ECU_ADDRESS 0x700135B4
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN2RxData_astruc[4].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[4].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[4].numBytes_u8
	ECU_ADDRESS 0x700135BC
	SYMBOL_LINK "CAN2RxData_astruc[4].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[5].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[5].data_au8
	ECU_ADDRESS 0x700135BE
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN2RxData_astruc[5].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[5].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[5].numBytes_u8
	ECU_ADDRESS 0x700135C6
	SYMBOL_LINK "CAN2RxData_astruc[5].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT bds_IPduGrpVctr_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER bds_IPduGrpVctr_au8
	ECU_ADDRESS 0x700135C8
	ARRAY_SIZE 8
	SYMBOL_LINK "bds_IPduGrpVctr_au8" 0
/end MEASUREMENT


/begin MEASUREMENT retSet_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER retSet_u16
	ECU_ADDRESS 0x700135D0
	SYMBOL_LINK "retSet_u16" 0
/end MEASUREMENT


/begin MEASUREMENT retStrt_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER retStrt_u16
	ECU_ADDRESS 0x700135D2
	SYMBOL_LINK "retStrt_u16" 0
/end MEASUREMENT


/begin MEASUREMENT data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER data_au8
	ECU_ADDRESS 0x700135D4
	ARRAY_SIZE 8
	SYMBOL_LINK "data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTx_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTx_au8
	ECU_ADDRESS 0x700135DC
	ARRAY_SIZE 8
	SYMBOL_LINK "dataTx_au8" 0
/end MEASUREMENT


/begin MEASUREMENT sigData_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER sigData_au8
	ECU_ADDRESS 0x700135E4
	ARRAY_SIZE 8
	SYMBOL_LINK "sigData_au8" 0
/end MEASUREMENT


/begin MEASUREMENT i_statusNvmIni_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER i_statusNvmIni_u16
	ECU_ADDRESS 0x700135EC
	SYMBOL_LINK "i_statusNvmIni_u16" 0
/end MEASUREMENT


/begin MEASUREMENT i_iPmpFwdAct_mA_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER i_iPmpFwdAct_mA_u16
	ECU_ADDRESS 0x700135EE
	SYMBOL_LINK "i_iPmpFwdAct_mA_u16" 0
/end MEASUREMENT


/begin MEASUREMENT i_iPmpFwdSet_mA_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER i_iPmpFwdSet_mA_u16
	ECU_ADDRESS 0x700135F0
	SYMBOL_LINK "i_iPmpFwdSet_mA_u16" 0
/end MEASUREMENT


/begin MEASUREMENT i_CtrlValve_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER i_CtrlValve_u8
	ECU_ADDRESS 0x700135F2
	SYMBOL_LINK "i_CtrlValve_u8" 0
/end MEASUREMENT


/begin MEASUREMENT i_rxActEngPercTq_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER i_rxActEngPercTq_u8
	ECU_ADDRESS 0x700135F3
	SYMBOL_LINK "i_rxActEngPercTq_u8" 0
/end MEASUREMENT


/begin MEASUREMENT i_vWhlSpd_kph_u16 ""
	SWORD CnvRule_NumberOneToOne 1 0 -32768 32767
	DISPLAY_IDENTIFIER i_vWhlSpd_kph_u16
	ECU_ADDRESS 0x700135F4
	SYMBOL_LINK "i_vWhlSpd_kph_u16" 0
/end MEASUREMENT


/begin MEASUREMENT i_uPmpSnsr_mV_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER i_uPmpSnsr_mV_u16
	ECU_ADDRESS 0x700135F6
	SYMBOL_LINK "i_uPmpSnsr_mV_u16" 0
/end MEASUREMENT


/begin MEASUREMENT i_frqVehSnsr_Hz_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER i_frqVehSnsr_Hz_u32
	ECU_ADDRESS 0x700135F8
	SYMBOL_LINK "i_frqVehSnsr_Hz_u32" 0
/end MEASUREMENT


/begin MEASUREMENT i_anValue_perc_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER i_anValue_perc_u8
	ECU_ADDRESS 0x700135FC
	SYMBOL_LINK "i_anValue_perc_u8" 0
/end MEASUREMENT


/begin MEASUREMENT i_stBrkSwt_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER i_stBrkSwt_u8
	ECU_ADDRESS 0x700135FD
	SYMBOL_LINK "i_stBrkSwt_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN1RxData_astruc[1].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN1RxData_astruc[1].data_au8
	ECU_ADDRESS 0x70013632
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN1RxData_astruc[1].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN1RxData_astruc[1].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN1RxData_astruc[1].numBytes_u8
	ECU_ADDRESS 0x7001363A
	SYMBOL_LINK "CAN1RxData_astruc[1].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN1RxData_astruc[2].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN1RxData_astruc[2].data_au8
	ECU_ADDRESS 0x7001363C
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN1RxData_astruc[2].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN1RxData_astruc[2].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN1RxData_astruc[2].numBytes_u8
	ECU_ADDRESS 0x70013644
	SYMBOL_LINK "CAN1RxData_astruc[2].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[1].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[1].data_au8
	ECU_ADDRESS 0x70013646
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN2RxData_astruc[1].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[1].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[1].numBytes_u8
	ECU_ADDRESS 0x7001364E
	SYMBOL_LINK "CAN2RxData_astruc[1].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[2].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[2].data_au8
	ECU_ADDRESS 0x70013650
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN2RxData_astruc[2].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[2].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[2].numBytes_u8
	ECU_ADDRESS 0x70013658
	SYMBOL_LINK "CAN2RxData_astruc[2].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[3].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[3].data_au8
	ECU_ADDRESS 0x7001365A
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN2RxData_astruc[3].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[3].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[3].numBytes_u8
	ECU_ADDRESS 0x70013662
	SYMBOL_LINK "CAN2RxData_astruc[3].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[4].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[4].data_au8
	ECU_ADDRESS 0x70013664
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN2RxData_astruc[4].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[4].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[4].numBytes_u8
	ECU_ADDRESS 0x7001366C
	SYMBOL_LINK "CAN2RxData_astruc[4].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[5].data_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[5].data_au8
	ECU_ADDRESS 0x7001366E
	ARRAY_SIZE 8
	SYMBOL_LINK "CAN2RxData_astruc[5].data_au8" 0
/end MEASUREMENT


/begin MEASUREMENT CAN2RxData_astruc[5].numBytes_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER CAN2RxData_astruc[5].numBytes_u8
	ECU_ADDRESS 0x70013676
	SYMBOL_LINK "CAN2RxData_astruc[5].numBytes_u8" 0
/end MEASUREMENT


/begin MEASUREMENT sigData_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER sigData_au8
	ECU_ADDRESS 0x70013678
	ARRAY_SIZE 8
	SYMBOL_LINK "sigData_au8" 0
/end MEASUREMENT


/begin MEASUREMENT o_rxActEngPercTq_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER o_rxActEngPercTq_u8
	ECU_ADDRESS 0x70013680
	SYMBOL_LINK "o_rxActEngPercTq_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].prodSdgDataboxNum_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].prodSdgDataboxNum_u16
	ECU_ADDRESS 0x70013B2C
	SYMBOL_LINK "dataJ1939Inst_as[1].prodSdgDataboxNum_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].addClaimInfoFunc_pf ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].addClaimInfoFunc_pf
	ECU_ADDRESS 0x70013B38
	SYMBOL_LINK "dataJ1939Inst_as[1].addClaimInfoFunc_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].DM3func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].DM3func_pf
	ECU_ADDRESS 0x70013BDC
	SYMBOL_LINK "dataJ1939Inst_as[1].DM3func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].DM11func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].DM11func_pf
	ECU_ADDRESS 0x70013BE0
	SYMBOL_LINK "dataJ1939Inst_as[1].DM11func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].ecuLoc_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].ecuLoc_pas8
	ECU_ADDRESS 0x70013BE4
	SYMBOL_LINK "dataJ1939Inst_as[1].ecuLoc_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].ecuType_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].ecuType_pas8
	ECU_ADDRESS 0x70013BE8
	SYMBOL_LINK "dataJ1939Inst_as[1].ecuType_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].ecuMan_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].ecuMan_pas8
	ECU_ADDRESS 0x70013BEC
	SYMBOL_LINK "dataJ1939Inst_as[1].ecuMan_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].applTask_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].applTask_pas8
	ECU_ADDRESS 0x70013BF0
	SYMBOL_LINK "dataJ1939Inst_as[1].applTask_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[1].data_pau8
	ECU_ADDRESS 0x70013BF8
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[1].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[1].func_pf
	ECU_ADDRESS 0x70013BFC
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[1].lenAct_u32
	ECU_ADDRESS 0x70013C04
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[1].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[1].lenRx_u32
	ECU_ADDRESS 0x70013C08
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[1].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[1].lenMax_u32
	ECU_ADDRESS 0x70013C0C
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[1].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[1].timeout_u16
	ECU_ADDRESS 0x70013C10
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[1].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[1].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[1].startTimeout_u16
	ECU_ADDRESS 0x70013C12
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[1].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[1].counter_u16
	ECU_ADDRESS 0x70013C14
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[1].status_u16
	ECU_ADDRESS 0x70013C16
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[1].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[1].action_u16
	ECU_ADDRESS 0x70013C18
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[1].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[1].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[1].internalBox_l
	ECU_ADDRESS 0x70013C1A
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[1].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[2].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[2].data_pau8
	ECU_ADDRESS 0x70013C1C
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[2].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[2].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[2].func_pf
	ECU_ADDRESS 0x70013C20
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[2].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[2].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[2].lenAct_u32
	ECU_ADDRESS 0x70013C28
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[2].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[2].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[2].lenRx_u32
	ECU_ADDRESS 0x70013C2C
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[2].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[2].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[2].lenMax_u32
	ECU_ADDRESS 0x70013C30
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[2].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[2].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[2].timeout_u16
	ECU_ADDRESS 0x70013C34
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[2].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[2].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[2].startTimeout_u16
	ECU_ADDRESS 0x70013C36
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[2].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[2].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[2].counter_u16
	ECU_ADDRESS 0x70013C38
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[2].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[2].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[2].status_u16
	ECU_ADDRESS 0x70013C3A
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[2].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[2].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[2].action_u16
	ECU_ADDRESS 0x70013C3C
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[2].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[2].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[2].internalBox_l
	ECU_ADDRESS 0x70013C3E
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[2].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[3].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[3].data_pau8
	ECU_ADDRESS 0x70013C40
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[3].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[3].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[3].func_pf
	ECU_ADDRESS 0x70013C44
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[3].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[3].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[3].lenAct_u32
	ECU_ADDRESS 0x70013C4C
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[3].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[3].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[3].lenRx_u32
	ECU_ADDRESS 0x70013C50
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[3].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[3].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[3].lenMax_u32
	ECU_ADDRESS 0x70013C54
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[3].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[3].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[3].timeout_u16
	ECU_ADDRESS 0x70013C58
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[3].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[3].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[3].startTimeout_u16
	ECU_ADDRESS 0x70013C5A
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[3].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[3].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[3].counter_u16
	ECU_ADDRESS 0x70013C5C
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[3].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[3].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[3].status_u16
	ECU_ADDRESS 0x70013C5E
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[3].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[3].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[3].action_u16
	ECU_ADDRESS 0x70013C60
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[3].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[3].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[3].internalBox_l
	ECU_ADDRESS 0x70013C62
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[3].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[4].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[4].data_pau8
	ECU_ADDRESS 0x70013C64
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[4].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[4].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[4].func_pf
	ECU_ADDRESS 0x70013C68
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[4].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[4].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[4].lenAct_u32
	ECU_ADDRESS 0x70013C70
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[4].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[4].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[4].lenRx_u32
	ECU_ADDRESS 0x70013C74
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[4].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[4].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[4].lenMax_u32
	ECU_ADDRESS 0x70013C78
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[4].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[4].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[4].timeout_u16
	ECU_ADDRESS 0x70013C7C
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[4].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[4].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[4].startTimeout_u16
	ECU_ADDRESS 0x70013C7E
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[4].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[4].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[4].counter_u16
	ECU_ADDRESS 0x70013C80
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[4].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[4].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[4].status_u16
	ECU_ADDRESS 0x70013C82
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[4].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[4].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[4].action_u16
	ECU_ADDRESS 0x70013C84
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[4].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[4].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[4].internalBox_l
	ECU_ADDRESS 0x70013C86
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[4].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[5].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[5].data_pau8
	ECU_ADDRESS 0x70013C88
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[5].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[5].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[5].func_pf
	ECU_ADDRESS 0x70013C8C
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[5].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[5].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[5].lenAct_u32
	ECU_ADDRESS 0x70013C94
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[5].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[5].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[5].lenRx_u32
	ECU_ADDRESS 0x70013C98
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[5].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[5].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[5].lenMax_u32
	ECU_ADDRESS 0x70013C9C
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[5].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[5].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[5].timeout_u16
	ECU_ADDRESS 0x70013CA0
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[5].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[5].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[5].startTimeout_u16
	ECU_ADDRESS 0x70013CA2
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[5].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[5].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[5].counter_u16
	ECU_ADDRESS 0x70013CA4
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[5].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[5].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[5].status_u16
	ECU_ADDRESS 0x70013CA6
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[5].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[5].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[5].action_u16
	ECU_ADDRESS 0x70013CA8
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[5].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as[5].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as[5].internalBox_l
	ECU_ADDRESS 0x70013CAA
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as[5].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxSysDatabox_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxSysDatabox_as
	ECU_ADDRESS 0x70013BF8
	ARRAY_SIZE 180
	SYMBOL_LINK "dataJ1939Inst_as[1].rxSysDatabox_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].txSysDatabox_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].txSysDatabox_as[1].data_pau8
	ECU_ADDRESS 0x70013CAC
	SYMBOL_LINK "dataJ1939Inst_as[1].txSysDatabox_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].txSysDatabox_as[1].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].txSysDatabox_as[1].func_pf
	ECU_ADDRESS 0x70013CB0
	SYMBOL_LINK "dataJ1939Inst_as[1].txSysDatabox_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].txSysDatabox_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].txSysDatabox_as[1].lenMax_u32
	ECU_ADDRESS 0x70013CB8
	SYMBOL_LINK "dataJ1939Inst_as[1].txSysDatabox_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].txSysDatabox_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].txSysDatabox_as[1].lenAct_u32
	ECU_ADDRESS 0x70013CBC
	SYMBOL_LINK "dataJ1939Inst_as[1].txSysDatabox_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].txSysDatabox_as[1].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].txSysDatabox_as[1].cycle_u16
	ECU_ADDRESS 0x70013CC0
	SYMBOL_LINK "dataJ1939Inst_as[1].txSysDatabox_as[1].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].txSysDatabox_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].txSysDatabox_as[1].counter_u16
	ECU_ADDRESS 0x70013CC2
	SYMBOL_LINK "dataJ1939Inst_as[1].txSysDatabox_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].txSysDatabox_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].txSysDatabox_as[1].status_u16
	ECU_ADDRESS 0x70013CC4
	SYMBOL_LINK "dataJ1939Inst_as[1].txSysDatabox_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].txSysDatabox_as[1].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].txSysDatabox_as[1].aperiodicdatabox_u16
	ECU_ADDRESS 0x70013CC6
	SYMBOL_LINK "dataJ1939Inst_as[1].txSysDatabox_as[1].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].txSysDatabox_as[1].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].txSysDatabox_as[1].periodicdatabox_u16
	ECU_ADDRESS 0x70013CC8
	SYMBOL_LINK "dataJ1939Inst_as[1].txSysDatabox_as[1].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].txSysDatabox_as ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].txSysDatabox_as
	ECU_ADDRESS 0x70013CAC
	ARRAY_SIZE 32
	SYMBOL_LINK "dataJ1939Inst_as[1].txSysDatabox_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxDataRequPgn_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxDataRequPgn_au8
	ECU_ADDRESS 0x70013CCC
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[1].rxDataRequPgn_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxDataAddrClm_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxDataAddrClm_au8
	ECU_ADDRESS 0x70013CD4
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[1].rxDataAddrClm_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxDataCmdAddr_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxDataCmdAddr_au8
	ECU_ADDRESS 0x70013CDC
	ARRAY_SIZE 9
	SYMBOL_LINK "dataJ1939Inst_as[1].rxDataCmdAddr_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxDataNameNmt_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxDataNameNmt_au8
	ECU_ADDRESS 0x70013CE5
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[1].rxDataNameNmt_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].rxDataDm13_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].rxDataDm13_au8
	ECU_ADDRESS 0x70013CED
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[1].rxDataDm13_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].txDataRequPgn_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].txDataRequPgn_au8
	ECU_ADDRESS 0x70013CF5
	ARRAY_SIZE 300
	SYMBOL_LINK "dataJ1939Inst_as[1].txDataRequPgn_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].dm1BuffDat_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].dm1BuffDat_au8
	ECU_ADDRESS 0x70013E21
	ARRAY_SIZE 130
	SYMBOL_LINK "dataJ1939Inst_as[1].dm1BuffDat_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].dm2BuffDat_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].dm2BuffDat_au8
	ECU_ADDRESS 0x70013EA3
	ARRAY_SIZE 130
	SYMBOL_LINK "dataJ1939Inst_as[1].dm2BuffDat_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].caStatus_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].caStatus_u16
	ECU_ADDRESS 0x70013F38
	SYMBOL_LINK "dataJ1939Inst_as[1].caStatus_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].addrClaimTimer_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].addrClaimTimer_u16
	ECU_ADDRESS 0x70013F3A
	SYMBOL_LINK "dataJ1939Inst_as[1].addrClaimTimer_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].taskNxtPeriodicTxIdx_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].taskNxtPeriodicTxIdx_u16
	ECU_ADDRESS 0x70013F3C
	SYMBOL_LINK "dataJ1939Inst_as[1].taskNxtPeriodicTxIdx_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].ownAddr_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].ownAddr_u8
	ECU_ADDRESS 0x70013F3E
	SYMBOL_LINK "dataJ1939Inst_as[1].ownAddr_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].canChannel_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].canChannel_u8
	ECU_ADDRESS 0x70013F3F
	SYMBOL_LINK "dataJ1939Inst_as[1].canChannel_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].nameMngSourceAddr_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].nameMngSourceAddr_u8
	ECU_ADDRESS 0x70013F40
	SYMBOL_LINK "dataJ1939Inst_as[1].nameMngSourceAddr_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].usedDm13Port_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].usedDm13Port_u8
	ECU_ADDRESS 0x70013F41
	SYMBOL_LINK "dataJ1939Inst_as[1].usedDm13Port_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].sendDm1Allowed_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].sendDm1Allowed_l
	ECU_ADDRESS 0x70013F42
	SYMBOL_LINK "dataJ1939Inst_as[1].sendDm1Allowed_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[1].dmLampStateJ1939_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[1].dmLampStateJ1939_l
	ECU_ADDRESS 0x70013F43
	SYMBOL_LINK "dataJ1939Inst_as[1].dmLampStateJ1939_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].prodSdgDataboxNum_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].prodSdgDataboxNum_u16
	ECU_ADDRESS 0x70013F6C
	SYMBOL_LINK "dataJ1939Inst_as[2].prodSdgDataboxNum_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].addClaimInfoFunc_pf ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].addClaimInfoFunc_pf
	ECU_ADDRESS 0x70013F78
	SYMBOL_LINK "dataJ1939Inst_as[2].addClaimInfoFunc_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].DM3func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].DM3func_pf
	ECU_ADDRESS 0x7001401C
	SYMBOL_LINK "dataJ1939Inst_as[2].DM3func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].DM11func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].DM11func_pf
	ECU_ADDRESS 0x70014020
	SYMBOL_LINK "dataJ1939Inst_as[2].DM11func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].ecuLoc_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].ecuLoc_pas8
	ECU_ADDRESS 0x70014024
	SYMBOL_LINK "dataJ1939Inst_as[2].ecuLoc_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].ecuType_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].ecuType_pas8
	ECU_ADDRESS 0x70014028
	SYMBOL_LINK "dataJ1939Inst_as[2].ecuType_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].ecuMan_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].ecuMan_pas8
	ECU_ADDRESS 0x7001402C
	SYMBOL_LINK "dataJ1939Inst_as[2].ecuMan_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].applTask_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].applTask_pas8
	ECU_ADDRESS 0x70014030
	SYMBOL_LINK "dataJ1939Inst_as[2].applTask_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[1].data_pau8
	ECU_ADDRESS 0x70014038
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[1].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[1].func_pf
	ECU_ADDRESS 0x7001403C
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[1].lenAct_u32
	ECU_ADDRESS 0x70014044
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[1].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[1].lenRx_u32
	ECU_ADDRESS 0x70014048
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[1].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[1].lenMax_u32
	ECU_ADDRESS 0x7001404C
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[1].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[1].timeout_u16
	ECU_ADDRESS 0x70014050
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[1].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[1].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[1].startTimeout_u16
	ECU_ADDRESS 0x70014052
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[1].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[1].counter_u16
	ECU_ADDRESS 0x70014054
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[1].status_u16
	ECU_ADDRESS 0x70014056
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[1].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[1].action_u16
	ECU_ADDRESS 0x70014058
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[1].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[1].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[1].internalBox_l
	ECU_ADDRESS 0x7001405A
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[1].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[2].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[2].data_pau8
	ECU_ADDRESS 0x7001405C
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[2].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[2].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[2].func_pf
	ECU_ADDRESS 0x70014060
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[2].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[2].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[2].lenAct_u32
	ECU_ADDRESS 0x70014068
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[2].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[2].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[2].lenRx_u32
	ECU_ADDRESS 0x7001406C
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[2].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[2].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[2].lenMax_u32
	ECU_ADDRESS 0x70014070
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[2].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[2].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[2].timeout_u16
	ECU_ADDRESS 0x70014074
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[2].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[2].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[2].startTimeout_u16
	ECU_ADDRESS 0x70014076
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[2].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[2].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[2].counter_u16
	ECU_ADDRESS 0x70014078
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[2].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[2].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[2].status_u16
	ECU_ADDRESS 0x7001407A
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[2].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[2].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[2].action_u16
	ECU_ADDRESS 0x7001407C
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[2].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[2].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[2].internalBox_l
	ECU_ADDRESS 0x7001407E
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[2].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[3].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[3].data_pau8
	ECU_ADDRESS 0x70014080
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[3].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[3].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[3].func_pf
	ECU_ADDRESS 0x70014084
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[3].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[3].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[3].lenAct_u32
	ECU_ADDRESS 0x7001408C
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[3].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[3].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[3].lenRx_u32
	ECU_ADDRESS 0x70014090
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[3].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[3].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[3].lenMax_u32
	ECU_ADDRESS 0x70014094
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[3].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[3].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[3].timeout_u16
	ECU_ADDRESS 0x70014098
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[3].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[3].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[3].startTimeout_u16
	ECU_ADDRESS 0x7001409A
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[3].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[3].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[3].counter_u16
	ECU_ADDRESS 0x7001409C
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[3].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[3].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[3].status_u16
	ECU_ADDRESS 0x7001409E
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[3].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[3].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[3].action_u16
	ECU_ADDRESS 0x700140A0
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[3].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[3].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[3].internalBox_l
	ECU_ADDRESS 0x700140A2
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[3].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[4].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[4].data_pau8
	ECU_ADDRESS 0x700140A4
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[4].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[4].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[4].func_pf
	ECU_ADDRESS 0x700140A8
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[4].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[4].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[4].lenAct_u32
	ECU_ADDRESS 0x700140B0
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[4].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[4].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[4].lenRx_u32
	ECU_ADDRESS 0x700140B4
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[4].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[4].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[4].lenMax_u32
	ECU_ADDRESS 0x700140B8
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[4].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[4].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[4].timeout_u16
	ECU_ADDRESS 0x700140BC
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[4].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[4].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[4].startTimeout_u16
	ECU_ADDRESS 0x700140BE
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[4].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[4].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[4].counter_u16
	ECU_ADDRESS 0x700140C0
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[4].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[4].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[4].status_u16
	ECU_ADDRESS 0x700140C2
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[4].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[4].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[4].action_u16
	ECU_ADDRESS 0x700140C4
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[4].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[4].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[4].internalBox_l
	ECU_ADDRESS 0x700140C6
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[4].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[5].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[5].data_pau8
	ECU_ADDRESS 0x700140C8
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[5].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[5].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[5].func_pf
	ECU_ADDRESS 0x700140CC
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[5].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[5].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[5].lenAct_u32
	ECU_ADDRESS 0x700140D4
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[5].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[5].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[5].lenRx_u32
	ECU_ADDRESS 0x700140D8
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[5].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[5].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[5].lenMax_u32
	ECU_ADDRESS 0x700140DC
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[5].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[5].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[5].timeout_u16
	ECU_ADDRESS 0x700140E0
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[5].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[5].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[5].startTimeout_u16
	ECU_ADDRESS 0x700140E2
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[5].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[5].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[5].counter_u16
	ECU_ADDRESS 0x700140E4
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[5].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[5].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[5].status_u16
	ECU_ADDRESS 0x700140E6
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[5].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[5].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[5].action_u16
	ECU_ADDRESS 0x700140E8
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[5].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as[5].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as[5].internalBox_l
	ECU_ADDRESS 0x700140EA
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as[5].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxSysDatabox_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxSysDatabox_as
	ECU_ADDRESS 0x70014038
	ARRAY_SIZE 180
	SYMBOL_LINK "dataJ1939Inst_as[2].rxSysDatabox_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].txSysDatabox_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].txSysDatabox_as[1].data_pau8
	ECU_ADDRESS 0x700140EC
	SYMBOL_LINK "dataJ1939Inst_as[2].txSysDatabox_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].txSysDatabox_as[1].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].txSysDatabox_as[1].func_pf
	ECU_ADDRESS 0x700140F0
	SYMBOL_LINK "dataJ1939Inst_as[2].txSysDatabox_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].txSysDatabox_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].txSysDatabox_as[1].lenMax_u32
	ECU_ADDRESS 0x700140F8
	SYMBOL_LINK "dataJ1939Inst_as[2].txSysDatabox_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].txSysDatabox_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].txSysDatabox_as[1].lenAct_u32
	ECU_ADDRESS 0x700140FC
	SYMBOL_LINK "dataJ1939Inst_as[2].txSysDatabox_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].txSysDatabox_as[1].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].txSysDatabox_as[1].cycle_u16
	ECU_ADDRESS 0x70014100
	SYMBOL_LINK "dataJ1939Inst_as[2].txSysDatabox_as[1].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].txSysDatabox_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].txSysDatabox_as[1].counter_u16
	ECU_ADDRESS 0x70014102
	SYMBOL_LINK "dataJ1939Inst_as[2].txSysDatabox_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].txSysDatabox_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].txSysDatabox_as[1].status_u16
	ECU_ADDRESS 0x70014104
	SYMBOL_LINK "dataJ1939Inst_as[2].txSysDatabox_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].txSysDatabox_as[1].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].txSysDatabox_as[1].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014106
	SYMBOL_LINK "dataJ1939Inst_as[2].txSysDatabox_as[1].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].txSysDatabox_as[1].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].txSysDatabox_as[1].periodicdatabox_u16
	ECU_ADDRESS 0x70014108
	SYMBOL_LINK "dataJ1939Inst_as[2].txSysDatabox_as[1].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].txSysDatabox_as ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].txSysDatabox_as
	ECU_ADDRESS 0x700140EC
	ARRAY_SIZE 32
	SYMBOL_LINK "dataJ1939Inst_as[2].txSysDatabox_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxDataRequPgn_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxDataRequPgn_au8
	ECU_ADDRESS 0x7001410C
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[2].rxDataRequPgn_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxDataAddrClm_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxDataAddrClm_au8
	ECU_ADDRESS 0x70014114
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[2].rxDataAddrClm_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxDataCmdAddr_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxDataCmdAddr_au8
	ECU_ADDRESS 0x7001411C
	ARRAY_SIZE 9
	SYMBOL_LINK "dataJ1939Inst_as[2].rxDataCmdAddr_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxDataNameNmt_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxDataNameNmt_au8
	ECU_ADDRESS 0x70014125
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[2].rxDataNameNmt_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].rxDataDm13_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].rxDataDm13_au8
	ECU_ADDRESS 0x7001412D
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[2].rxDataDm13_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].txDataRequPgn_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].txDataRequPgn_au8
	ECU_ADDRESS 0x70014135
	ARRAY_SIZE 300
	SYMBOL_LINK "dataJ1939Inst_as[2].txDataRequPgn_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].dm1BuffDat_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].dm1BuffDat_au8
	ECU_ADDRESS 0x70014261
	ARRAY_SIZE 130
	SYMBOL_LINK "dataJ1939Inst_as[2].dm1BuffDat_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].dm2BuffDat_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].dm2BuffDat_au8
	ECU_ADDRESS 0x700142E3
	ARRAY_SIZE 130
	SYMBOL_LINK "dataJ1939Inst_as[2].dm2BuffDat_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].caStatus_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].caStatus_u16
	ECU_ADDRESS 0x70014378
	SYMBOL_LINK "dataJ1939Inst_as[2].caStatus_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].addrClaimTimer_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].addrClaimTimer_u16
	ECU_ADDRESS 0x7001437A
	SYMBOL_LINK "dataJ1939Inst_as[2].addrClaimTimer_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].taskNxtPeriodicTxIdx_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].taskNxtPeriodicTxIdx_u16
	ECU_ADDRESS 0x7001437C
	SYMBOL_LINK "dataJ1939Inst_as[2].taskNxtPeriodicTxIdx_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].ownAddr_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].ownAddr_u8
	ECU_ADDRESS 0x7001437E
	SYMBOL_LINK "dataJ1939Inst_as[2].ownAddr_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].canChannel_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].canChannel_u8
	ECU_ADDRESS 0x7001437F
	SYMBOL_LINK "dataJ1939Inst_as[2].canChannel_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].nameMngSourceAddr_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].nameMngSourceAddr_u8
	ECU_ADDRESS 0x70014380
	SYMBOL_LINK "dataJ1939Inst_as[2].nameMngSourceAddr_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].usedDm13Port_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].usedDm13Port_u8
	ECU_ADDRESS 0x70014381
	SYMBOL_LINK "dataJ1939Inst_as[2].usedDm13Port_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].sendDm1Allowed_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].sendDm1Allowed_l
	ECU_ADDRESS 0x70014382
	SYMBOL_LINK "dataJ1939Inst_as[2].sendDm1Allowed_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[2].dmLampStateJ1939_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[2].dmLampStateJ1939_l
	ECU_ADDRESS 0x70014383
	SYMBOL_LINK "dataJ1939Inst_as[2].dmLampStateJ1939_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].prodSdgDataboxNum_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].prodSdgDataboxNum_u16
	ECU_ADDRESS 0x700143AC
	SYMBOL_LINK "dataJ1939Inst_as[3].prodSdgDataboxNum_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].addClaimInfoFunc_pf ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].addClaimInfoFunc_pf
	ECU_ADDRESS 0x700143B8
	SYMBOL_LINK "dataJ1939Inst_as[3].addClaimInfoFunc_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].DM3func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].DM3func_pf
	ECU_ADDRESS 0x7001445C
	SYMBOL_LINK "dataJ1939Inst_as[3].DM3func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].DM11func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].DM11func_pf
	ECU_ADDRESS 0x70014460
	SYMBOL_LINK "dataJ1939Inst_as[3].DM11func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].ecuLoc_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].ecuLoc_pas8
	ECU_ADDRESS 0x70014464
	SYMBOL_LINK "dataJ1939Inst_as[3].ecuLoc_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].ecuType_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].ecuType_pas8
	ECU_ADDRESS 0x70014468
	SYMBOL_LINK "dataJ1939Inst_as[3].ecuType_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].ecuMan_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].ecuMan_pas8
	ECU_ADDRESS 0x7001446C
	SYMBOL_LINK "dataJ1939Inst_as[3].ecuMan_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].applTask_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].applTask_pas8
	ECU_ADDRESS 0x70014470
	SYMBOL_LINK "dataJ1939Inst_as[3].applTask_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[1].data_pau8
	ECU_ADDRESS 0x70014478
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[1].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[1].func_pf
	ECU_ADDRESS 0x7001447C
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[1].lenAct_u32
	ECU_ADDRESS 0x70014484
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[1].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[1].lenRx_u32
	ECU_ADDRESS 0x70014488
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[1].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[1].lenMax_u32
	ECU_ADDRESS 0x7001448C
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[1].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[1].timeout_u16
	ECU_ADDRESS 0x70014490
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[1].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[1].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[1].startTimeout_u16
	ECU_ADDRESS 0x70014492
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[1].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[1].counter_u16
	ECU_ADDRESS 0x70014494
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[1].status_u16
	ECU_ADDRESS 0x70014496
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[1].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[1].action_u16
	ECU_ADDRESS 0x70014498
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[1].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[1].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[1].internalBox_l
	ECU_ADDRESS 0x7001449A
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[1].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[2].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[2].data_pau8
	ECU_ADDRESS 0x7001449C
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[2].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[2].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[2].func_pf
	ECU_ADDRESS 0x700144A0
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[2].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[2].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[2].lenAct_u32
	ECU_ADDRESS 0x700144A8
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[2].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[2].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[2].lenRx_u32
	ECU_ADDRESS 0x700144AC
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[2].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[2].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[2].lenMax_u32
	ECU_ADDRESS 0x700144B0
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[2].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[2].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[2].timeout_u16
	ECU_ADDRESS 0x700144B4
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[2].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[2].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[2].startTimeout_u16
	ECU_ADDRESS 0x700144B6
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[2].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[2].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[2].counter_u16
	ECU_ADDRESS 0x700144B8
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[2].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[2].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[2].status_u16
	ECU_ADDRESS 0x700144BA
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[2].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[2].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[2].action_u16
	ECU_ADDRESS 0x700144BC
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[2].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[2].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[2].internalBox_l
	ECU_ADDRESS 0x700144BE
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[2].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[3].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[3].data_pau8
	ECU_ADDRESS 0x700144C0
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[3].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[3].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[3].func_pf
	ECU_ADDRESS 0x700144C4
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[3].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[3].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[3].lenAct_u32
	ECU_ADDRESS 0x700144CC
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[3].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[3].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[3].lenRx_u32
	ECU_ADDRESS 0x700144D0
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[3].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[3].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[3].lenMax_u32
	ECU_ADDRESS 0x700144D4
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[3].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[3].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[3].timeout_u16
	ECU_ADDRESS 0x700144D8
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[3].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[3].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[3].startTimeout_u16
	ECU_ADDRESS 0x700144DA
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[3].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[3].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[3].counter_u16
	ECU_ADDRESS 0x700144DC
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[3].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[3].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[3].status_u16
	ECU_ADDRESS 0x700144DE
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[3].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[3].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[3].action_u16
	ECU_ADDRESS 0x700144E0
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[3].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[3].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[3].internalBox_l
	ECU_ADDRESS 0x700144E2
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[3].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[4].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[4].data_pau8
	ECU_ADDRESS 0x700144E4
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[4].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[4].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[4].func_pf
	ECU_ADDRESS 0x700144E8
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[4].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[4].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[4].lenAct_u32
	ECU_ADDRESS 0x700144F0
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[4].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[4].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[4].lenRx_u32
	ECU_ADDRESS 0x700144F4
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[4].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[4].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[4].lenMax_u32
	ECU_ADDRESS 0x700144F8
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[4].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[4].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[4].timeout_u16
	ECU_ADDRESS 0x700144FC
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[4].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[4].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[4].startTimeout_u16
	ECU_ADDRESS 0x700144FE
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[4].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[4].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[4].counter_u16
	ECU_ADDRESS 0x70014500
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[4].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[4].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[4].status_u16
	ECU_ADDRESS 0x70014502
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[4].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[4].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[4].action_u16
	ECU_ADDRESS 0x70014504
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[4].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[4].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[4].internalBox_l
	ECU_ADDRESS 0x70014506
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[4].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[5].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[5].data_pau8
	ECU_ADDRESS 0x70014508
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[5].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[5].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[5].func_pf
	ECU_ADDRESS 0x7001450C
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[5].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[5].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[5].lenAct_u32
	ECU_ADDRESS 0x70014514
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[5].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[5].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[5].lenRx_u32
	ECU_ADDRESS 0x70014518
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[5].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[5].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[5].lenMax_u32
	ECU_ADDRESS 0x7001451C
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[5].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[5].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[5].timeout_u16
	ECU_ADDRESS 0x70014520
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[5].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[5].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[5].startTimeout_u16
	ECU_ADDRESS 0x70014522
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[5].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[5].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[5].counter_u16
	ECU_ADDRESS 0x70014524
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[5].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[5].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[5].status_u16
	ECU_ADDRESS 0x70014526
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[5].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[5].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[5].action_u16
	ECU_ADDRESS 0x70014528
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[5].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as[5].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as[5].internalBox_l
	ECU_ADDRESS 0x7001452A
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as[5].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxSysDatabox_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxSysDatabox_as
	ECU_ADDRESS 0x70014478
	ARRAY_SIZE 180
	SYMBOL_LINK "dataJ1939Inst_as[3].rxSysDatabox_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].txSysDatabox_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].txSysDatabox_as[1].data_pau8
	ECU_ADDRESS 0x7001452C
	SYMBOL_LINK "dataJ1939Inst_as[3].txSysDatabox_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].txSysDatabox_as[1].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].txSysDatabox_as[1].func_pf
	ECU_ADDRESS 0x70014530
	SYMBOL_LINK "dataJ1939Inst_as[3].txSysDatabox_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].txSysDatabox_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].txSysDatabox_as[1].lenMax_u32
	ECU_ADDRESS 0x70014538
	SYMBOL_LINK "dataJ1939Inst_as[3].txSysDatabox_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].txSysDatabox_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].txSysDatabox_as[1].lenAct_u32
	ECU_ADDRESS 0x7001453C
	SYMBOL_LINK "dataJ1939Inst_as[3].txSysDatabox_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].txSysDatabox_as[1].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].txSysDatabox_as[1].cycle_u16
	ECU_ADDRESS 0x70014540
	SYMBOL_LINK "dataJ1939Inst_as[3].txSysDatabox_as[1].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].txSysDatabox_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].txSysDatabox_as[1].counter_u16
	ECU_ADDRESS 0x70014542
	SYMBOL_LINK "dataJ1939Inst_as[3].txSysDatabox_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].txSysDatabox_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].txSysDatabox_as[1].status_u16
	ECU_ADDRESS 0x70014544
	SYMBOL_LINK "dataJ1939Inst_as[3].txSysDatabox_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].txSysDatabox_as[1].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].txSysDatabox_as[1].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014546
	SYMBOL_LINK "dataJ1939Inst_as[3].txSysDatabox_as[1].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].txSysDatabox_as[1].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].txSysDatabox_as[1].periodicdatabox_u16
	ECU_ADDRESS 0x70014548
	SYMBOL_LINK "dataJ1939Inst_as[3].txSysDatabox_as[1].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].txSysDatabox_as ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].txSysDatabox_as
	ECU_ADDRESS 0x7001452C
	ARRAY_SIZE 32
	SYMBOL_LINK "dataJ1939Inst_as[3].txSysDatabox_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxDataRequPgn_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxDataRequPgn_au8
	ECU_ADDRESS 0x7001454C
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[3].rxDataRequPgn_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxDataAddrClm_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxDataAddrClm_au8
	ECU_ADDRESS 0x70014554
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[3].rxDataAddrClm_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxDataCmdAddr_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxDataCmdAddr_au8
	ECU_ADDRESS 0x7001455C
	ARRAY_SIZE 9
	SYMBOL_LINK "dataJ1939Inst_as[3].rxDataCmdAddr_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxDataNameNmt_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxDataNameNmt_au8
	ECU_ADDRESS 0x70014565
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[3].rxDataNameNmt_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].rxDataDm13_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].rxDataDm13_au8
	ECU_ADDRESS 0x7001456D
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[3].rxDataDm13_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].txDataRequPgn_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].txDataRequPgn_au8
	ECU_ADDRESS 0x70014575
	ARRAY_SIZE 300
	SYMBOL_LINK "dataJ1939Inst_as[3].txDataRequPgn_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].dm1BuffDat_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].dm1BuffDat_au8
	ECU_ADDRESS 0x700146A1
	ARRAY_SIZE 130
	SYMBOL_LINK "dataJ1939Inst_as[3].dm1BuffDat_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].dm2BuffDat_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].dm2BuffDat_au8
	ECU_ADDRESS 0x70014723
	ARRAY_SIZE 130
	SYMBOL_LINK "dataJ1939Inst_as[3].dm2BuffDat_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].caStatus_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].caStatus_u16
	ECU_ADDRESS 0x700147B8
	SYMBOL_LINK "dataJ1939Inst_as[3].caStatus_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].addrClaimTimer_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].addrClaimTimer_u16
	ECU_ADDRESS 0x700147BA
	SYMBOL_LINK "dataJ1939Inst_as[3].addrClaimTimer_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].taskNxtPeriodicTxIdx_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].taskNxtPeriodicTxIdx_u16
	ECU_ADDRESS 0x700147BC
	SYMBOL_LINK "dataJ1939Inst_as[3].taskNxtPeriodicTxIdx_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].ownAddr_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].ownAddr_u8
	ECU_ADDRESS 0x700147BE
	SYMBOL_LINK "dataJ1939Inst_as[3].ownAddr_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].canChannel_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].canChannel_u8
	ECU_ADDRESS 0x700147BF
	SYMBOL_LINK "dataJ1939Inst_as[3].canChannel_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].nameMngSourceAddr_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].nameMngSourceAddr_u8
	ECU_ADDRESS 0x700147C0
	SYMBOL_LINK "dataJ1939Inst_as[3].nameMngSourceAddr_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].usedDm13Port_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].usedDm13Port_u8
	ECU_ADDRESS 0x700147C1
	SYMBOL_LINK "dataJ1939Inst_as[3].usedDm13Port_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].sendDm1Allowed_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].sendDm1Allowed_l
	ECU_ADDRESS 0x700147C2
	SYMBOL_LINK "dataJ1939Inst_as[3].sendDm1Allowed_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[3].dmLampStateJ1939_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[3].dmLampStateJ1939_l
	ECU_ADDRESS 0x700147C3
	SYMBOL_LINK "dataJ1939Inst_as[3].dmLampStateJ1939_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].prodSdgDataboxNum_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].prodSdgDataboxNum_u16
	ECU_ADDRESS 0x700147EC
	SYMBOL_LINK "dataJ1939Inst_as[4].prodSdgDataboxNum_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].addClaimInfoFunc_pf ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].addClaimInfoFunc_pf
	ECU_ADDRESS 0x700147F8
	SYMBOL_LINK "dataJ1939Inst_as[4].addClaimInfoFunc_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].DM3func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].DM3func_pf
	ECU_ADDRESS 0x7001489C
	SYMBOL_LINK "dataJ1939Inst_as[4].DM3func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].DM11func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].DM11func_pf
	ECU_ADDRESS 0x700148A0
	SYMBOL_LINK "dataJ1939Inst_as[4].DM11func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].ecuLoc_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].ecuLoc_pas8
	ECU_ADDRESS 0x700148A4
	SYMBOL_LINK "dataJ1939Inst_as[4].ecuLoc_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].ecuType_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].ecuType_pas8
	ECU_ADDRESS 0x700148A8
	SYMBOL_LINK "dataJ1939Inst_as[4].ecuType_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].ecuMan_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].ecuMan_pas8
	ECU_ADDRESS 0x700148AC
	SYMBOL_LINK "dataJ1939Inst_as[4].ecuMan_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].applTask_pas8 ""
	SBYTE CnvRule_NumberOneToOne 1 0 -128 127
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].applTask_pas8
	ECU_ADDRESS 0x700148B0
	SYMBOL_LINK "dataJ1939Inst_as[4].applTask_pas8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[1].data_pau8
	ECU_ADDRESS 0x700148B8
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[1].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[1].func_pf
	ECU_ADDRESS 0x700148BC
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[1].lenAct_u32
	ECU_ADDRESS 0x700148C4
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[1].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[1].lenRx_u32
	ECU_ADDRESS 0x700148C8
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[1].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[1].lenMax_u32
	ECU_ADDRESS 0x700148CC
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[1].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[1].timeout_u16
	ECU_ADDRESS 0x700148D0
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[1].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[1].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[1].startTimeout_u16
	ECU_ADDRESS 0x700148D2
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[1].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[1].counter_u16
	ECU_ADDRESS 0x700148D4
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[1].status_u16
	ECU_ADDRESS 0x700148D6
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[1].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[1].action_u16
	ECU_ADDRESS 0x700148D8
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[1].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[1].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[1].internalBox_l
	ECU_ADDRESS 0x700148DA
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[1].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[2].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[2].data_pau8
	ECU_ADDRESS 0x700148DC
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[2].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[2].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[2].func_pf
	ECU_ADDRESS 0x700148E0
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[2].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[2].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[2].lenAct_u32
	ECU_ADDRESS 0x700148E8
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[2].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[2].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[2].lenRx_u32
	ECU_ADDRESS 0x700148EC
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[2].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[2].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[2].lenMax_u32
	ECU_ADDRESS 0x700148F0
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[2].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[2].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[2].timeout_u16
	ECU_ADDRESS 0x700148F4
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[2].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[2].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[2].startTimeout_u16
	ECU_ADDRESS 0x700148F6
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[2].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[2].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[2].counter_u16
	ECU_ADDRESS 0x700148F8
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[2].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[2].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[2].status_u16
	ECU_ADDRESS 0x700148FA
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[2].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[2].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[2].action_u16
	ECU_ADDRESS 0x700148FC
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[2].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[2].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[2].internalBox_l
	ECU_ADDRESS 0x700148FE
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[2].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[3].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[3].data_pau8
	ECU_ADDRESS 0x70014900
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[3].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[3].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[3].func_pf
	ECU_ADDRESS 0x70014904
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[3].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[3].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[3].lenAct_u32
	ECU_ADDRESS 0x7001490C
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[3].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[3].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[3].lenRx_u32
	ECU_ADDRESS 0x70014910
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[3].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[3].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[3].lenMax_u32
	ECU_ADDRESS 0x70014914
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[3].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[3].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[3].timeout_u16
	ECU_ADDRESS 0x70014918
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[3].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[3].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[3].startTimeout_u16
	ECU_ADDRESS 0x7001491A
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[3].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[3].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[3].counter_u16
	ECU_ADDRESS 0x7001491C
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[3].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[3].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[3].status_u16
	ECU_ADDRESS 0x7001491E
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[3].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[3].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[3].action_u16
	ECU_ADDRESS 0x70014920
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[3].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[3].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[3].internalBox_l
	ECU_ADDRESS 0x70014922
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[3].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[4].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[4].data_pau8
	ECU_ADDRESS 0x70014924
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[4].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[4].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[4].func_pf
	ECU_ADDRESS 0x70014928
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[4].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[4].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[4].lenAct_u32
	ECU_ADDRESS 0x70014930
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[4].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[4].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[4].lenRx_u32
	ECU_ADDRESS 0x70014934
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[4].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[4].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[4].lenMax_u32
	ECU_ADDRESS 0x70014938
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[4].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[4].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[4].timeout_u16
	ECU_ADDRESS 0x7001493C
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[4].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[4].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[4].startTimeout_u16
	ECU_ADDRESS 0x7001493E
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[4].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[4].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[4].counter_u16
	ECU_ADDRESS 0x70014940
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[4].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[4].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[4].status_u16
	ECU_ADDRESS 0x70014942
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[4].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[4].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[4].action_u16
	ECU_ADDRESS 0x70014944
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[4].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[4].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[4].internalBox_l
	ECU_ADDRESS 0x70014946
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[4].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[5].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[5].data_pau8
	ECU_ADDRESS 0x70014948
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[5].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[5].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[5].func_pf
	ECU_ADDRESS 0x7001494C
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[5].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[5].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[5].lenAct_u32
	ECU_ADDRESS 0x70014954
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[5].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[5].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[5].lenRx_u32
	ECU_ADDRESS 0x70014958
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[5].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[5].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[5].lenMax_u32
	ECU_ADDRESS 0x7001495C
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[5].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[5].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[5].timeout_u16
	ECU_ADDRESS 0x70014960
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[5].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[5].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[5].startTimeout_u16
	ECU_ADDRESS 0x70014962
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[5].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[5].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[5].counter_u16
	ECU_ADDRESS 0x70014964
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[5].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[5].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[5].status_u16
	ECU_ADDRESS 0x70014966
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[5].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[5].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[5].action_u16
	ECU_ADDRESS 0x70014968
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[5].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as[5].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as[5].internalBox_l
	ECU_ADDRESS 0x7001496A
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as[5].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxSysDatabox_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxSysDatabox_as
	ECU_ADDRESS 0x700148B8
	ARRAY_SIZE 180
	SYMBOL_LINK "dataJ1939Inst_as[4].rxSysDatabox_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].txSysDatabox_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].txSysDatabox_as[1].data_pau8
	ECU_ADDRESS 0x7001496C
	SYMBOL_LINK "dataJ1939Inst_as[4].txSysDatabox_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].txSysDatabox_as[1].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].txSysDatabox_as[1].func_pf
	ECU_ADDRESS 0x70014970
	SYMBOL_LINK "dataJ1939Inst_as[4].txSysDatabox_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].txSysDatabox_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].txSysDatabox_as[1].lenMax_u32
	ECU_ADDRESS 0x70014978
	SYMBOL_LINK "dataJ1939Inst_as[4].txSysDatabox_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].txSysDatabox_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].txSysDatabox_as[1].lenAct_u32
	ECU_ADDRESS 0x7001497C
	SYMBOL_LINK "dataJ1939Inst_as[4].txSysDatabox_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].txSysDatabox_as[1].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].txSysDatabox_as[1].cycle_u16
	ECU_ADDRESS 0x70014980
	SYMBOL_LINK "dataJ1939Inst_as[4].txSysDatabox_as[1].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].txSysDatabox_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].txSysDatabox_as[1].counter_u16
	ECU_ADDRESS 0x70014982
	SYMBOL_LINK "dataJ1939Inst_as[4].txSysDatabox_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].txSysDatabox_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].txSysDatabox_as[1].status_u16
	ECU_ADDRESS 0x70014984
	SYMBOL_LINK "dataJ1939Inst_as[4].txSysDatabox_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].txSysDatabox_as[1].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].txSysDatabox_as[1].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014986
	SYMBOL_LINK "dataJ1939Inst_as[4].txSysDatabox_as[1].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].txSysDatabox_as[1].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].txSysDatabox_as[1].periodicdatabox_u16
	ECU_ADDRESS 0x70014988
	SYMBOL_LINK "dataJ1939Inst_as[4].txSysDatabox_as[1].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].txSysDatabox_as ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].txSysDatabox_as
	ECU_ADDRESS 0x7001496C
	ARRAY_SIZE 32
	SYMBOL_LINK "dataJ1939Inst_as[4].txSysDatabox_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxDataRequPgn_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxDataRequPgn_au8
	ECU_ADDRESS 0x7001498C
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[4].rxDataRequPgn_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxDataAddrClm_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxDataAddrClm_au8
	ECU_ADDRESS 0x70014994
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[4].rxDataAddrClm_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxDataCmdAddr_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxDataCmdAddr_au8
	ECU_ADDRESS 0x7001499C
	ARRAY_SIZE 9
	SYMBOL_LINK "dataJ1939Inst_as[4].rxDataCmdAddr_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxDataNameNmt_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxDataNameNmt_au8
	ECU_ADDRESS 0x700149A5
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[4].rxDataNameNmt_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].rxDataDm13_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].rxDataDm13_au8
	ECU_ADDRESS 0x700149AD
	ARRAY_SIZE 8
	SYMBOL_LINK "dataJ1939Inst_as[4].rxDataDm13_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].txDataRequPgn_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].txDataRequPgn_au8
	ECU_ADDRESS 0x700149B5
	ARRAY_SIZE 300
	SYMBOL_LINK "dataJ1939Inst_as[4].txDataRequPgn_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].dm1BuffDat_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].dm1BuffDat_au8
	ECU_ADDRESS 0x70014AE1
	ARRAY_SIZE 130
	SYMBOL_LINK "dataJ1939Inst_as[4].dm1BuffDat_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].dm2BuffDat_au8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].dm2BuffDat_au8
	ECU_ADDRESS 0x70014B63
	ARRAY_SIZE 130
	SYMBOL_LINK "dataJ1939Inst_as[4].dm2BuffDat_au8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].caStatus_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].caStatus_u16
	ECU_ADDRESS 0x70014BF8
	SYMBOL_LINK "dataJ1939Inst_as[4].caStatus_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].addrClaimTimer_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].addrClaimTimer_u16
	ECU_ADDRESS 0x70014BFA
	SYMBOL_LINK "dataJ1939Inst_as[4].addrClaimTimer_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].taskNxtPeriodicTxIdx_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].taskNxtPeriodicTxIdx_u16
	ECU_ADDRESS 0x70014BFC
	SYMBOL_LINK "dataJ1939Inst_as[4].taskNxtPeriodicTxIdx_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].ownAddr_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].ownAddr_u8
	ECU_ADDRESS 0x70014BFE
	SYMBOL_LINK "dataJ1939Inst_as[4].ownAddr_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].canChannel_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].canChannel_u8
	ECU_ADDRESS 0x70014BFF
	SYMBOL_LINK "dataJ1939Inst_as[4].canChannel_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].nameMngSourceAddr_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].nameMngSourceAddr_u8
	ECU_ADDRESS 0x70014C00
	SYMBOL_LINK "dataJ1939Inst_as[4].nameMngSourceAddr_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].usedDm13Port_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].usedDm13Port_u8
	ECU_ADDRESS 0x70014C01
	SYMBOL_LINK "dataJ1939Inst_as[4].usedDm13Port_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].sendDm1Allowed_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].sendDm1Allowed_l
	ECU_ADDRESS 0x70014C02
	SYMBOL_LINK "dataJ1939Inst_as[4].sendDm1Allowed_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Inst_as[4].dmLampStateJ1939_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataJ1939Inst_as[4].dmLampStateJ1939_l
	ECU_ADDRESS 0x70014C03
	SYMBOL_LINK "dataJ1939Inst_as[4].dmLampStateJ1939_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[1].data_pau8
	ECU_ADDRESS 0x70014C0C
	SYMBOL_LINK "dataTxBufDataBoxes1_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[1].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[1].func_pf
	ECU_ADDRESS 0x70014C10
	SYMBOL_LINK "dataTxBufDataBoxes1_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[1].lenMax_u32
	ECU_ADDRESS 0x70014C18
	SYMBOL_LINK "dataTxBufDataBoxes1_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[1].lenAct_u32
	ECU_ADDRESS 0x70014C1C
	SYMBOL_LINK "dataTxBufDataBoxes1_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[1].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[1].cycle_u16
	ECU_ADDRESS 0x70014C20
	SYMBOL_LINK "dataTxBufDataBoxes1_as[1].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[1].counter_u16
	ECU_ADDRESS 0x70014C22
	SYMBOL_LINK "dataTxBufDataBoxes1_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[1].status_u16
	ECU_ADDRESS 0x70014C24
	SYMBOL_LINK "dataTxBufDataBoxes1_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[1].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[1].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014C26
	SYMBOL_LINK "dataTxBufDataBoxes1_as[1].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[1].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[1].periodicdatabox_u16
	ECU_ADDRESS 0x70014C28
	SYMBOL_LINK "dataTxBufDataBoxes1_as[1].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[2].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[2].data_pau8
	ECU_ADDRESS 0x70014C2C
	SYMBOL_LINK "dataTxBufDataBoxes1_as[2].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[2].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[2].func_pf
	ECU_ADDRESS 0x70014C30
	SYMBOL_LINK "dataTxBufDataBoxes1_as[2].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[2].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[2].lenMax_u32
	ECU_ADDRESS 0x70014C38
	SYMBOL_LINK "dataTxBufDataBoxes1_as[2].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[2].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[2].lenAct_u32
	ECU_ADDRESS 0x70014C3C
	SYMBOL_LINK "dataTxBufDataBoxes1_as[2].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[2].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[2].cycle_u16
	ECU_ADDRESS 0x70014C40
	SYMBOL_LINK "dataTxBufDataBoxes1_as[2].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[2].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[2].counter_u16
	ECU_ADDRESS 0x70014C42
	SYMBOL_LINK "dataTxBufDataBoxes1_as[2].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[2].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[2].status_u16
	ECU_ADDRESS 0x70014C44
	SYMBOL_LINK "dataTxBufDataBoxes1_as[2].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[2].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[2].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014C46
	SYMBOL_LINK "dataTxBufDataBoxes1_as[2].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[2].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[2].periodicdatabox_u16
	ECU_ADDRESS 0x70014C48
	SYMBOL_LINK "dataTxBufDataBoxes1_as[2].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[3].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[3].data_pau8
	ECU_ADDRESS 0x70014C4C
	SYMBOL_LINK "dataTxBufDataBoxes1_as[3].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[3].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[3].func_pf
	ECU_ADDRESS 0x70014C50
	SYMBOL_LINK "dataTxBufDataBoxes1_as[3].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[3].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[3].lenMax_u32
	ECU_ADDRESS 0x70014C58
	SYMBOL_LINK "dataTxBufDataBoxes1_as[3].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[3].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[3].lenAct_u32
	ECU_ADDRESS 0x70014C5C
	SYMBOL_LINK "dataTxBufDataBoxes1_as[3].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[3].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[3].cycle_u16
	ECU_ADDRESS 0x70014C60
	SYMBOL_LINK "dataTxBufDataBoxes1_as[3].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[3].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[3].counter_u16
	ECU_ADDRESS 0x70014C62
	SYMBOL_LINK "dataTxBufDataBoxes1_as[3].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[3].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[3].status_u16
	ECU_ADDRESS 0x70014C64
	SYMBOL_LINK "dataTxBufDataBoxes1_as[3].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[3].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[3].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014C66
	SYMBOL_LINK "dataTxBufDataBoxes1_as[3].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[3].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[3].periodicdatabox_u16
	ECU_ADDRESS 0x70014C68
	SYMBOL_LINK "dataTxBufDataBoxes1_as[3].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[4].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[4].data_pau8
	ECU_ADDRESS 0x70014C6C
	SYMBOL_LINK "dataTxBufDataBoxes1_as[4].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[4].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[4].func_pf
	ECU_ADDRESS 0x70014C70
	SYMBOL_LINK "dataTxBufDataBoxes1_as[4].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[4].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[4].lenMax_u32
	ECU_ADDRESS 0x70014C78
	SYMBOL_LINK "dataTxBufDataBoxes1_as[4].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[4].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[4].lenAct_u32
	ECU_ADDRESS 0x70014C7C
	SYMBOL_LINK "dataTxBufDataBoxes1_as[4].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[4].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[4].cycle_u16
	ECU_ADDRESS 0x70014C80
	SYMBOL_LINK "dataTxBufDataBoxes1_as[4].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[4].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[4].counter_u16
	ECU_ADDRESS 0x70014C82
	SYMBOL_LINK "dataTxBufDataBoxes1_as[4].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[4].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[4].status_u16
	ECU_ADDRESS 0x70014C84
	SYMBOL_LINK "dataTxBufDataBoxes1_as[4].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[4].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[4].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014C86
	SYMBOL_LINK "dataTxBufDataBoxes1_as[4].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[4].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[4].periodicdatabox_u16
	ECU_ADDRESS 0x70014C88
	SYMBOL_LINK "dataTxBufDataBoxes1_as[4].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[5].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[5].data_pau8
	ECU_ADDRESS 0x70014C8C
	SYMBOL_LINK "dataTxBufDataBoxes1_as[5].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[5].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[5].func_pf
	ECU_ADDRESS 0x70014C90
	SYMBOL_LINK "dataTxBufDataBoxes1_as[5].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[5].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[5].lenMax_u32
	ECU_ADDRESS 0x70014C98
	SYMBOL_LINK "dataTxBufDataBoxes1_as[5].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[5].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[5].lenAct_u32
	ECU_ADDRESS 0x70014C9C
	SYMBOL_LINK "dataTxBufDataBoxes1_as[5].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[5].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[5].cycle_u16
	ECU_ADDRESS 0x70014CA0
	SYMBOL_LINK "dataTxBufDataBoxes1_as[5].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[5].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[5].counter_u16
	ECU_ADDRESS 0x70014CA2
	SYMBOL_LINK "dataTxBufDataBoxes1_as[5].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[5].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[5].status_u16
	ECU_ADDRESS 0x70014CA4
	SYMBOL_LINK "dataTxBufDataBoxes1_as[5].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[5].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[5].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014CA6
	SYMBOL_LINK "dataTxBufDataBoxes1_as[5].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[5].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[5].periodicdatabox_u16
	ECU_ADDRESS 0x70014CA8
	SYMBOL_LINK "dataTxBufDataBoxes1_as[5].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[6].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[6].data_pau8
	ECU_ADDRESS 0x70014CAC
	SYMBOL_LINK "dataTxBufDataBoxes1_as[6].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[6].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[6].func_pf
	ECU_ADDRESS 0x70014CB0
	SYMBOL_LINK "dataTxBufDataBoxes1_as[6].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[6].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[6].lenMax_u32
	ECU_ADDRESS 0x70014CB8
	SYMBOL_LINK "dataTxBufDataBoxes1_as[6].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[6].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[6].lenAct_u32
	ECU_ADDRESS 0x70014CBC
	SYMBOL_LINK "dataTxBufDataBoxes1_as[6].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[6].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[6].cycle_u16
	ECU_ADDRESS 0x70014CC0
	SYMBOL_LINK "dataTxBufDataBoxes1_as[6].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[6].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[6].counter_u16
	ECU_ADDRESS 0x70014CC2
	SYMBOL_LINK "dataTxBufDataBoxes1_as[6].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[6].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[6].status_u16
	ECU_ADDRESS 0x70014CC4
	SYMBOL_LINK "dataTxBufDataBoxes1_as[6].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[6].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[6].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014CC6
	SYMBOL_LINK "dataTxBufDataBoxes1_as[6].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes1_as[6].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes1_as[6].periodicdatabox_u16
	ECU_ADDRESS 0x70014CC8
	SYMBOL_LINK "dataTxBufDataBoxes1_as[6].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[1].data_pau8
	ECU_ADDRESS 0x70014CCC
	SYMBOL_LINK "dataRxBufDataBoxes1_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[1].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[1].func_pf
	ECU_ADDRESS 0x70014CD0
	SYMBOL_LINK "dataRxBufDataBoxes1_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[1].lenAct_u32
	ECU_ADDRESS 0x70014CD8
	SYMBOL_LINK "dataRxBufDataBoxes1_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[1].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[1].lenRx_u32
	ECU_ADDRESS 0x70014CDC
	SYMBOL_LINK "dataRxBufDataBoxes1_as[1].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[1].lenMax_u32
	ECU_ADDRESS 0x70014CE0
	SYMBOL_LINK "dataRxBufDataBoxes1_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[1].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[1].timeout_u16
	ECU_ADDRESS 0x70014CE4
	SYMBOL_LINK "dataRxBufDataBoxes1_as[1].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[1].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[1].startTimeout_u16
	ECU_ADDRESS 0x70014CE6
	SYMBOL_LINK "dataRxBufDataBoxes1_as[1].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[1].counter_u16
	ECU_ADDRESS 0x70014CE8
	SYMBOL_LINK "dataRxBufDataBoxes1_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[1].status_u16
	ECU_ADDRESS 0x70014CEA
	SYMBOL_LINK "dataRxBufDataBoxes1_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[1].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[1].action_u16
	ECU_ADDRESS 0x70014CEC
	SYMBOL_LINK "dataRxBufDataBoxes1_as[1].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[1].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[1].internalBox_l
	ECU_ADDRESS 0x70014CEE
	SYMBOL_LINK "dataRxBufDataBoxes1_as[1].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[2].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[2].data_pau8
	ECU_ADDRESS 0x70014CF0
	SYMBOL_LINK "dataRxBufDataBoxes1_as[2].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[2].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[2].func_pf
	ECU_ADDRESS 0x70014CF4
	SYMBOL_LINK "dataRxBufDataBoxes1_as[2].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[2].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[2].lenAct_u32
	ECU_ADDRESS 0x70014CFC
	SYMBOL_LINK "dataRxBufDataBoxes1_as[2].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[2].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[2].lenRx_u32
	ECU_ADDRESS 0x70014D00
	SYMBOL_LINK "dataRxBufDataBoxes1_as[2].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[2].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[2].lenMax_u32
	ECU_ADDRESS 0x70014D04
	SYMBOL_LINK "dataRxBufDataBoxes1_as[2].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[2].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[2].timeout_u16
	ECU_ADDRESS 0x70014D08
	SYMBOL_LINK "dataRxBufDataBoxes1_as[2].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[2].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[2].startTimeout_u16
	ECU_ADDRESS 0x70014D0A
	SYMBOL_LINK "dataRxBufDataBoxes1_as[2].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[2].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[2].counter_u16
	ECU_ADDRESS 0x70014D0C
	SYMBOL_LINK "dataRxBufDataBoxes1_as[2].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[2].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[2].status_u16
	ECU_ADDRESS 0x70014D0E
	SYMBOL_LINK "dataRxBufDataBoxes1_as[2].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[2].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[2].action_u16
	ECU_ADDRESS 0x70014D10
	SYMBOL_LINK "dataRxBufDataBoxes1_as[2].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[2].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[2].internalBox_l
	ECU_ADDRESS 0x70014D12
	SYMBOL_LINK "dataRxBufDataBoxes1_as[2].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[3].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[3].data_pau8
	ECU_ADDRESS 0x70014D14
	SYMBOL_LINK "dataRxBufDataBoxes1_as[3].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[3].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[3].func_pf
	ECU_ADDRESS 0x70014D18
	SYMBOL_LINK "dataRxBufDataBoxes1_as[3].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[3].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[3].lenAct_u32
	ECU_ADDRESS 0x70014D20
	SYMBOL_LINK "dataRxBufDataBoxes1_as[3].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[3].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[3].lenRx_u32
	ECU_ADDRESS 0x70014D24
	SYMBOL_LINK "dataRxBufDataBoxes1_as[3].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[3].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[3].lenMax_u32
	ECU_ADDRESS 0x70014D28
	SYMBOL_LINK "dataRxBufDataBoxes1_as[3].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[3].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[3].timeout_u16
	ECU_ADDRESS 0x70014D2C
	SYMBOL_LINK "dataRxBufDataBoxes1_as[3].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[3].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[3].startTimeout_u16
	ECU_ADDRESS 0x70014D2E
	SYMBOL_LINK "dataRxBufDataBoxes1_as[3].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[3].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[3].counter_u16
	ECU_ADDRESS 0x70014D30
	SYMBOL_LINK "dataRxBufDataBoxes1_as[3].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[3].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[3].status_u16
	ECU_ADDRESS 0x70014D32
	SYMBOL_LINK "dataRxBufDataBoxes1_as[3].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[3].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[3].action_u16
	ECU_ADDRESS 0x70014D34
	SYMBOL_LINK "dataRxBufDataBoxes1_as[3].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[3].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[3].internalBox_l
	ECU_ADDRESS 0x70014D36
	SYMBOL_LINK "dataRxBufDataBoxes1_as[3].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[4].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[4].data_pau8
	ECU_ADDRESS 0x70014D38
	SYMBOL_LINK "dataRxBufDataBoxes1_as[4].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[4].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[4].func_pf
	ECU_ADDRESS 0x70014D3C
	SYMBOL_LINK "dataRxBufDataBoxes1_as[4].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[4].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[4].lenAct_u32
	ECU_ADDRESS 0x70014D44
	SYMBOL_LINK "dataRxBufDataBoxes1_as[4].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[4].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[4].lenRx_u32
	ECU_ADDRESS 0x70014D48
	SYMBOL_LINK "dataRxBufDataBoxes1_as[4].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[4].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[4].lenMax_u32
	ECU_ADDRESS 0x70014D4C
	SYMBOL_LINK "dataRxBufDataBoxes1_as[4].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[4].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[4].timeout_u16
	ECU_ADDRESS 0x70014D50
	SYMBOL_LINK "dataRxBufDataBoxes1_as[4].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[4].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[4].startTimeout_u16
	ECU_ADDRESS 0x70014D52
	SYMBOL_LINK "dataRxBufDataBoxes1_as[4].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[4].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[4].counter_u16
	ECU_ADDRESS 0x70014D54
	SYMBOL_LINK "dataRxBufDataBoxes1_as[4].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[4].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[4].status_u16
	ECU_ADDRESS 0x70014D56
	SYMBOL_LINK "dataRxBufDataBoxes1_as[4].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[4].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[4].action_u16
	ECU_ADDRESS 0x70014D58
	SYMBOL_LINK "dataRxBufDataBoxes1_as[4].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes1_as[4].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes1_as[4].internalBox_l
	ECU_ADDRESS 0x70014D5A
	SYMBOL_LINK "dataRxBufDataBoxes1_as[4].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[1].data_pau8
	ECU_ADDRESS 0x70014D5C
	SYMBOL_LINK "dataTxBufDataBoxes2_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[1].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[1].func_pf
	ECU_ADDRESS 0x70014D60
	SYMBOL_LINK "dataTxBufDataBoxes2_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[1].lenMax_u32
	ECU_ADDRESS 0x70014D68
	SYMBOL_LINK "dataTxBufDataBoxes2_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[1].lenAct_u32
	ECU_ADDRESS 0x70014D6C
	SYMBOL_LINK "dataTxBufDataBoxes2_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[1].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[1].cycle_u16
	ECU_ADDRESS 0x70014D70
	SYMBOL_LINK "dataTxBufDataBoxes2_as[1].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[1].counter_u16
	ECU_ADDRESS 0x70014D72
	SYMBOL_LINK "dataTxBufDataBoxes2_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[1].status_u16
	ECU_ADDRESS 0x70014D74
	SYMBOL_LINK "dataTxBufDataBoxes2_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[1].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[1].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014D76
	SYMBOL_LINK "dataTxBufDataBoxes2_as[1].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[1].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[1].periodicdatabox_u16
	ECU_ADDRESS 0x70014D78
	SYMBOL_LINK "dataTxBufDataBoxes2_as[1].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[2].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[2].data_pau8
	ECU_ADDRESS 0x70014D7C
	SYMBOL_LINK "dataTxBufDataBoxes2_as[2].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[2].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[2].func_pf
	ECU_ADDRESS 0x70014D80
	SYMBOL_LINK "dataTxBufDataBoxes2_as[2].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[2].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[2].lenMax_u32
	ECU_ADDRESS 0x70014D88
	SYMBOL_LINK "dataTxBufDataBoxes2_as[2].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[2].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[2].lenAct_u32
	ECU_ADDRESS 0x70014D8C
	SYMBOL_LINK "dataTxBufDataBoxes2_as[2].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[2].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[2].cycle_u16
	ECU_ADDRESS 0x70014D90
	SYMBOL_LINK "dataTxBufDataBoxes2_as[2].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[2].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[2].counter_u16
	ECU_ADDRESS 0x70014D92
	SYMBOL_LINK "dataTxBufDataBoxes2_as[2].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[2].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[2].status_u16
	ECU_ADDRESS 0x70014D94
	SYMBOL_LINK "dataTxBufDataBoxes2_as[2].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[2].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[2].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014D96
	SYMBOL_LINK "dataTxBufDataBoxes2_as[2].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[2].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[2].periodicdatabox_u16
	ECU_ADDRESS 0x70014D98
	SYMBOL_LINK "dataTxBufDataBoxes2_as[2].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[3].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[3].data_pau8
	ECU_ADDRESS 0x70014D9C
	SYMBOL_LINK "dataTxBufDataBoxes2_as[3].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[3].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[3].func_pf
	ECU_ADDRESS 0x70014DA0
	SYMBOL_LINK "dataTxBufDataBoxes2_as[3].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[3].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[3].lenMax_u32
	ECU_ADDRESS 0x70014DA8
	SYMBOL_LINK "dataTxBufDataBoxes2_as[3].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[3].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[3].lenAct_u32
	ECU_ADDRESS 0x70014DAC
	SYMBOL_LINK "dataTxBufDataBoxes2_as[3].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[3].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[3].cycle_u16
	ECU_ADDRESS 0x70014DB0
	SYMBOL_LINK "dataTxBufDataBoxes2_as[3].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[3].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[3].counter_u16
	ECU_ADDRESS 0x70014DB2
	SYMBOL_LINK "dataTxBufDataBoxes2_as[3].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[3].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[3].status_u16
	ECU_ADDRESS 0x70014DB4
	SYMBOL_LINK "dataTxBufDataBoxes2_as[3].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[3].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[3].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014DB6
	SYMBOL_LINK "dataTxBufDataBoxes2_as[3].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[3].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[3].periodicdatabox_u16
	ECU_ADDRESS 0x70014DB8
	SYMBOL_LINK "dataTxBufDataBoxes2_as[3].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[4].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[4].data_pau8
	ECU_ADDRESS 0x70014DBC
	SYMBOL_LINK "dataTxBufDataBoxes2_as[4].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[4].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[4].func_pf
	ECU_ADDRESS 0x70014DC0
	SYMBOL_LINK "dataTxBufDataBoxes2_as[4].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[4].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[4].lenMax_u32
	ECU_ADDRESS 0x70014DC8
	SYMBOL_LINK "dataTxBufDataBoxes2_as[4].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[4].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[4].lenAct_u32
	ECU_ADDRESS 0x70014DCC
	SYMBOL_LINK "dataTxBufDataBoxes2_as[4].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[4].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[4].cycle_u16
	ECU_ADDRESS 0x70014DD0
	SYMBOL_LINK "dataTxBufDataBoxes2_as[4].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[4].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[4].counter_u16
	ECU_ADDRESS 0x70014DD2
	SYMBOL_LINK "dataTxBufDataBoxes2_as[4].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[4].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[4].status_u16
	ECU_ADDRESS 0x70014DD4
	SYMBOL_LINK "dataTxBufDataBoxes2_as[4].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[4].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[4].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014DD6
	SYMBOL_LINK "dataTxBufDataBoxes2_as[4].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes2_as[4].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes2_as[4].periodicdatabox_u16
	ECU_ADDRESS 0x70014DD8
	SYMBOL_LINK "dataTxBufDataBoxes2_as[4].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[1].data_pau8
	ECU_ADDRESS 0x70014DDC
	SYMBOL_LINK "dataRxBufDataBoxes2_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[1].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[1].func_pf
	ECU_ADDRESS 0x70014DE0
	SYMBOL_LINK "dataRxBufDataBoxes2_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[1].lenAct_u32
	ECU_ADDRESS 0x70014DE8
	SYMBOL_LINK "dataRxBufDataBoxes2_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[1].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[1].lenRx_u32
	ECU_ADDRESS 0x70014DEC
	SYMBOL_LINK "dataRxBufDataBoxes2_as[1].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[1].lenMax_u32
	ECU_ADDRESS 0x70014DF0
	SYMBOL_LINK "dataRxBufDataBoxes2_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[1].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[1].timeout_u16
	ECU_ADDRESS 0x70014DF4
	SYMBOL_LINK "dataRxBufDataBoxes2_as[1].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[1].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[1].startTimeout_u16
	ECU_ADDRESS 0x70014DF6
	SYMBOL_LINK "dataRxBufDataBoxes2_as[1].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[1].counter_u16
	ECU_ADDRESS 0x70014DF8
	SYMBOL_LINK "dataRxBufDataBoxes2_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[1].status_u16
	ECU_ADDRESS 0x70014DFA
	SYMBOL_LINK "dataRxBufDataBoxes2_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[1].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[1].action_u16
	ECU_ADDRESS 0x70014DFC
	SYMBOL_LINK "dataRxBufDataBoxes2_as[1].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[1].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[1].internalBox_l
	ECU_ADDRESS 0x70014DFE
	SYMBOL_LINK "dataRxBufDataBoxes2_as[1].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[2].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[2].data_pau8
	ECU_ADDRESS 0x70014E00
	SYMBOL_LINK "dataRxBufDataBoxes2_as[2].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[2].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[2].func_pf
	ECU_ADDRESS 0x70014E04
	SYMBOL_LINK "dataRxBufDataBoxes2_as[2].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[2].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[2].lenAct_u32
	ECU_ADDRESS 0x70014E0C
	SYMBOL_LINK "dataRxBufDataBoxes2_as[2].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[2].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[2].lenRx_u32
	ECU_ADDRESS 0x70014E10
	SYMBOL_LINK "dataRxBufDataBoxes2_as[2].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[2].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[2].lenMax_u32
	ECU_ADDRESS 0x70014E14
	SYMBOL_LINK "dataRxBufDataBoxes2_as[2].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[2].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[2].timeout_u16
	ECU_ADDRESS 0x70014E18
	SYMBOL_LINK "dataRxBufDataBoxes2_as[2].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[2].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[2].startTimeout_u16
	ECU_ADDRESS 0x70014E1A
	SYMBOL_LINK "dataRxBufDataBoxes2_as[2].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[2].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[2].counter_u16
	ECU_ADDRESS 0x70014E1C
	SYMBOL_LINK "dataRxBufDataBoxes2_as[2].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[2].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[2].status_u16
	ECU_ADDRESS 0x70014E1E
	SYMBOL_LINK "dataRxBufDataBoxes2_as[2].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[2].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[2].action_u16
	ECU_ADDRESS 0x70014E20
	SYMBOL_LINK "dataRxBufDataBoxes2_as[2].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[2].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[2].internalBox_l
	ECU_ADDRESS 0x70014E22
	SYMBOL_LINK "dataRxBufDataBoxes2_as[2].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[3].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[3].data_pau8
	ECU_ADDRESS 0x70014E24
	SYMBOL_LINK "dataRxBufDataBoxes2_as[3].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[3].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[3].func_pf
	ECU_ADDRESS 0x70014E28
	SYMBOL_LINK "dataRxBufDataBoxes2_as[3].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[3].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[3].lenAct_u32
	ECU_ADDRESS 0x70014E30
	SYMBOL_LINK "dataRxBufDataBoxes2_as[3].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[3].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[3].lenRx_u32
	ECU_ADDRESS 0x70014E34
	SYMBOL_LINK "dataRxBufDataBoxes2_as[3].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[3].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[3].lenMax_u32
	ECU_ADDRESS 0x70014E38
	SYMBOL_LINK "dataRxBufDataBoxes2_as[3].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[3].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[3].timeout_u16
	ECU_ADDRESS 0x70014E3C
	SYMBOL_LINK "dataRxBufDataBoxes2_as[3].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[3].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[3].startTimeout_u16
	ECU_ADDRESS 0x70014E3E
	SYMBOL_LINK "dataRxBufDataBoxes2_as[3].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[3].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[3].counter_u16
	ECU_ADDRESS 0x70014E40
	SYMBOL_LINK "dataRxBufDataBoxes2_as[3].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[3].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[3].status_u16
	ECU_ADDRESS 0x70014E42
	SYMBOL_LINK "dataRxBufDataBoxes2_as[3].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[3].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[3].action_u16
	ECU_ADDRESS 0x70014E44
	SYMBOL_LINK "dataRxBufDataBoxes2_as[3].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[3].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[3].internalBox_l
	ECU_ADDRESS 0x70014E46
	SYMBOL_LINK "dataRxBufDataBoxes2_as[3].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[4].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[4].data_pau8
	ECU_ADDRESS 0x70014E48
	SYMBOL_LINK "dataRxBufDataBoxes2_as[4].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[4].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[4].func_pf
	ECU_ADDRESS 0x70014E4C
	SYMBOL_LINK "dataRxBufDataBoxes2_as[4].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[4].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[4].lenAct_u32
	ECU_ADDRESS 0x70014E54
	SYMBOL_LINK "dataRxBufDataBoxes2_as[4].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[4].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[4].lenRx_u32
	ECU_ADDRESS 0x70014E58
	SYMBOL_LINK "dataRxBufDataBoxes2_as[4].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[4].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[4].lenMax_u32
	ECU_ADDRESS 0x70014E5C
	SYMBOL_LINK "dataRxBufDataBoxes2_as[4].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[4].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[4].timeout_u16
	ECU_ADDRESS 0x70014E60
	SYMBOL_LINK "dataRxBufDataBoxes2_as[4].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[4].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[4].startTimeout_u16
	ECU_ADDRESS 0x70014E62
	SYMBOL_LINK "dataRxBufDataBoxes2_as[4].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[4].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[4].counter_u16
	ECU_ADDRESS 0x70014E64
	SYMBOL_LINK "dataRxBufDataBoxes2_as[4].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[4].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[4].status_u16
	ECU_ADDRESS 0x70014E66
	SYMBOL_LINK "dataRxBufDataBoxes2_as[4].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[4].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[4].action_u16
	ECU_ADDRESS 0x70014E68
	SYMBOL_LINK "dataRxBufDataBoxes2_as[4].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes2_as[4].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes2_as[4].internalBox_l
	ECU_ADDRESS 0x70014E6A
	SYMBOL_LINK "dataRxBufDataBoxes2_as[4].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[1].data_pau8
	ECU_ADDRESS 0x70014E6C
	SYMBOL_LINK "dataTxBufDataBoxes3_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[1].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[1].func_pf
	ECU_ADDRESS 0x70014E70
	SYMBOL_LINK "dataTxBufDataBoxes3_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[1].lenMax_u32
	ECU_ADDRESS 0x70014E78
	SYMBOL_LINK "dataTxBufDataBoxes3_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[1].lenAct_u32
	ECU_ADDRESS 0x70014E7C
	SYMBOL_LINK "dataTxBufDataBoxes3_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[1].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[1].cycle_u16
	ECU_ADDRESS 0x70014E80
	SYMBOL_LINK "dataTxBufDataBoxes3_as[1].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[1].counter_u16
	ECU_ADDRESS 0x70014E82
	SYMBOL_LINK "dataTxBufDataBoxes3_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[1].status_u16
	ECU_ADDRESS 0x70014E84
	SYMBOL_LINK "dataTxBufDataBoxes3_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[1].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[1].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014E86
	SYMBOL_LINK "dataTxBufDataBoxes3_as[1].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[1].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[1].periodicdatabox_u16
	ECU_ADDRESS 0x70014E88
	SYMBOL_LINK "dataTxBufDataBoxes3_as[1].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[2].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[2].data_pau8
	ECU_ADDRESS 0x70014E8C
	SYMBOL_LINK "dataTxBufDataBoxes3_as[2].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[2].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[2].func_pf
	ECU_ADDRESS 0x70014E90
	SYMBOL_LINK "dataTxBufDataBoxes3_as[2].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[2].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[2].lenMax_u32
	ECU_ADDRESS 0x70014E98
	SYMBOL_LINK "dataTxBufDataBoxes3_as[2].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[2].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[2].lenAct_u32
	ECU_ADDRESS 0x70014E9C
	SYMBOL_LINK "dataTxBufDataBoxes3_as[2].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[2].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[2].cycle_u16
	ECU_ADDRESS 0x70014EA0
	SYMBOL_LINK "dataTxBufDataBoxes3_as[2].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[2].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[2].counter_u16
	ECU_ADDRESS 0x70014EA2
	SYMBOL_LINK "dataTxBufDataBoxes3_as[2].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[2].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[2].status_u16
	ECU_ADDRESS 0x70014EA4
	SYMBOL_LINK "dataTxBufDataBoxes3_as[2].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[2].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[2].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014EA6
	SYMBOL_LINK "dataTxBufDataBoxes3_as[2].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[2].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[2].periodicdatabox_u16
	ECU_ADDRESS 0x70014EA8
	SYMBOL_LINK "dataTxBufDataBoxes3_as[2].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[3].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[3].data_pau8
	ECU_ADDRESS 0x70014EAC
	SYMBOL_LINK "dataTxBufDataBoxes3_as[3].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[3].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[3].func_pf
	ECU_ADDRESS 0x70014EB0
	SYMBOL_LINK "dataTxBufDataBoxes3_as[3].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[3].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[3].lenMax_u32
	ECU_ADDRESS 0x70014EB8
	SYMBOL_LINK "dataTxBufDataBoxes3_as[3].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[3].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[3].lenAct_u32
	ECU_ADDRESS 0x70014EBC
	SYMBOL_LINK "dataTxBufDataBoxes3_as[3].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[3].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[3].cycle_u16
	ECU_ADDRESS 0x70014EC0
	SYMBOL_LINK "dataTxBufDataBoxes3_as[3].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[3].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[3].counter_u16
	ECU_ADDRESS 0x70014EC2
	SYMBOL_LINK "dataTxBufDataBoxes3_as[3].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[3].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[3].status_u16
	ECU_ADDRESS 0x70014EC4
	SYMBOL_LINK "dataTxBufDataBoxes3_as[3].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[3].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[3].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014EC6
	SYMBOL_LINK "dataTxBufDataBoxes3_as[3].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[3].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[3].periodicdatabox_u16
	ECU_ADDRESS 0x70014EC8
	SYMBOL_LINK "dataTxBufDataBoxes3_as[3].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[4].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[4].data_pau8
	ECU_ADDRESS 0x70014ECC
	SYMBOL_LINK "dataTxBufDataBoxes3_as[4].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[4].func_pf ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[4].func_pf
	ECU_ADDRESS 0x70014ED0
	SYMBOL_LINK "dataTxBufDataBoxes3_as[4].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[4].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[4].lenMax_u32
	ECU_ADDRESS 0x70014ED8
	SYMBOL_LINK "dataTxBufDataBoxes3_as[4].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[4].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[4].lenAct_u32
	ECU_ADDRESS 0x70014EDC
	SYMBOL_LINK "dataTxBufDataBoxes3_as[4].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[4].cycle_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[4].cycle_u16
	ECU_ADDRESS 0x70014EE0
	SYMBOL_LINK "dataTxBufDataBoxes3_as[4].cycle_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[4].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[4].counter_u16
	ECU_ADDRESS 0x70014EE2
	SYMBOL_LINK "dataTxBufDataBoxes3_as[4].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[4].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[4].status_u16
	ECU_ADDRESS 0x70014EE4
	SYMBOL_LINK "dataTxBufDataBoxes3_as[4].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[4].aperiodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[4].aperiodicdatabox_u16
	ECU_ADDRESS 0x70014EE6
	SYMBOL_LINK "dataTxBufDataBoxes3_as[4].aperiodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataTxBufDataBoxes3_as[4].periodicdatabox_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataTxBufDataBoxes3_as[4].periodicdatabox_u16
	ECU_ADDRESS 0x70014EE8
	SYMBOL_LINK "dataTxBufDataBoxes3_as[4].periodicdatabox_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[1].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[1].data_pau8
	ECU_ADDRESS 0x70014EEC
	SYMBOL_LINK "dataRxBufDataBoxes3_as[1].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[1].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[1].func_pf
	ECU_ADDRESS 0x70014EF0
	SYMBOL_LINK "dataRxBufDataBoxes3_as[1].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[1].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[1].lenAct_u32
	ECU_ADDRESS 0x70014EF8
	SYMBOL_LINK "dataRxBufDataBoxes3_as[1].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[1].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[1].lenRx_u32
	ECU_ADDRESS 0x70014EFC
	SYMBOL_LINK "dataRxBufDataBoxes3_as[1].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[1].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[1].lenMax_u32
	ECU_ADDRESS 0x70014F00
	SYMBOL_LINK "dataRxBufDataBoxes3_as[1].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[1].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[1].timeout_u16
	ECU_ADDRESS 0x70014F04
	SYMBOL_LINK "dataRxBufDataBoxes3_as[1].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[1].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[1].startTimeout_u16
	ECU_ADDRESS 0x70014F06
	SYMBOL_LINK "dataRxBufDataBoxes3_as[1].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[1].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[1].counter_u16
	ECU_ADDRESS 0x70014F08
	SYMBOL_LINK "dataRxBufDataBoxes3_as[1].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[1].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[1].status_u16
	ECU_ADDRESS 0x70014F0A
	SYMBOL_LINK "dataRxBufDataBoxes3_as[1].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[1].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[1].action_u16
	ECU_ADDRESS 0x70014F0C
	SYMBOL_LINK "dataRxBufDataBoxes3_as[1].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[1].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[1].internalBox_l
	ECU_ADDRESS 0x70014F0E
	SYMBOL_LINK "dataRxBufDataBoxes3_as[1].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[2].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[2].data_pau8
	ECU_ADDRESS 0x70014F10
	SYMBOL_LINK "dataRxBufDataBoxes3_as[2].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[2].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[2].func_pf
	ECU_ADDRESS 0x70014F14
	SYMBOL_LINK "dataRxBufDataBoxes3_as[2].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[2].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[2].lenAct_u32
	ECU_ADDRESS 0x70014F1C
	SYMBOL_LINK "dataRxBufDataBoxes3_as[2].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[2].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[2].lenRx_u32
	ECU_ADDRESS 0x70014F20
	SYMBOL_LINK "dataRxBufDataBoxes3_as[2].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[2].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[2].lenMax_u32
	ECU_ADDRESS 0x70014F24
	SYMBOL_LINK "dataRxBufDataBoxes3_as[2].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[2].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[2].timeout_u16
	ECU_ADDRESS 0x70014F28
	SYMBOL_LINK "dataRxBufDataBoxes3_as[2].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[2].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[2].startTimeout_u16
	ECU_ADDRESS 0x70014F2A
	SYMBOL_LINK "dataRxBufDataBoxes3_as[2].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[2].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[2].counter_u16
	ECU_ADDRESS 0x70014F2C
	SYMBOL_LINK "dataRxBufDataBoxes3_as[2].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[2].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[2].status_u16
	ECU_ADDRESS 0x70014F2E
	SYMBOL_LINK "dataRxBufDataBoxes3_as[2].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[2].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[2].action_u16
	ECU_ADDRESS 0x70014F30
	SYMBOL_LINK "dataRxBufDataBoxes3_as[2].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[2].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[2].internalBox_l
	ECU_ADDRESS 0x70014F32
	SYMBOL_LINK "dataRxBufDataBoxes3_as[2].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[3].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[3].data_pau8
	ECU_ADDRESS 0x70014F34
	SYMBOL_LINK "dataRxBufDataBoxes3_as[3].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[3].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[3].func_pf
	ECU_ADDRESS 0x70014F38
	SYMBOL_LINK "dataRxBufDataBoxes3_as[3].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[3].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[3].lenAct_u32
	ECU_ADDRESS 0x70014F40
	SYMBOL_LINK "dataRxBufDataBoxes3_as[3].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[3].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[3].lenRx_u32
	ECU_ADDRESS 0x70014F44
	SYMBOL_LINK "dataRxBufDataBoxes3_as[3].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[3].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[3].lenMax_u32
	ECU_ADDRESS 0x70014F48
	SYMBOL_LINK "dataRxBufDataBoxes3_as[3].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[3].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[3].timeout_u16
	ECU_ADDRESS 0x70014F4C
	SYMBOL_LINK "dataRxBufDataBoxes3_as[3].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[3].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[3].startTimeout_u16
	ECU_ADDRESS 0x70014F4E
	SYMBOL_LINK "dataRxBufDataBoxes3_as[3].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[3].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[3].counter_u16
	ECU_ADDRESS 0x70014F50
	SYMBOL_LINK "dataRxBufDataBoxes3_as[3].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[3].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[3].status_u16
	ECU_ADDRESS 0x70014F52
	SYMBOL_LINK "dataRxBufDataBoxes3_as[3].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[3].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[3].action_u16
	ECU_ADDRESS 0x70014F54
	SYMBOL_LINK "dataRxBufDataBoxes3_as[3].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[3].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[3].internalBox_l
	ECU_ADDRESS 0x70014F56
	SYMBOL_LINK "dataRxBufDataBoxes3_as[3].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[4].data_pau8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[4].data_pau8
	ECU_ADDRESS 0x70014F58
	SYMBOL_LINK "dataRxBufDataBoxes3_as[4].data_pau8" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[4].func_pf ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[4].func_pf
	ECU_ADDRESS 0x70014F5C
	SYMBOL_LINK "dataRxBufDataBoxes3_as[4].func_pf" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[4].lenAct_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[4].lenAct_u32
	ECU_ADDRESS 0x70014F64
	SYMBOL_LINK "dataRxBufDataBoxes3_as[4].lenAct_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[4].lenRx_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[4].lenRx_u32
	ECU_ADDRESS 0x70014F68
	SYMBOL_LINK "dataRxBufDataBoxes3_as[4].lenRx_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[4].lenMax_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[4].lenMax_u32
	ECU_ADDRESS 0x70014F6C
	SYMBOL_LINK "dataRxBufDataBoxes3_as[4].lenMax_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[4].timeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[4].timeout_u16
	ECU_ADDRESS 0x70014F70
	SYMBOL_LINK "dataRxBufDataBoxes3_as[4].timeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[4].startTimeout_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[4].startTimeout_u16
	ECU_ADDRESS 0x70014F72
	SYMBOL_LINK "dataRxBufDataBoxes3_as[4].startTimeout_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[4].counter_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[4].counter_u16
	ECU_ADDRESS 0x70014F74
	SYMBOL_LINK "dataRxBufDataBoxes3_as[4].counter_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[4].status_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[4].status_u16
	ECU_ADDRESS 0x70014F76
	SYMBOL_LINK "dataRxBufDataBoxes3_as[4].status_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[4].action_u16 ""
	UWORD CnvRule_NumberOneToOne 1 0 0 65535
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[4].action_u16
	ECU_ADDRESS 0x70014F78
	SYMBOL_LINK "dataRxBufDataBoxes3_as[4].action_u16" 0
/end MEASUREMENT


/begin MEASUREMENT dataRxBufDataBoxes3_as[4].internalBox_l ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 1
	DISPLAY_IDENTIFIER dataRxBufDataBoxes3_as[4].internalBox_l
	ECU_ADDRESS 0x70014F7A
	SYMBOL_LINK "dataRxBufDataBoxes3_as[4].internalBox_l" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70014F80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70014F84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70014F85
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70014F88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70014F8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70014F8D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70014F90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70014F94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70014F95
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70014F98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70014F9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70014F9D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70014FA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70014FA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70014FA5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70014FA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70014FAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70014FAD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70014FB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70014FB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70014FB5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70014FB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70014FBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70014FBD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70014FC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70014FC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70014FC5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70014FC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70014FCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70014FCD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70014FD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70014FD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70014FD5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70014FD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70014FDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70014FDD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70014FE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70014FE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70014FE5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70014FE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70014FEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70014FED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70014FF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70014FF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70014FF5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70014FF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70014FFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70014FFD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70015000
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70015004
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70015005
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70015008
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x7001500C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[18].occ_u8
	ECU_ADDRESS 0x7001500D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70015010
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70015014
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70015015
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70015018
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x7001501C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as[20].occ_u8
	ECU_ADDRESS 0x7001501D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[1].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[1].dtc_as
	ECU_ADDRESS 0x70014F80
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[1].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70015024
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70015028
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70015029
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[2].spn_u32
	ECU_ADDRESS 0x7001502C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70015030
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70015031
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70015034
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70015038
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70015039
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[4].spn_u32
	ECU_ADDRESS 0x7001503C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70015040
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70015041
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70015044
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70015048
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70015049
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[6].spn_u32
	ECU_ADDRESS 0x7001504C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70015050
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70015051
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70015054
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70015058
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70015059
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[8].spn_u32
	ECU_ADDRESS 0x7001505C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70015060
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70015061
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70015064
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70015068
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70015069
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[10].spn_u32
	ECU_ADDRESS 0x7001506C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70015070
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70015071
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70015074
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015078
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015079
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[12].spn_u32
	ECU_ADDRESS 0x7001507C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015080
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015081
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015084
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015088
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[2].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[2].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015089
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[2].dtc_as[13].occ_u8" 0
/end MEASUREMENT


