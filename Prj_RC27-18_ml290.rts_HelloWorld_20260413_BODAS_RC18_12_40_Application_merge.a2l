	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70015FD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70015FD9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70015FDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70015FE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70015FE1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70015FE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70015FE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70015FE9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70015FEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70015FF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70015FF1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70015FF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70015FF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70015FF9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70015FFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016000
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016001
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016004
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016008
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016009
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[18].spn_u32
	ECU_ADDRESS 0x7001600C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016010
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016011
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016014
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016018
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016019
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[20].spn_u32
	ECU_ADDRESS 0x7001601C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016020
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016021
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[26].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[26].dtc_as
	ECU_ADDRESS 0x70015F84
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[26].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016028
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x7001602C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[1].occ_u8
	ECU_ADDRESS 0x7001602D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016030
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016034
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016035
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016038
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x7001603C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[3].occ_u8
	ECU_ADDRESS 0x7001603D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016040
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016044
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016045
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016048
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x7001604C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[5].occ_u8
	ECU_ADDRESS 0x7001604D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016050
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016054
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016055
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016058
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x7001605C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[7].occ_u8
	ECU_ADDRESS 0x7001605D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016060
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016064
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016065
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016068
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x7001606C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[9].occ_u8
	ECU_ADDRESS 0x7001606D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016070
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016074
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016075
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016078
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x7001607C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[11].occ_u8
	ECU_ADDRESS 0x7001607D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016080
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016084
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016085
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016088
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x7001608C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[13].occ_u8
	ECU_ADDRESS 0x7001608D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016090
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016094
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016095
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016098
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x7001609C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[15].occ_u8
	ECU_ADDRESS 0x7001609D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700160A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700160A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700160A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700160A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700160AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700160AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700160B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700160B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700160B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700160B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700160BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700160BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700160C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700160C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700160C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[27].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[27].dtc_as
	ECU_ADDRESS 0x70016028
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[27].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700160CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700160D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700160D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700160D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700160D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700160D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700160DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700160E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700160E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700160E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700160E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700160E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700160EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700160F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700160F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700160F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700160F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700160F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700160FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016100
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016101
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016104
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016108
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016109
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[9].spn_u32
	ECU_ADDRESS 0x7001610C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016110
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016111
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016114
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016118
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016119
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[11].spn_u32
	ECU_ADDRESS 0x7001611C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016120
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016121
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016124
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016128
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016129
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[13].spn_u32
	ECU_ADDRESS 0x7001612C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016130
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016131
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016134
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016138
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016139
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[15].spn_u32
	ECU_ADDRESS 0x7001613C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016140
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016141
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016144
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016148
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016149
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[17].spn_u32
	ECU_ADDRESS 0x7001614C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016150
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016151
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016154
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016158
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016159
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[19].spn_u32
	ECU_ADDRESS 0x7001615C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016161
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016164
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016168
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016169
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[28].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[28].dtc_as
	ECU_ADDRESS 0x700160CC
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[28].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016170
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016174
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016175
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016178
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x7001617C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[2].occ_u8
	ECU_ADDRESS 0x7001617D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016180
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016184
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016185
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016188
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x7001618C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[4].occ_u8
	ECU_ADDRESS 0x7001618D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016190
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016194
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016195
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016198
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x7001619C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[6].occ_u8
	ECU_ADDRESS 0x7001619D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700161A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700161A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700161A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700161A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700161AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700161AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700161B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700161B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700161B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700161B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700161BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700161BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700161C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700161C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700161C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700161C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700161CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700161CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700161D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700161D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700161D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700161D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700161DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700161DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700161E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700161E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700161E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700161E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700161EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700161ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700161F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700161F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700161F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700161F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700161FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700161FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016200
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016204
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016205
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016208
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x7001620C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as[20].occ_u8
	ECU_ADDRESS 0x7001620D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[29].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[29].dtc_as
	ECU_ADDRESS 0x70016170
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[29].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016214
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016218
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016219
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[2].spn_u32
	ECU_ADDRESS 0x7001621C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016220
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016221
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016224
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016228
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016229
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[4].spn_u32
	ECU_ADDRESS 0x7001622C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016230
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016231
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016234
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016238
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016239
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[6].spn_u32
	ECU_ADDRESS 0x7001623C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016240
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016241
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016244
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016248
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016249
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[8].spn_u32
	ECU_ADDRESS 0x7001624C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016250
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016251
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016254
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016258
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016259
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[10].spn_u32
	ECU_ADDRESS 0x7001625C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016260
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016261
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016264
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016268
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016269
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[12].spn_u32
	ECU_ADDRESS 0x7001626C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016270
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016271
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016274
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016278
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016279
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[14].spn_u32
	ECU_ADDRESS 0x7001627C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016280
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016281
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016284
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016288
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016289
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[16].spn_u32
	ECU_ADDRESS 0x7001628C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016290
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016291
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016294
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016298
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016299
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[18].spn_u32
	ECU_ADDRESS 0x7001629C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700162A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700162A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700162A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700162A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700162A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700162AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700162B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700162B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[30].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[30].dtc_as
	ECU_ADDRESS 0x70016214
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[30].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700162B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700162BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700162BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700162C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700162C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700162C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700162C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700162CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700162CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700162D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700162D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700162D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700162D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700162DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700162DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700162E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700162E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700162E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700162E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700162EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700162ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700162F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700162F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700162F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700162F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700162FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700162FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016300
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016304
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016305
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016308
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x7001630C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[11].occ_u8
	ECU_ADDRESS 0x7001630D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016310
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016314
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016315
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016318
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x7001631C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[13].occ_u8
	ECU_ADDRESS 0x7001631D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016320
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016324
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016325
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016328
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x7001632C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[15].occ_u8
	ECU_ADDRESS 0x7001632D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016330
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016334
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016335
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016338
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x7001633C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[17].occ_u8
	ECU_ADDRESS 0x7001633D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016340
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016344
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016345
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016348
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x7001634C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[19].occ_u8
	ECU_ADDRESS 0x7001634D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016350
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016354
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016355
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[31].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[31].dtc_as
	ECU_ADDRESS 0x700162B8
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[31].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[1].spn_u32
	ECU_ADDRESS 0x7001635C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016360
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016361
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016364
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016368
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016369
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[3].spn_u32
	ECU_ADDRESS 0x7001636C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016370
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016371
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016374
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016378
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016379
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[5].spn_u32
	ECU_ADDRESS 0x7001637C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016380
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016381
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016384
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016388
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016389
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[7].spn_u32
	ECU_ADDRESS 0x7001638C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016390
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016391
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016394
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016398
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016399
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[9].spn_u32
	ECU_ADDRESS 0x7001639C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700163A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700163A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700163A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700163A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700163A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700163AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700163B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700163B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700163B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700163B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700163B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700163BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700163C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700163C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700163C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700163C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700163C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700163CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700163D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700163D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700163D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700163D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700163D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700163DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700163E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700163E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700163E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700163E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700163E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700163EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700163F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700163F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700163F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700163F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700163F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[32].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[32].dtc_as
	ECU_ADDRESS 0x7001635C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[32].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016400
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016404
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016405
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016408
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x7001640C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[2].occ_u8
	ECU_ADDRESS 0x7001640D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016410
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016414
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016415
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016418
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x7001641C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[4].occ_u8
	ECU_ADDRESS 0x7001641D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016420
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016424
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016425
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016428
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x7001642C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[6].occ_u8
	ECU_ADDRESS 0x7001642D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016430
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016434
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016435
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016438
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x7001643C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[8].occ_u8
	ECU_ADDRESS 0x7001643D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016440
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016444
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016445
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016448
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x7001644C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[10].occ_u8
	ECU_ADDRESS 0x7001644D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016450
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016454
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016455
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016458
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x7001645C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[12].occ_u8
	ECU_ADDRESS 0x7001645D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016460
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016464
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016465
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016468
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x7001646C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[14].occ_u8
	ECU_ADDRESS 0x7001646D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016470
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016474
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016475
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016478
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x7001647C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[16].occ_u8
	ECU_ADDRESS 0x7001647D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016480
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016484
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016485
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016488
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x7001648C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[18].occ_u8
	ECU_ADDRESS 0x7001648D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016490
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016494
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016495
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016498
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x7001649C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as[20].occ_u8
	ECU_ADDRESS 0x7001649D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[33].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[33].dtc_as
	ECU_ADDRESS 0x70016400
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[33].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700164A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700164A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700164A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700164AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700164B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700164B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700164B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700164B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700164B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700164BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700164C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700164C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700164C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700164C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700164C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700164CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700164D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700164D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700164D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700164D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700164D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700164DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700164E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700164E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700164E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700164E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700164E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700164EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700164F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700164F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700164F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700164F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700164F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700164FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016500
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016501
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016504
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016508
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016509
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[14].spn_u32
	ECU_ADDRESS 0x7001650C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016510
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016511
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016514
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016518
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016519
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[16].spn_u32
	ECU_ADDRESS 0x7001651C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016520
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016521
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016524
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016528
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016529
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[18].spn_u32
	ECU_ADDRESS 0x7001652C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016530
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016531
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016534
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016538
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016539
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[20].spn_u32
	ECU_ADDRESS 0x7001653C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016540
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016541
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[34].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[34].dtc_as
	ECU_ADDRESS 0x700164A4
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[34].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016548
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x7001654C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[1].occ_u8
	ECU_ADDRESS 0x7001654D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016550
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016554
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016555
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016558
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x7001655C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[3].occ_u8
	ECU_ADDRESS 0x7001655D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016560
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016564
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016565
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016568
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x7001656C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[5].occ_u8
	ECU_ADDRESS 0x7001656D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016570
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016574
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016575
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016578
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x7001657C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[7].occ_u8
	ECU_ADDRESS 0x7001657D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016580
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016584
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016585
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016588
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x7001658C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[9].occ_u8
	ECU_ADDRESS 0x7001658D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016590
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016594
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016595
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016598
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x7001659C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[11].occ_u8
	ECU_ADDRESS 0x7001659D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700165A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700165A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700165A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700165A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700165AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700165AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700165B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700165B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700165B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700165B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700165BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700165BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700165C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700165C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700165C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700165C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700165CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700165CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700165D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700165D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700165D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700165D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700165DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700165DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700165E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700165E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700165E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[35].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[35].dtc_as
	ECU_ADDRESS 0x70016548
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[35].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700165EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700165F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700165F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700165F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700165F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700165F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700165FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016600
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016601
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016604
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016608
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016609
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[5].spn_u32
	ECU_ADDRESS 0x7001660C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016610
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016611
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016614
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016618
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016619
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[7].spn_u32
	ECU_ADDRESS 0x7001661C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016620
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016621
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016624
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016628
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016629
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[9].spn_u32
	ECU_ADDRESS 0x7001662C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016630
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016631
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016634
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016638
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016639
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[11].spn_u32
	ECU_ADDRESS 0x7001663C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016640
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016641
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016644
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016648
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016649
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[13].spn_u32
	ECU_ADDRESS 0x7001664C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016650
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016651
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016654
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016658
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016659
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[15].spn_u32
	ECU_ADDRESS 0x7001665C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016660
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016661
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016664
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016668
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016669
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[17].spn_u32
	ECU_ADDRESS 0x7001666C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016670
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016671
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016674
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016678
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016679
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[19].spn_u32
	ECU_ADDRESS 0x7001667C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016680
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016681
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016684
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016688
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016689
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[36].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[36].dtc_as
	ECU_ADDRESS 0x700165EC
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[36].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016690
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016694
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016695
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016698
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x7001669C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[2].occ_u8
	ECU_ADDRESS 0x7001669D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700166A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700166A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700166A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700166A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700166AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700166AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700166B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700166B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700166B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700166B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700166BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700166BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700166C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700166C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700166C5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700166C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700166CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700166CD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700166D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700166D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700166D5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700166D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700166DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700166DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700166E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700166E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700166E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700166E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700166EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700166ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700166F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700166F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700166F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700166F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700166FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700166FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016700
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016704
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016705
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016708
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x7001670C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[16].occ_u8
	ECU_ADDRESS 0x7001670D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016710
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016714
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016715
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016718
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x7001671C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[18].occ_u8
	ECU_ADDRESS 0x7001671D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016720
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016724
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016725
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016728
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x7001672C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as[20].occ_u8
	ECU_ADDRESS 0x7001672D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[37].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[37].dtc_as
	ECU_ADDRESS 0x70016690
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[37].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016734
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016738
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016739
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[2].spn_u32
	ECU_ADDRESS 0x7001673C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016740
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016741
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016744
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016748
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016749
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[4].spn_u32
	ECU_ADDRESS 0x7001674C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016750
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016751
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016754
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016758
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016759
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[6].spn_u32
	ECU_ADDRESS 0x7001675C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016760
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016761
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016764
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016768
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016769
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[8].spn_u32
	ECU_ADDRESS 0x7001676C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016770
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016771
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016774
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016778
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016779
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[10].spn_u32
	ECU_ADDRESS 0x7001677C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016780
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016781
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016784
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016788
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016789
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[12].spn_u32
	ECU_ADDRESS 0x7001678C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016790
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016791
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016794
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016798
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016799
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[14].spn_u32
	ECU_ADDRESS 0x7001679C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700167A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700167A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700167A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700167A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700167A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700167AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700167B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700167B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700167B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700167B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700167B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700167BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700167C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700167C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700167C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700167C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700167C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700167CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700167D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700167D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[38].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[38].dtc_as
	ECU_ADDRESS 0x70016734
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[38].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700167D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700167DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700167DD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700167E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700167E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700167E5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700167E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700167EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700167ED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700167F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700167F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700167F5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700167F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700167FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700167FD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016800
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016804
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016805
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016808
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x7001680C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[7].occ_u8
	ECU_ADDRESS 0x7001680D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016810
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016814
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016815
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016818
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x7001681C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[9].occ_u8
	ECU_ADDRESS 0x7001681D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016820
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016824
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016825
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016828
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x7001682C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[11].occ_u8
	ECU_ADDRESS 0x7001682D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016830
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016834
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016835
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016838
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x7001683C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[13].occ_u8
	ECU_ADDRESS 0x7001683D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016840
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016844
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016845
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016848
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x7001684C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[15].occ_u8
	ECU_ADDRESS 0x7001684D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016850
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016854
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016855
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016858
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x7001685C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[17].occ_u8
	ECU_ADDRESS 0x7001685D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016860
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016864
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016865
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016868
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x7001686C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[19].occ_u8
	ECU_ADDRESS 0x7001686D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016870
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016874
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016875
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[39].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[39].dtc_as
	ECU_ADDRESS 0x700167D8
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[39].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[1].spn_u32
	ECU_ADDRESS 0x7001687C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016880
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016881
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016884
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016888
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016889
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[3].spn_u32
	ECU_ADDRESS 0x7001688C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016890
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016891
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016894
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016898
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016899
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[5].spn_u32
	ECU_ADDRESS 0x7001689C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700168A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700168A1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700168A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700168A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700168A9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700168AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700168B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700168B1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700168B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x700168B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[8].occ_u8
	ECU_ADDRESS 0x700168B9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[9].spn_u32
	ECU_ADDRESS 0x700168BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x700168C0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[9].occ_u8
	ECU_ADDRESS 0x700168C1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[10].spn_u32
	ECU_ADDRESS 0x700168C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x700168C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[10].occ_u8
	ECU_ADDRESS 0x700168C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[11].spn_u32
	ECU_ADDRESS 0x700168CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x700168D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[11].occ_u8
	ECU_ADDRESS 0x700168D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[12].spn_u32
	ECU_ADDRESS 0x700168D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x700168D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[12].occ_u8
	ECU_ADDRESS 0x700168D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[13].spn_u32
	ECU_ADDRESS 0x700168DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x700168E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[13].occ_u8
	ECU_ADDRESS 0x700168E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[14].spn_u32
	ECU_ADDRESS 0x700168E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x700168E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[14].occ_u8
	ECU_ADDRESS 0x700168E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[15].spn_u32
	ECU_ADDRESS 0x700168EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x700168F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[15].occ_u8
	ECU_ADDRESS 0x700168F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[16].spn_u32
	ECU_ADDRESS 0x700168F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x700168F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[16].occ_u8
	ECU_ADDRESS 0x700168F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700168FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016900
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016901
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016904
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016908
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016909
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[19].spn_u32
	ECU_ADDRESS 0x7001690C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016910
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016911
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016914
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016918
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016919
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[40].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[40].dtc_as
	ECU_ADDRESS 0x7001687C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[40].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016920
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016924
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016925
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016928
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x7001692C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[2].occ_u8
	ECU_ADDRESS 0x7001692D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016930
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016934
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016935
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016938
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x7001693C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[4].occ_u8
	ECU_ADDRESS 0x7001693D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016940
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016944
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016945
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016948
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x7001694C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[6].occ_u8
	ECU_ADDRESS 0x7001694D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016950
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016954
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016955
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016958
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x7001695C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[8].occ_u8
	ECU_ADDRESS 0x7001695D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016960
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016964
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016965
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016968
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x7001696C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[10].occ_u8
	ECU_ADDRESS 0x7001696D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016970
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016974
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016975
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016978
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x7001697C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[12].occ_u8
	ECU_ADDRESS 0x7001697D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016980
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016984
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016985
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016988
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x7001698C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[14].occ_u8
	ECU_ADDRESS 0x7001698D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016990
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016994
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016995
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016998
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x7001699C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[16].occ_u8
	ECU_ADDRESS 0x7001699D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[17].spn_u32
	ECU_ADDRESS 0x700169A0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x700169A4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[17].occ_u8
	ECU_ADDRESS 0x700169A5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[18].spn_u32
	ECU_ADDRESS 0x700169A8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x700169AC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[18].occ_u8
	ECU_ADDRESS 0x700169AD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[19].spn_u32
	ECU_ADDRESS 0x700169B0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x700169B4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[19].occ_u8
	ECU_ADDRESS 0x700169B5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[20].spn_u32
	ECU_ADDRESS 0x700169B8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x700169BC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as[20].occ_u8
	ECU_ADDRESS 0x700169BD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[41].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[41].dtc_as
	ECU_ADDRESS 0x70016920
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[41].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[1].spn_u32
	ECU_ADDRESS 0x700169C4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x700169C8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[1].occ_u8
	ECU_ADDRESS 0x700169C9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[2].spn_u32
	ECU_ADDRESS 0x700169CC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x700169D0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[2].occ_u8
	ECU_ADDRESS 0x700169D1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[3].spn_u32
	ECU_ADDRESS 0x700169D4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x700169D8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[3].occ_u8
	ECU_ADDRESS 0x700169D9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[4].spn_u32
	ECU_ADDRESS 0x700169DC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x700169E0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[4].occ_u8
	ECU_ADDRESS 0x700169E1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[5].spn_u32
	ECU_ADDRESS 0x700169E4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x700169E8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[5].occ_u8
	ECU_ADDRESS 0x700169E9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[6].spn_u32
	ECU_ADDRESS 0x700169EC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x700169F0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[6].occ_u8
	ECU_ADDRESS 0x700169F1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[7].spn_u32
	ECU_ADDRESS 0x700169F4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x700169F8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[7].occ_u8
	ECU_ADDRESS 0x700169F9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[8].spn_u32
	ECU_ADDRESS 0x700169FC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016A00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016A01
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016A04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016A08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016A09
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016A0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016A10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016A11
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016A14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016A18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016A19
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016A1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016A20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016A21
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016A24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016A28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016A29
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016A2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016A30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016A31
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016A34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016A38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016A39
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016A3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016A40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016A41
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016A44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016A48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016A49
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016A4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016A50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016A51
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016A54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016A58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016A59
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016A5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016A60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016A61
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[42].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[42].dtc_as
	ECU_ADDRESS 0x700169C4
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[42].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016A68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016A6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016A6D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016A70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016A74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016A75
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016A78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016A7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016A7D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016A80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016A84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016A85
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016A88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016A8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016A8D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016A90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016A94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016A95
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016A98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016A9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016A9D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016AA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016AA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016AA5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016AA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016AAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016AAD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016AB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016AB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016AB5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016AB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016ABC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016ABD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016AC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016AC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016AC5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016AC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016ACC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016ACD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016AD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016AD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016AD5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016AD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016ADC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016ADD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016AE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016AE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016AE5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016AE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016AEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016AED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016AF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016AF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016AF5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016AF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016AFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016AFD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016B00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016B04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016B05
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[43].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[43].dtc_as
	ECU_ADDRESS 0x70016A68
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[43].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016B0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016B10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016B11
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016B14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016B18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016B19
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016B1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016B20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016B21
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016B24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016B28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016B29
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016B2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016B30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016B31
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016B34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016B38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016B39
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016B3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016B40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016B41
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016B44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016B48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016B49
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016B4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016B50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016B51
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016B54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016B58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016B59
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016B5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016B60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016B61
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016B64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016B68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016B69
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016B6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016B70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016B71
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016B74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016B78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016B79
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016B7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016B80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016B81
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016B84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016B88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016B89
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016B8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016B90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016B91
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016B94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016B98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016B99
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016B9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016BA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016BA1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016BA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016BA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016BA9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[44].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[44].dtc_as
	ECU_ADDRESS 0x70016B0C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[44].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016BB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016BB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016BB5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016BB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016BBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016BBD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016BC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016BC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016BC5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016BC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016BCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016BCD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016BD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016BD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016BD5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016BD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016BDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016BDD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016BE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016BE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016BE5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016BE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016BEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016BED
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016BF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016BF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016BF5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016BF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016BFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016BFD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016C00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016C04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016C05
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016C08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016C0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016C0D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016C10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016C14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016C15
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016C18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016C1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016C1D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016C20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016C24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016C25
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016C28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016C2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016C2D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016C30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016C34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016C35
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016C38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016C3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016C3D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016C40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016C44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016C45
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016C48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016C4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016C4D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[45].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[45].dtc_as
	ECU_ADDRESS 0x70016BB0
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[45].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016C54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016C58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016C59
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016C5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016C60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016C61
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016C64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016C68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016C69
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016C6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016C70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016C71
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016C74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016C78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016C79
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016C7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016C80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016C81
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016C84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016C88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016C89
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016C8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016C90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016C91
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016C94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016C98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016C99
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016C9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016CA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016CA1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016CA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016CA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016CA9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016CAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016CB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016CB1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016CB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016CB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016CB9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016CBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016CC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016CC1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016CC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016CC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016CC9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016CCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016CD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016CD1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016CD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016CD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016CD9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016CDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016CE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016CE1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016CE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016CE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016CE9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016CEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016CF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016CF1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[46].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[46].dtc_as
	ECU_ADDRESS 0x70016C54
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[46].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016CF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016CFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016CFD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016D00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016D04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016D05
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016D08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016D0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016D0D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016D10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016D14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016D15
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016D18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016D1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016D1D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016D20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016D24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016D25
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016D28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016D2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016D2D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016D30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016D34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016D35
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016D38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016D3C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016D3D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016D40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016D44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016D45
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016D48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016D4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016D4D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016D50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016D54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016D55
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016D58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016D5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016D5D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016D60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016D64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016D65
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016D68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016D6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016D6D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016D70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016D74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016D75
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016D78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016D7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016D7D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016D80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016D84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016D85
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016D88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016D8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016D8D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016D90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016D94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016D95
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[47].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[47].dtc_as
	ECU_ADDRESS 0x70016CF8
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[47].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016D9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016DA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016DA1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016DA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016DA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016DA9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016DAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016DB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016DB1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016DB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016DB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016DB9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016DBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016DC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016DC1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016DC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016DC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016DC9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016DCC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016DD0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016DD1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016DD4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016DD8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016DD9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016DDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016DE0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016DE1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016DE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016DE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016DE9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016DEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016DF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016DF1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016DF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016DF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016DF9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016DFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016E00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016E01
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016E04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016E08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016E09
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016E0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016E10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016E11
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016E14
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016E18
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016E19
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016E1C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016E20
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016E21
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016E24
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016E28
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016E29
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016E2C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016E30
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016E31
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016E34
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016E38
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016E39
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[48].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[48].dtc_as
	ECU_ADDRESS 0x70016D9C
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[48].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016E40
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016E44
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016E45
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016E48
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016E4C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016E4D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016E50
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016E54
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016E55
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016E58
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016E5C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016E5D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016E60
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016E64
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016E65
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016E68
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016E6C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[6].occ_u8
	ECU_ADDRESS 0x70016E6D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[6].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[7].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[7].spn_u32
	ECU_ADDRESS 0x70016E70
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[7].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[7].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[7].fmi_u8
	ECU_ADDRESS 0x70016E74
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[7].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[7].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[7].occ_u8
	ECU_ADDRESS 0x70016E75
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[7].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[8].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[8].spn_u32
	ECU_ADDRESS 0x70016E78
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[8].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[8].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[8].fmi_u8
	ECU_ADDRESS 0x70016E7C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[8].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[8].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[8].occ_u8
	ECU_ADDRESS 0x70016E7D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[8].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[9].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[9].spn_u32
	ECU_ADDRESS 0x70016E80
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[9].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[9].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[9].fmi_u8
	ECU_ADDRESS 0x70016E84
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[9].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[9].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[9].occ_u8
	ECU_ADDRESS 0x70016E85
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[9].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[10].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[10].spn_u32
	ECU_ADDRESS 0x70016E88
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[10].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[10].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[10].fmi_u8
	ECU_ADDRESS 0x70016E8C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[10].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[10].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[10].occ_u8
	ECU_ADDRESS 0x70016E8D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[10].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[11].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[11].spn_u32
	ECU_ADDRESS 0x70016E90
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[11].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[11].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[11].fmi_u8
	ECU_ADDRESS 0x70016E94
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[11].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[11].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[11].occ_u8
	ECU_ADDRESS 0x70016E95
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[11].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[12].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[12].spn_u32
	ECU_ADDRESS 0x70016E98
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[12].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[12].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[12].fmi_u8
	ECU_ADDRESS 0x70016E9C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[12].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[12].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[12].occ_u8
	ECU_ADDRESS 0x70016E9D
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[12].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[13].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[13].spn_u32
	ECU_ADDRESS 0x70016EA0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[13].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[13].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[13].fmi_u8
	ECU_ADDRESS 0x70016EA4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[13].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[13].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[13].occ_u8
	ECU_ADDRESS 0x70016EA5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[13].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[14].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[14].spn_u32
	ECU_ADDRESS 0x70016EA8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[14].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[14].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[14].fmi_u8
	ECU_ADDRESS 0x70016EAC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[14].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[14].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[14].occ_u8
	ECU_ADDRESS 0x70016EAD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[14].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[15].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[15].spn_u32
	ECU_ADDRESS 0x70016EB0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[15].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[15].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[15].fmi_u8
	ECU_ADDRESS 0x70016EB4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[15].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[15].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[15].occ_u8
	ECU_ADDRESS 0x70016EB5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[15].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[16].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[16].spn_u32
	ECU_ADDRESS 0x70016EB8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[16].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[16].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[16].fmi_u8
	ECU_ADDRESS 0x70016EBC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[16].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[16].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[16].occ_u8
	ECU_ADDRESS 0x70016EBD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[16].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[17].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[17].spn_u32
	ECU_ADDRESS 0x70016EC0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[17].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[17].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[17].fmi_u8
	ECU_ADDRESS 0x70016EC4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[17].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[17].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[17].occ_u8
	ECU_ADDRESS 0x70016EC5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[17].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[18].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[18].spn_u32
	ECU_ADDRESS 0x70016EC8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[18].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[18].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[18].fmi_u8
	ECU_ADDRESS 0x70016ECC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[18].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[18].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[18].occ_u8
	ECU_ADDRESS 0x70016ECD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[18].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[19].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[19].spn_u32
	ECU_ADDRESS 0x70016ED0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[19].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[19].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[19].fmi_u8
	ECU_ADDRESS 0x70016ED4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[19].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[19].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[19].occ_u8
	ECU_ADDRESS 0x70016ED5
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[19].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[20].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[20].spn_u32
	ECU_ADDRESS 0x70016ED8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[20].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[20].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[20].fmi_u8
	ECU_ADDRESS 0x70016EDC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[20].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as[20].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as[20].occ_u8
	ECU_ADDRESS 0x70016EDD
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as[20].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[49].dtc_as ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[49].dtc_as
	ECU_ADDRESS 0x70016E40
	ARRAY_SIZE 160
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[49].dtc_as" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[1].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[1].spn_u32
	ECU_ADDRESS 0x70016EE4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[1].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[1].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[1].fmi_u8
	ECU_ADDRESS 0x70016EE8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[1].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[1].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[1].occ_u8
	ECU_ADDRESS 0x70016EE9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[1].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[2].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[2].spn_u32
	ECU_ADDRESS 0x70016EEC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[2].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[2].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[2].fmi_u8
	ECU_ADDRESS 0x70016EF0
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[2].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[2].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[2].occ_u8
	ECU_ADDRESS 0x70016EF1
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[2].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[3].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[3].spn_u32
	ECU_ADDRESS 0x70016EF4
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[3].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[3].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[3].fmi_u8
	ECU_ADDRESS 0x70016EF8
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[3].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[3].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[3].occ_u8
	ECU_ADDRESS 0x70016EF9
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[3].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[4].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[4].spn_u32
	ECU_ADDRESS 0x70016EFC
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[4].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[4].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[4].fmi_u8
	ECU_ADDRESS 0x70016F00
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[4].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[4].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[4].occ_u8
	ECU_ADDRESS 0x70016F01
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[4].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[5].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[5].spn_u32
	ECU_ADDRESS 0x70016F04
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[5].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[5].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[5].fmi_u8
	ECU_ADDRESS 0x70016F08
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[5].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[5].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[5].occ_u8
	ECU_ADDRESS 0x70016F09
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[5].occ_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[6].spn_u32 ""
	ULONG CnvRule_NumberOneToOne 1 0 0 4294967295
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[6].spn_u32
	ECU_ADDRESS 0x70016F0C
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[6].spn_u32" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[6].fmi_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[6].fmi_u8
	ECU_ADDRESS 0x70016F10
	SYMBOL_LINK "dataJ1939Dm1Failrs_as[50].dtc_as[6].fmi_u8" 0
/end MEASUREMENT


/begin MEASUREMENT dataJ1939Dm1Failrs_as[50].dtc_as[6].occ_u8 ""
	UBYTE CnvRule_NumberOneToOne 1 0 0 255
	DISPLAY_IDENTIFIER dataJ1939Dm1Failrs_as[50].dtc_as[6].occ_u8
