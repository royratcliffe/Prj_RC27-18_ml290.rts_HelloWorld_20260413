    rba_SyC_States_Wait_TimeoutHistoryDelay_MP
    "Timeout history for Wait Delay"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x7003043B

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for Wait Delay\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_TimeoutHistoryNetwork_MP
    "Timeout history for Wait Network"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x7003043C

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for Wait Network\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_TimeoutHistoryProlong_MP
    "Timeout history for Wait Prolong"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x7003043D

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for Wait Prolong\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_substate_MP
    "Sub-state of System Control state Wait"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Wait_CompuMethod
    1
    100
    0.0
    5.
    FORMAT "%8.3"
    ECU_ADDRESS 0x7003043F

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Sub-state of System Control state Wait\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_GlobalScope_Prolongers_MP
    "Prolongers in Global Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x70030435

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in Global Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_PostDriveScope_Delayers_MP
    "Delayers in PostDrive Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x70030433

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Delayers in PostDrive Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_PostDriveScope_Prolongers_MP
    "Prolongers in PostDrive Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x70030436

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in PostDrive Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_PrepareShutdownScope_Delayers_MP
    "Delayers in PrepareShutdown Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x70030432

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Delayers in PrepareShutdown Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_WaitScope_Delayers_MP
    "Delayers in Wait Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x70030434

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Delayers in Wait Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_User_WaitScope_Prolongers_MP
    "Prolongers in Wait Scope"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x70030437

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in Wait Scope\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiBoot_us_MP
    "Time elapsed for BOOT State in micro seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x70030414

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for BOOT State in micro seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiDrive_10ms_MP
    "Time elapsed for Drive State in 10 milli seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x70030404

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Drive State in 10 milli seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiInit_us_MP
    "Time elapsed for Init State in micro seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x70030410

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Init State in micro seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiLastShutdown_us_MP
    "Time elapsed for Last Shutdown State in micro seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x700303F8

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Shutdown State in micro seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiPostDrive_10ms_MP
    "Time elapsed for Post Drive State in 10 milli seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x70030400

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Post Drive State in 10 milli seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiPrepareDrive_10ms_MP
    "Time elapsed for Prepare drive State in 10 milli seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x70030408

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Prepare drive State in 10 milli seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiPrepareShutdown_10ms_MP
    "Time elapsed for Prepare Shutdown State in 10 milli seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x700303FC

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Prepare Shutdown State in 10 milli seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_tiWait_10ms_MP
    "Time elapsed for Wait State in 10 milli seconds"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x7003040C

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Time elapsed for Wait State in 10 milli seconds\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_T15_Signal_Debounced_MP
    "Debounced signal status of Terminal 15"
    UBYTE
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Status_CompuMethod
    1
    100
    0.0
    1.
    FORMAT "%8.3"
    ECU_ADDRESS 0x7003041E

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Debounced signal status of Terminal 15\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_T15_Signal_Logical_MP
    "Logical signal status of Terminal 15"
    UBYTE
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Status_CompuMethod
    1
    100
    0.0
    1.
    FORMAT "%8.3"
    ECU_ADDRESS 0x7003041F

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Logical signal status of Terminal 15\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_T15_Signal_UndebouncedValid_MP
    "Validity of undebounced signal status of Terminal 15"
    UBYTE
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_StatusValid_CompuMethod
    1
    100
    0.0
    1.
    FORMAT "%8.3"
    ECU_ADDRESS 0x7003041C

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Validity of undebounced signal status of Terminal 15\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_T15_Signal_Undebounced_MP
    "Undebounced signal status of Terminal 15"
    UBYTE
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Status_CompuMethod
    1
    100
    0.0
    1.
    FORMAT "%8.3"
    ECU_ADDRESS 0x7003041D

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Undebounced signal status of Terminal 15\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    Unconnected_DcmTest_EngineSpeed
    "unsigned integer 16bit"
    UWORD
    SwComponentTypes_ComDia_Dcm_Rte_Adapter_SwComponentTypes_EngN
    1
    100
    0.0
    65535.
    FORMAT "%6.3"
    MAX_REFRESH 6 1
    ECU_ADDRESS 0x6000B302


/end MEASUREMENT




/begin MEASUREMENT

    Unconnected_DcmTest_Timer
    "unsigned integer 16bit"
    UWORD
    SwComponentTypes_ComDia_Dcm_Rte_Adapter_SwComponentTypes_t100msxs_uw_b6553p5
    1
    100
    0.0
    65535.0
    MAX_REFRESH 6 1
    ECU_ADDRESS 0x6000B300


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_St_u32
    "State of the timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    ULONG
    TimedCom_HrmcCh_StMac_COMPU_VERB
    1
    1
    0.00
    4.00000000000
    FORMAT "%13.2"
    ECU_ADDRESS 0x70006130


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_TransLastDurInUs_u32
    "Execution time (us) of last transaction for timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    ULONG
    OneToOne_us
    1
    1
    0.00
    4294967295.00
    FORMAT "%13.2"
    ECU_ADDRESS 0x7000613C


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_Err_u16
    "Last error of the timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    UWORD
    TimedCom_HrmcCh_Err_COMPU_VERB
    1
    1
    0.00
    4.00000000000
    FORMAT "%13.2"
    ECU_ADDRESS 0x70006140


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_ErrCntr_u16
    "Error counter for timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    UWORD
    OneToOne
    1
    1
    0.00
    65536.00
    FORMAT "%13.2"
    ECU_ADDRESS 0x70006142


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_TransCntr_u32
    "Transaction counter for timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    ULONG
    OneToOne
    1
    1
    0.00
    4294967295.00
    FORMAT "%13.2"
    ECU_ADDRESS 0x70006144


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_SrcTskTransCntDwn_u32
    "Transaction counter of task OS_1ms_Task for timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    ULONG
    OneToOne
    1
    1
    0.00
    4294967295.00
    FORMAT "%13.2"
    ECU_ADDRESS 0x70006148


/end MEASUREMENT




/begin MEASUREMENT

    TimedCom_hchannel_HC_OS_1ms_Task__OS_10ms_Task.TimedCom_HrmcCh_DestTskTransCntDwn_u32
    "Transaction counter of task OS_10ms_Task for timed communication channel HC_OS_1ms_Task__OS_10ms_Task"
    ULONG
    OneToOne
    1
    1
    0.00
    4294967295.00
    FORMAT "%13.2"
    ECU_ADDRESS 0x7000614C


/end MEASUREMENT



/***********   End of merged MEASUREMENT blocks    ***********/
/begin MEASUREMENT

    ACCI_mEstimCAN
    "Vehiclemass of the Massestimationunit (needed to be written on the CAN)"
    SWORD
    ACCIMass
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B4DC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ACCI_rSlpRoad
    "Highway slope in ratio"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B4DA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ACCI_stMVeh
    "Qualification bit for the vehicle mass"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C811

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ACCI_stRSlpRoad
    "Qualification bit for the highway slope"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C810

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    AFS_mAirPerCyl
    "Air mass per cylinder"
    SWORD
    AirMassPerCyl
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B4D8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    AirSys_tFld
    "Temperature field, induction system"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6000B4D0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    AmbPres_dataDigSens
    ""
    SLONG
    p_q1_Pa
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003390

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    APP1_uRaw
    "."
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B4D6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    APP_r
    "Standardized accelerator pedal position"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B4D4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    APP_rUnFlt
    "Unfiltered APP value"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B4D2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ATS_ctCurRunTst
    "Number of current activated actuators"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C80F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ATS_IntvVal_mp
    "Intervention value"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70030336

/end MEASUREMENT

/begin MEASUREMENT

    ATS_stMon
    "status of ATS internal monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C81A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ATS_stMonTimeLimit
    "Behaviour time limit response for new tester demands"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C80E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ATS_TstStatus_mp
    "Status of actuatorintervention"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303EF

/end MEASUREMENT

/begin MEASUREMENT

    BasSvr_bFuncTstReq
    "condition general function request"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C814

/end MEASUREMENT

/begin MEASUREMENT

    BattU_facCor
    "Correction factor for battery voltage"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0x6000B4CE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    BattU_u
    "Battery voltage"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0x6000B4CC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    BattU_uRaw
    "Battery voltage before defect detection and handling"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B4CA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    BattU_uSens
    "Sensed battery voltage"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0x6000B4C8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    BrkP_uRaw
    "Raw voltage signal from brake pressure sensor."
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B4C6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Brk_r
    "Standardized angle of brake pedal"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B436

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Brk_st
    "Brake switch state"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C80D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Brk_stBrkBstWarn
    "Status to indicate low vacuum in brake booster"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C80C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Brk_stExt
    "This is SW-VARIABLE"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C80B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    B_deseehr_msg
    "Diagnosis power stage after the main Relay: entry conditions fulfilled"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    B_desee_msg
    "Diagnosis power stages, entry conditions fulfilled"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    B_eepwf
    "Condition Powerfail EEPROM"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000CA

/end MEASUREMENT

/begin MEASUREMENT

    B_PmdInit_msg
    "Reset of standard powerstage diagnosis required"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    B_pwf
    "condition for powerfail"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000C9

/end MEASUREMENT

/begin MEASUREMENT

    CEngDsT_t
    "Coolant temperature at engine output"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B4C4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Clth_st
    "Debounced status of Clutch"
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C80A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoDsplCtl_stCoErrLmp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C809

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoDsplCtl_stDiaBlnIntv
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B4C2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoDsplCtl_stSVSReq_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303EE

/end MEASUREMENT

/begin MEASUREMENT

    CoEng_bObdTmrInctg
    "OBD timer is incrementing"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x1
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6000C816

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_flgShOffCtrlDne
    "Flag: the engine shut off control is completed and there are no further CoEng requirements to control actuators."
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x600000C8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_st
    "Engine operation status"
    UBYTE
    CoEng_st_COMPU_VERB
    1
    100
    0.00
    5.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C807

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stMai
    "Variable for engine states"
    UWORD
    CoEng_stMai_VERB
    1
    100
    0.00
    16384.0000000

    
    FORMAT "%13.7"
    
    ECU_ADDRESS 0x6000B432

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stOld
    "engine state before current state was reached"
    UBYTE
    CoEng_st_COMPU_VERB
    1
    100
    0.00
    5.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C806

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_stStopEng
    "Engine STOP order from CoEng"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C805

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiNormal
    "time since state COENG_RUNNING was reached"
    ULONG
    Time_ms
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0x6000337C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEng_tiNormalOBD
    "Engine running time - for OBD requirement"
    ULONG
    Time_sec_q1_COMPU
    1
    100
    1.0000000
    65535.0000000

    
    FORMAT "%13.7"
    
    ECU_ADDRESS 0x60003378

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEOM_stDSCHEDDem
    "Operation mode demand from DSCHED"
    UWORD
    OneToOne
    1
    100
    1.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B434

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEOM_stOpModeActTSync
    "Diesel Particulate Filter Active Regeneration Status."
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003380

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEOM_stOpModePos
    "Bit mask of the possible operation modes for the DSM-Scheduler"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B460

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoEOM_stTransActv
    "Status if an operation mode change is active"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C73A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoESS_stRcpt
    "recuperation state"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C808

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoETS_rTrq
    "Calculated load value"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B4C0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_adrSrcAdrCtlDev
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7FA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_APP_rUnFlt
    ""
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B4BE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Bauteil_Temp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C803

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_elektr_Fehler
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C727

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Fehler_CAN_Comm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C738

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_IstStrom_Aufnahme
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C802

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Ist_Spannung
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C801

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_mech_Fehler
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C726

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_QBit_Bauteil_Temp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C737

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_QBit_Ist_Strom
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C736

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Regelabweichung
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C735

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_StromSens_KS_Masse
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C734

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_StromSens_KS_Plus
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C733

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Tempsens_KS_Masse
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C732

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Tempsens_KS_Plus
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C731

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Tempsens_OpenLoad
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C730

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Uberspannung_48V
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Ubertemperatur
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Ueberspannung_12V
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Unterspannung_12V
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Unterspannung_48V
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_Verpolung_48V
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C72A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_ZyklusBit_EEPROM
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C729

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_BOOST_ZyklusBit_kont
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C728

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ctENG11MsgCnt
    "Message counter value of CAN frame Motor_11"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7F9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ctENG12V6MsgCnt
    "Message counter information of CAN frame Motor_12"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7F8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ctENG20MsgCnt
    "Message counter value of CAN frame Motor_20"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7F7

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ctENG28MsgCnt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7F6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dataEngCod0
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7F2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dataEngCod1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7F1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dataEngCod2
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7F0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dataEngCod3
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7EF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dCANVer
    "Supported CAN version sent via CAN"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7F5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dDrvDemTrq
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7F4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_dOilTOut
    "CAN Value of the oil temperature"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7F3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_drAPPPrefilg
    "Absolute value for accelerator pedal position gradient sent on CAN"
    SWORD
    PrcPerSec_4ms
    1
    100
    -100000.0
    99996.9

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0x6000B4BC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ENG11Chksum
    "CAN signal Motor_11_CRC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C800

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ENG12V6Chksum
    "CAN signal Motor_12_CRC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7FF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ENG20Chksum
    "CAN signal Motor_20_CRC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7FE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_ENG28Chksum
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7FD

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_flgComNEngNeut
    "Neutral flag for Com_nEng"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_flgSwsVWGearActDspl
    "calibration variable"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C725

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_flgSwvar
    "Flag Variable for Pdu EcuVariant"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x70002B44

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_flgtrqClthEngNegAvl
    "calibration variable"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C724

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_Drehzahl_VM
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B45E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_Fehlerstatus_Antrieb_FDR
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7FC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_IstMoment_VKM
    "FlexRay Application Signal for Motor_28"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B45C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_Mom_Begr_Schalt
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B45A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_Mom_Begr_Schalt_Min
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B458

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_MO_Primaerachse_Anforderung
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7FB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_nEng
    "Engine speed sent over CAN"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B4BA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_nEngDes
    "Desired min/max engine speed for gearbox"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B4B8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_nEngMin
    "Desired minimal engine speed for gearbox"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B4B6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_nEngSpd
    ""
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B4B4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_numCDA
    "CAN signal MO_Anzahl_Abgesch_Zyl"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7EE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_numGearPos
    "CAN signal MO_Gangposition"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7ED

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_pCACDs
    "Boost Pressure"
    UWORD
    Pres_hPa
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B456

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_pEnv
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B4B2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_pwrPTC
    "CAN interface for signal MO_PTC_Leistung"
    UBYTE
    Pwr_50
    1
    100
    0.00
    12750.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0x6000C7EC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rActEngTrq
    ""
    SWORD
    Prc_trq
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B4B0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rActEngTrqHiRes
    ""
    SBYTE
    Trq_PrcHi
    1
    100
    -16.00
    15.88

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0x6000C812

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rEngDemTrq
    ""
    SWORD
    Prc_trq
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B4AE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rIncrRmn
    "Percentage value of torque-integral transmission intervention to be sent over CAN"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B4AC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rNOvrd
    "Influence of number of revolution"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B4AA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_rWaPmpHeat
    "CAN signal for MO_Heizungspumpenansteuerung"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B4A8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stAftRunTyp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7E9

/end MEASUREMENT

/begin MEASUREMENT

    Com_stAirCIntv
    "Status of the Air Conditioned Intervention"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7E8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stAPPGradSign
    "Sign of the accelerator pedal gradient transmitted via CAN"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7EB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stAPPLowIdl
    "Low Idle Information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7EA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stBrkTOut
    "Timeout brake message"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7E7

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stCarTyp
    "CAN signal for MO_Fahrzeugtyp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7E5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stCDA
    "CAN signal MO_Zylinderabschaltung"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7E6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stClthOut
    "Clutch switch Status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7E4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stCylShOff
    "State of cylinder shut off for CAN transmission"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7E3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stDFESEntry
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7E2

/end MEASUREMENT

/begin MEASUREMENT

    Com_stEng
    "Engine status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7E1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stEngTQBit
    "ComCIL interface of MO_QBit_Kuehlmittel_Temp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7E0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stEngTrqMode
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7DF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stEngTxt
    "Motor text bits"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7DE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stFlConsOvrFlw
    "fuel consumption &amp; Overflowbit in MSB"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7DD

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stGbxIntvLeadActv
    "Air path during gearbox intervention active"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7DC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stGearAdvPrs
    "CAN signal MO_Schaltempf_verfbar"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7DB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stGearPos
    "Display_position_gearbox"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7DA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stIntrLck
    "Interlock switch signal for CAN output"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7D9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stKD
    "Secured kick down signal"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7D8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stMILBlinkReq
    ""
    UBYTE
    Pres_hPa
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7D7

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stMILReq
    "status of external request for MIL illumination"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7D6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stOilTQBit
    "Qualification bit for Oil temperature"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7D5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stPFltRgnActv
    "CAN signal MO_DPF_reg"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7D4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stSCRWarn
    "Com interface for SCR Warning"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7D3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stStopReq
    ""
    UBYTE
    Pres_hPa
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7D0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stStSys
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7D1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stSVSReq
    "Blink or Illuminate SVS Lamp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7D2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stSysErr
    "CAN signal SCR_Systemfehler"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7CF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stSysLmp
    "Status system lamp for B8"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7CE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stTransptModeActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7CC

/end MEASUREMENT

/begin MEASUREMENT

    Com_stTRQ
    "Torque specification imprecise"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7CD

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stWaHtStg
    "Status of glow plugs"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7CB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_stWrnReq
    ""
    UBYTE
    Pres_hPa
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7CA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_swtSCRDsplEna
    "CAN signal SCR_verbaut"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7C9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_tEngTEng07
    "CAN signal MO_Kuehlmittel_Temp"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B4A6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_tEngTEng09
    "CAN signal MO_ITM_Kuehlmittel_Temp"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B4A4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_tIntkAirT
    "Intake Air temperature Sensor Value"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B4A2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEng
    "CAN signal MO_Mom_Ist_Summe"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B4A0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEngDes
    "Momentenanforderung Fahrpedal ACC ASR"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B49E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEngDesFlt
    "Momentenanforderung Fahrpedal ACC ASR gefiltert"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B49C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEngLimDyn
    "Maximal m�gliches Drehmoment mit ESP ASR Eingriff"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B49A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEngLimStat
    "Maximal m�gliches Drehmoment ohne ESP ASR Eingriff"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B498

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqClthEngNegAvl
    "CAN signal for MO_Mom_neg_verfuegbar"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B496

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Com_trqLos
    "Schub bzw. Verlustmoment ohne Gas"
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B494

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoVeh_bRollrModeActv
    "Status of local roll mode activates export BIT"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C804

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    CoVOM_bSailEna
    "Application variable for the flexray pdu"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C739

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DcmDspUds_DID_requestIBChk
    "Internal variable to request the Info Block check internaly"
    UBYTE
    DcmDspUds_DID_requestIBChk_Cnv
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x70001480

/end MEASUREMENT

/begin MEASUREMENT

    Dcm_stCallWr
    "Call state of writing information into EEPROM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C716

/end MEASUREMENT

/begin MEASUREMENT

    Dcm_stEepOrder
    "EEPROM order state of writing information into EEPROM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C715

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_rbr_mo_OV_VSS1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VSS1"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2EC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_rbr_mo_OV_VSS2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VSS2"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2EE

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_rbr_mo_UV_VSS1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VSS1"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2F0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_rbr_mo_UV_VSS2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VSS2"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2F2

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CANSM_E_BUS_OFF_NETWORK_0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2F4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CANSM_E_BUS_OFF_NETWORK_1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2F6

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CANSM_E_BUS_OFF_NETWORK_2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2F8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CANSM_E_BUS_OFF_NETWORK_3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2FA

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CANTRCV_E_NO_TRCV_CONTROL_0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2FC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_CAN_E_TIMEOUT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_CAN_E_TIMEOUT"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C2FE

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C300

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C302

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C304

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C306

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C308

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_COMM_E_NET_START_IND_CHANNEL_5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C30A

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_LIN_E_TIMEOUT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_LIN_E_TIMEOUT"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C30C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_ctArDebLvl.DFC_rba_MultiStackTrace_Threshold
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rba_MultiStackTrace_Threshold"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C30E

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80c7
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80c7"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A458

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80c8
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80c8"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A45C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80c9
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80c9"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A460

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ca
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ca"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A464

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80cb
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80cb"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A468

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80cc
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80cc"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A46C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80cd
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80cd"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A470

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ce
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ce"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A474

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80cf
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80cf"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A478

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80d0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80d0"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A47C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80d1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80d1"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A480

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80d2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80d2"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A484

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80d3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80d3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A488

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80d4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80d4"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A48C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80d5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80d5"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A490

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80d6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80d6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A494

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80d7
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80d7"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A498

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80d8
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80d8"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A49C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80d9
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80d9"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4A0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80da
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80da"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4A4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80db
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80db"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4A8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80dc
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80dc"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4AC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80dd
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80dd"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4B0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80de
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80de"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4B4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80df
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80df"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4B8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80e0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80e0"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4BC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80e1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80e1"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4C0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80e2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80e2"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4C4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80e3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80e3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4C8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80e4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80e4"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4CC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80e5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80e5"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4D0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80e6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80e6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4D4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80e7
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80e7"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4D8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80e8
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80e8"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4DC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80e9
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80e9"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4E0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ea
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ea"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4E4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80eb
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80eb"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4E8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ec
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ec"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4EC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ed
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ed"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4F0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ee
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ee"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4F4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ef
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ef"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4F8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80f0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80f0"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A4FC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80f1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80f1"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A500

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80f2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80f2"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A504

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80f3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80f3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A508

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80f4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80f4"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A50C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80f5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80f5"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A510

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80f6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80f6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A514

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80f7
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80f7"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A518

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80f8
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80f8"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A51C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80f9
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80f9"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A520

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80fa
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80fa"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A524

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80fb
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80fb"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A528

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80fc
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80fc"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A52C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80fd
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80fd"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A530

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80fe
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80fe"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A534

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ff
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ff"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A538

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8100
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8100"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A53C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8101
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8101"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A540

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8102
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8102"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A544

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8103
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8103"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A548

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8104
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8104"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A54C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8105
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8105"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A550

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8106
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8106"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A554

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8107
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8107"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A558

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8108
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8108"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A55C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8109
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8109"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A560

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x810a
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x810a"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A564

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x810b
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x810b"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A568

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x810c
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x810c"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A56C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x810d
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x810d"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A570

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x810e
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x810e"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A574

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x810f
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x810f"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A578

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8110
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8110"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A57C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8111
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8111"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A580

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8112
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8112"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A584

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8113
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8113"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A588

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8114
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8114"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A58C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8115
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8115"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A590

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8116
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8116"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A594

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8117
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8117"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A598

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8118
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8118"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A59C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8119
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8119"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5A0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x811a
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x811a"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5A4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x811b
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x811b"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5A8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x811c
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x811c"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5AC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x811d
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x811d"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5B0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x811e
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x811e"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5B4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x811f
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x811f"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5B8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8120
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8120"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5BC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8121
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8121"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5C0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8122
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8122"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5C4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8123
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8123"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5C8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8124
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8124"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5CC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8125
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8125"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5D0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8126
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8126"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5D4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8127
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8127"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5D8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8128
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8128"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5DC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8129
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8129"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5E0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x812a
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x812a"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5E4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_TiInRow0x8B01
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_TiInRow0x8B01"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5E8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_TiInRow0x8B02
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_TiInRow0x8B02"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5EC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_TiInRow0x8B03
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_TiInRow0x8B03"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5F0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_DevLibBattUHi
    "Debouncing counters / Debounce Timer or Event counter for check DFC_DevLibBattUHi"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5F4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_DevLibBattULo
    "Debouncing counters / Debounce Timer or Event counter for check DFC_DevLibBattULo"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5F8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8063
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8063"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A5FC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8064
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8064"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A600

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8065
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8065"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A604

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8066
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8066"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A608

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8067
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8067"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A60C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8068
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8068"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A610

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8069
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8069"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A614

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x806a
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x806a"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A618

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x806b
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x806b"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A61C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x806c
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x806c"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A620

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x806d
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x806d"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A624

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x806e
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x806e"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A628

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x806f
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x806f"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A62C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8070
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8070"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A630

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8071
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8071"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A634

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8072
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8072"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A638

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8073
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8073"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A63C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8074
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8074"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A640

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8075
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8075"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A644

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8076
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8076"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A648

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8077
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8077"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A64C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8078
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8078"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A650

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8079
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8079"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A654

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x807a
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x807a"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A658

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x807b
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x807b"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A65C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x807c
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x807c"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A660

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x807d
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x807d"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A664

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x807e
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x807e"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A668

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x807f
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x807f"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A66C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8080
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8080"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A670

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8081
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8081"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A674

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8082
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8082"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A678

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8083
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8083"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A67C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8084
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8084"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A680

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8085
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8085"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A684

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8086
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8086"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A688

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8087
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8087"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A68C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8088
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8088"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A690

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8089
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8089"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A694

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x808a
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x808a"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A698

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x808b
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x808b"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A69C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x808c
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x808c"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6A0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x808d
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x808d"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6A4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x808e
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x808e"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6A8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x808f
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x808f"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6AC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8090
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8090"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6B0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8091
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8091"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6B4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8092
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8092"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6B8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8093
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8093"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6BC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8094
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8094"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6C0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8095
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8095"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6C4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8096
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8096"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6C8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8097
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8097"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6CC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8098
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8098"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6D0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x8099
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x8099"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6D4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x809a
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x809a"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6D8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x809b
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x809b"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6DC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x809c
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x809c"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6E0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x809d
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x809d"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6E4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x809e
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x809e"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6E8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x809f
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x809f"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6EC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80a0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80a0"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6F0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80a1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80a1"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6F4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80a2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80a2"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6F8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80a3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80a3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A6FC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80a4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80a4"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A700

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80a5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80a5"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A704

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80a6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80a6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A708

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80a7
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80a7"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A70C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80a8
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80a8"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A710

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80a9
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80a9"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A714

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80aa
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80aa"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A718

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ab
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ab"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A71C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ac
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ac"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A720

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ad
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ad"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A724

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ae
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ae"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A728

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80af
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80af"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A72C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80b0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80b0"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A730

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80b1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80b1"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A734

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80b2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80b2"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A738

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80b3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80b3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A73C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80b4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80b4"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A740

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80b5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80b5"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A744

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80b6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80b6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A748

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80b7
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80b7"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A74C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80b8
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80b8"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A750

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80b9
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80b9"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A754

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80ba
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80ba"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A758

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80bb
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80bb"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A75C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80bc
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80bc"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A760

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80bd
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80bd"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A764

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80be
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80be"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A768

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80bf
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80bf"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A76C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80c0
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80c0"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A770

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80c1
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80c1"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A774

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80c2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80c2"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A778

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80c3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80c3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A77C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80c4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80c4"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A780

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80c5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80c5"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A784

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_NoDeb0x80c6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_NoDeb0x80c6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A788

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_TiUpDwn0x8A01
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_TiUpDwn0x8A01"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A78C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_TiUpDwn0x8A02
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_TiUpDwn0x8A02"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A790

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_bds_TiUpDwn0x8A03
    "Debouncing counters / Debounce Timer or Event counter for check DFC_bds_TiUpDwn0x8A03"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A794

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA13OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA13OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A798

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA13SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA13SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A79C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA13SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA13SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7A0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA14OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA14OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7A4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA14SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA14SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7A8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA14SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA14SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7AC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA21OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA21OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7B0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA21SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA21SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7B4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA21SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA21SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7B8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA22OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA22OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7BC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA22SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA22SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7C0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA22SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA22SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7C4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA23OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA23OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7C8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA23SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA23SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7CC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA23SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA23SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7D0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA24OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA24OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7D4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA24SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA24SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7D8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA24SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA24SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7DC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA25OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA25OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7E0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA25SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA25SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7E4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA25SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA25SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7E8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA26OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA26OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7EC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA26SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA26SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7F0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA26SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA26SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7F4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA27OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA27OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7F8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA27SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA27SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A7FC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA27SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA27SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A800

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA28OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA28OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A804

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA28SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA28SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A808

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA28SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA28SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A80C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA29OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA29OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A810

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA29SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA29SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A814

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA29SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA29SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A818

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A81C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A820

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A824

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A828

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A82C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA36ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA36ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A830

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A834

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A838

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A83C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A840

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A844

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA37ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA37ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A848

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A84C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A850

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A854

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A858

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A85C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA38ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA38ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A860

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A864

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A868

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A86C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A870

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A874

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA39ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA39ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A878

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA40OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA40OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A87C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA40SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA40SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A880

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA40SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA40SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A884

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA41OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA41OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A888

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA41SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA41SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A88C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA41SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA41SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A890

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA42OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA42OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A894

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA42SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA42SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A898

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA42SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA42SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A89C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8A0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8A4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8A8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8AC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8B0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA43ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA43ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8B4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA44OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA44OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8B8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA44SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA44SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8BC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA44SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA44SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8C0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA57OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA57OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8C4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA57SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA57SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8C8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA57SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA57SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8CC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA59OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA59OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8D0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA59SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA59SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8D4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inA59SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inA59SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8D8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK10OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK10OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8DC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK10SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK10SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8E0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK10SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK10SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8E4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK11OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK11OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8E8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK11SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK11SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8EC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK11SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK11SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8F0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8F4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8F8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A8FC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A900

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A904

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK30ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK30ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A908

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK31OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK31OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A90C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK31SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK31SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A910

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK31SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK31SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A914

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK32OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK32OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A918

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK32SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK32SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A91C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK32SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK32SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A920

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK33OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK33OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A924

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK33SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK33SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A928

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK33SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK33SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A92C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK34OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK34OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A930

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK34SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK34SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A934

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK34SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK34SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A938

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK35OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK35OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A93C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK35SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK35SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A940

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK35SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK35SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A944

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK36OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK36OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A948

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK36SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK36SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A94C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK36SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK36SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A950

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A954

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A958

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A95C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A960

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A964

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK37ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK37ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A968

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A96C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A970

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A974

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A978

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A97C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK38ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK38ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A980

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A984

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A988

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A98C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A990

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A994

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK39ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK39ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A998

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A99C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9A0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9A4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9A8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9AC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK40ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK40ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9B0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9B4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9B8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9BC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9C0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9C4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK41ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK41ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9C8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9CC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9D0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9D4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9D8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9DC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK42ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK42ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9E0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK43OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK43OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9E4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK43SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK43SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9E8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK43SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK43SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9EC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9F0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9F4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9F8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000A9FC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK44ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK44ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK45ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK45ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK52OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK52OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK52SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK52SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK52SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK52SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK53OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK53OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK53SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK53SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK53SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK53SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK54ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK54ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK55ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK55ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK56OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK56OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK56SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK56SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK56SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK56SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK57OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK57OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK57SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK57SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK57SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK57SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK58OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK58OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK58SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK58SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK58SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK58SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK59OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK59OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK59SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK59SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK59SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK59SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA94

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK60OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK60OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA98

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK60SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK60SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AA9C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK60SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK60SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAA0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAA4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAA8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAAC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAB0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAB4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK61ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK61ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAB8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK62OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK62OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AABC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK62SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK62SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAC0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK62SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK62SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAC4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAC8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AACC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAD0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAD4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAD8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK63ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK63ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AADC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAE0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAE4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAE8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAEC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAF0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK64ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK64ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAF4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65AicSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65AicSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAF8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65AicSCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65AicSCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AAFC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK65ShuntSCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK65ShuntSCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK74OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK74OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK74SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK74SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK74SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK74SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK75OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK75OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK75SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK75SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK75SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK75SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK76OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK76OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK76SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK76SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK76SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK76SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK77OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK77OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK77SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK77SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK77SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK77SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK78OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK78OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK78SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK78SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_inK78SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_inK78SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_DvUBAT_FWs
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_DvUBAT_FWs"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OVErr_VPR6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OVErr_VPR6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OVWarn_VPR6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OVWarn_VPR6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_UBAT_MON
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_UBAT_MON"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_UBRM24_FLEXIN
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_UBRM24_LOADS
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_UBRM24_LOADS"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_UBRM24_MON
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_UBRM24_MON"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_VDD5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VDD5"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_VDD5_IN
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VDD5_IN"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_VPR6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VPR6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_VSS3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VSS3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_OV_VSS4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_OV_VSS4"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_Temp1_HTErr
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_Temp1_HTErr"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_Temp1_HTWarn
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_Temp1_HTWarn"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_Temp2_HTErr
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_Temp2_HTErr"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_Temp2_HTWarn
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_Temp2_HTWarn"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB94

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB98

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_VDD5
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VDD5"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AB9C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_VDD5_IN
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VDD5_IN"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABA0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_VPR6
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VPR6"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABA4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_VSS3
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VSS3"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABA8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_mo_UV_VSS4
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_mo_UV_VSS4"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABAC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA01OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA01OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABB0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA01OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA01OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABB4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA01SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA01SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABB8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA01SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA01SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABBC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA02OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA02OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABC0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA02OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA02OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABC4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA02OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA02OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABC8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA02SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA02SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABCC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA02SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA02SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABD0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA03OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA03OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABD4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA03OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA03OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABD8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA03SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA03SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABDC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA03SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA03SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABE0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA04OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA04OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABE4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA04OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA04OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABE8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA04SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA04SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABEC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA04SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA04SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABF0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA05OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA05OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABF4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA05OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA05OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABF8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA05OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA05OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ABFC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA05SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA05SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA05SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA05SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA06OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA06OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA06OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA06OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA06OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA06OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA06SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA06SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA06SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA06SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA07OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA07OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA07OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA07OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA07SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA07SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA07SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA07SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA08OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA08OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA08OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA08OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA08SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA08SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA08SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA08SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA09OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA09OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA09OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA09OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA09OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA09OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA09SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA09SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA09SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA09SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA10OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA10OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA10OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA10OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA10SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA10SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA10SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA10SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA11OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA11OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA11OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA11OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA11SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA11SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA11SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA11SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA12OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA12OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA12SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA12SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA12SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA12SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA16OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA16OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA16OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA16OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA16SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA16SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA16SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA16SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA17OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA17OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA17OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA17OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA17OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA17OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC94

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA17SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA17SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC98

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA17SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA17SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AC9C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA18OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA18OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACA0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA18OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA18OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACA4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA18SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA18SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACA8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA18SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA18SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACAC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA19OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA19OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACB0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA19OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA19OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACB4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA19OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA19OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACB8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA19SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA19SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACBC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA19SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA19SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACC0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA20OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA20OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACC4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA20OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA20OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACC8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA20OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA20OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACCC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA20SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA20SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACD0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA20SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA20SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACD4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA31OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA31OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACD8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA31OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA31OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACDC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA31OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA31OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACE0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA31SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA31SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACE4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA31SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA31SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACE8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA32OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA32OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACEC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA32OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA32OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACF0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA32OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA32OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACF4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA32SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA32SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACF8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA32SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA32SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ACFC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA33OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA33OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA33OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA33OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA33OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA33OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA33SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA33SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA33SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA33SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA34OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA34OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA34OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA34OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA34OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA34OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA34SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA34SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA34SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA34SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA35OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA35OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA35OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA35OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA35OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA35OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA35SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA35SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA35SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA35SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA46OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA46OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA46OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA46OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA46OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA46OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA46SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA46SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA46SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA46SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA47OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA47OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA47OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA47OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA47OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA47OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA47SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA47SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA47SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA47SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA48OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA48OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA48OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA48OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA48OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA48OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA48SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA48SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA48SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA48SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA49OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA49OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA49OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA49OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA49SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA49SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA49SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA49SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA50OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA50OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA50OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA50OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA50SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA50SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA50SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA50SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD94

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA51OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA51OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD98

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA51OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA51OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AD9C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA51OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA51OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADA0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA51SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA51SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADA4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA51SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA51SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADA8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA52OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA52OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADAC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA52OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA52OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADB0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA52OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA52OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADB4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA52SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA52SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADB8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA52SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA52SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADBC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA53OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA53OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADC0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA53OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA53OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADC4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA53OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA53OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADC8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA53SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA53SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADCC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA53SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA53SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADD0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA54OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA54OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADD4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA54OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA54OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADD8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA54OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA54OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADDC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA54SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA54SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADE0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA54SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA54SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADE4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA55OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA55OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADE8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA55OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA55OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADEC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA55SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA55SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADF0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA55SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA55SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADF4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA56OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA56OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADF8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA56OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA56OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000ADFC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA56SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA56SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA56SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA56SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA58OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA58OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA58OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA58OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA58SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA58SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outA58SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outA58SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK07OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK07OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK07OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK07OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK07OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK07OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK07SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK07SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK07SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK07SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK08OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK08OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK08OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK08OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK08OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK08OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK08SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK08SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK08SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK08SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK09OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK09OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK09OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK09OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK09OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK09OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK09SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK09SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK09SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK09SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK12OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK12OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK12OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK12OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK12SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK12SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK12SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK12SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK13OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK13OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK13OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK13OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK13SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK13SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK13SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK13SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK14OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK14OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK14OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK14OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK14OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK14OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK14SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK14SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK14SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK14SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK15OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK15OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK15OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK15OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK15OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK15OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK15SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK15SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE94

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK15SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK15SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE98

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK16OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK16OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AE9C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK16OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK16OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEA0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK16OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK16OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEA4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK16SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK16SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEA8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK16SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK16SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEAC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK17OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK17OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEB0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK17OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK17OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEB4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK17OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK17OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEB8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK17SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK17SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEBC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK17SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK17SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEC0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK25OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK25OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEC4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK25SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK25SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEC8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK25SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK25SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AECC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK29OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK29OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AED0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK29OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK29OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AED4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK29OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK29OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AED8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK29SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK29SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEDC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK29SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK29SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEE0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK51OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK51OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEE4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK51OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK51OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEE8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK51SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK51SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEEC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK51SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK51SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEF0

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK62OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK62OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEF4

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK62SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK62SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEF8

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK62SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK62SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AEFC

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK73OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK73OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF00

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK73OR
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK73OR"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF04

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK73OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK73OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF08

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK73SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK73SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF0C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK73SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK73SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF10

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK80OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK80OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF14

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK80OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK80OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF18

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK80SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK80SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF1C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK80SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK80SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF20

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK81OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK81OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF24

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK81OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK81OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF28

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK81SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK81SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF2C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK81SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK81SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF30

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK82OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK82OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF34

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK82OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK82OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF38

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK82SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK82SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF3C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK82SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK82SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF40

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK83OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK83OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF44

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK83OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK83OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF48

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK83SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK83SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF4C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK83SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK83SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF50

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK84OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK84OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF54

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK84OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK84OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF58

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK84SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK84SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF5C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK84SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK84SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF60

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK85OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK85OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF64

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK85OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK85OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF68

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK85SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK85SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF6C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK85SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK85SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF70

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK86OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK86OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF74

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK86OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK86OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF78

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK86SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK86SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF7C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK86SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK86SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF80

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK87OL
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK87OL"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF84

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK87OT
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK87OT"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF88

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK87SCB
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK87SCB"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF8C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_St.DFC_rbr_outK87SCG
    "Debouncing counters / Debounce Timer or Event counter for check DFC_rbr_outK87SCG"
    ULONG
    DFC_OneToOne
    1
    100
    0.00
    536870911.000

    BIT_MASK 0x1fffffff
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000AF90

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_rbr_mo_OV_VSS1
    "Monitoring state / Monitoring state of DFC_rbr_mo_OV_VSS1"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D159

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_rbr_mo_OV_VSS2
    "Monitoring state / Monitoring state of DFC_rbr_mo_OV_VSS2"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15A

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_rbr_mo_UV_VSS1
    "Monitoring state / Monitoring state of DFC_rbr_mo_UV_VSS1"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15B

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_rbr_mo_UV_VSS2
    "Monitoring state / Monitoring state of DFC_rbr_mo_UV_VSS2"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15C

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CANSM_E_BUS_OFF_NETWORK_0
    "Monitoring state / Monitoring state of DFC_CANSM_E_BUS_OFF_NETWORK_0"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15D

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CANSM_E_BUS_OFF_NETWORK_1
    "Monitoring state / Monitoring state of DFC_CANSM_E_BUS_OFF_NETWORK_1"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15E

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CANSM_E_BUS_OFF_NETWORK_2
    "Monitoring state / Monitoring state of DFC_CANSM_E_BUS_OFF_NETWORK_2"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D15F

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CANSM_E_BUS_OFF_NETWORK_3
    "Monitoring state / Monitoring state of DFC_CANSM_E_BUS_OFF_NETWORK_3"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D160

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CANTRCV_E_NO_TRCV_CONTROL_0
    "Monitoring state / Monitoring state of DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D161

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_CAN_E_TIMEOUT
    "Monitoring state / Monitoring state of DFC_CAN_E_TIMEOUT"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D162

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_0
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_0"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D163

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_1
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_1"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D164

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_2
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_2"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D165

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_3
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_3"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D166

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_4
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_4"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D167

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_COMM_E_NET_START_IND_CHANNEL_5
    "Monitoring state / Monitoring state of DFC_COMM_E_NET_START_IND_CHANNEL_5"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D168

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_LIN_E_TIMEOUT
    "Monitoring state / Monitoring state of DFC_LIN_E_TIMEOUT"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D169

/end MEASUREMENT

/begin MEASUREMENT

    DDRC_stLstRprtEve.DFC_rba_MultiStackTrace_Threshold
    "Monitoring state / Monitoring state of DFC_rba_MultiStackTrace_Threshold"
    UBYTE
    DDRC_LstRprtEve_VERB
    1
    100
    0.00
    255.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000D16A

/end MEASUREMENT

/begin MEASUREMENT

    DELib_idxArrSnsr
    "e_:SW Version of DELib calibration data:_e;d_:SW Version der Applikationsdaten:_d"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000B446

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DELib_numVar_mp
    "SW Version variant of DELibPackage (110 = DELibPackage_1.1.0)"
    UWORD
    OneToOne
    1
    100
    0.
    65535.

    
    FORMAT "%10.0"
    
    ECU_ADDRESS 0x6000B4E0

/end MEASUREMENT

/begin MEASUREMENT

    DELib_num_mp
    "e_:SW Version of DELibPackage (1110 = DELibPackage.1.11.0):_e;d_:SW Version der DELibPackage 1110 = DELibPackage.1.11.0):_d"
    UWORD
    OneToOne
    1
    100
    0.
    65535.

    
    FORMAT "%10.0"
    
    ECU_ADDRESS 0x6000B4DE

/end MEASUREMENT

/begin MEASUREMENT

    DELib_stArrSnsr
    "e_:SW Version of DELib calibration data:_e;d_:SW Version der Applikationsdaten:_d"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000C7C1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DELib_stFirstPreDrvOverCopy
    "status of First Pre Drive over copy"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7C0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DELib_xArrSnsr
    "e_:Array to hold float values of sensors:_e;d_:SW Version der Applikationsdaten:_d"
    FLOAT32_IEEE
    OneToOne
    1
    100
    -1.00000000E+037
    1.00000000E+037

    
    FORMAT "%13.3"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x600033A0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Dem_BswErrorBufferWriteCounter
    "Write access counter"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x7000A7E0

/end MEASUREMENT

/begin MEASUREMENT

    Dem_BswErrorBufferWriteIndex
    "Write index for pre init buffer"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x7000A7E2

/end MEASUREMENT

/begin MEASUREMENT

    Dem_disableEventStatusUpdateGroup
    "Bit encoded DTCGroups disabled for EventStatusUpdate"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7000BA9C

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltForFltDetnCntr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000BA9F

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltFormat
    "DTCFormat parameter of current Dem_SetDTCFilter() request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000BAA7

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltOrigin
    "DTCOrigin parameter of current Dem_SetDTCFilter() request"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000A608

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltProcCnt
    "Number of DTCs found to current Dem_SetDTCFilter() request"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000A614

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltProcIdx
    "Loop index for asynchron Dem_SetDTCFilter() processing"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000A618

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltRecFormat
    "DTCFormat parameter of current Dem_SetFreezeFrameRecordFilter() request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000BAA1

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltRecRsltIdx
    "Index variable for incremental GetNextFilteredRecord output"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000A60C

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltRsltIdx
    "Index variable for incremental GetNextFilteredDTCxxx output"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000A610

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltSeverity
    "DTCSeverity parameter of current Dem_SetDTCFilter() request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000BAA3

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltSt
    "Current state of Dem_SetDTCFilter() processing"
    UBYTE
    Dem_DTCFltSt_Verb
    1
    100
    0.00
    5.00000000000

    
    FORMAT "%13.11"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000BA9D

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltStatusMask
    "DTCStatusMask parameter of current Dem_SetDTCFilter() request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000BAA9

/end MEASUREMENT

/begin MEASUREMENT

    Dem_DTCFltWithSev
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x7000BAA5

/end MEASUREMENT

/begin MEASUREMENT

    Dem_PTOSt
    "Current PTO active status reported to Dem"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7000BB46

/end MEASUREMENT

/begin MEASUREMENT

    Dem_stInit
    "Initialization state of Dem"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x7000BB65

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stDigOutErr_mp
    "Measuring point that contains the error information received from HWE for the digital out signal selected by DevLib_DigOutDbgSig_C"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x7003017C

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stDigOutPrevTst_mp
    "Measuring point for the previous test result for the digital out signal selected by DevLib_DigOutDbgSig_C"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70030334

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stDigOutTstImp_mp
    "Measuring point for the frequency of the test impulse sent to the digital out powerstage selected by DevLib_DigOutDbgSig_C"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303ED

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPWMOutErr_mp
    "Measuring point that contains the error information received from HWE for the PWM out signal selected by DevLib_PWMOutDbgSig_C"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030178

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPWMOutPrevTst_mp
    "Measuring point for the previous test result for the PWM out signal selected by DevLib_PWMOutDbgSig_C"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70030332

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPWMOutTstImp_mp
    "Measuring point for the frequency of the test impulse sent to the PWM out powerstage selected by DevLib_PWMOutDbgSig_C"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303EC

/end MEASUREMENT

/begin MEASUREMENT

    DevLib_stPwrStgEnaCond
    "Device Library - state of powerstage enabling conditions"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B442

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DFC_lenMaxCllsn
    "Measurement longest DFC Kollision"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60037E00

/end MEASUREMENT

/begin MEASUREMENT

    DFC_nrCllsnClear
    "Number of DFC collisions at fcmclear"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002A9C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_nrCllsnReInit
    "Number of DFC collisions at reInit"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002A98

/end MEASUREMENT

/begin MEASUREMENT

    DFC_nrCllsnReport
    "Number of DFC collisions at report"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002A94

/end MEASUREMENT

/begin MEASUREMENT

    DFC_numDfcMaxCllsn
    "DFC which encountered the longest collision"
    UWORD
    DFCDFP_Verb
    1
    100
    0.00
    1312.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x60037DFE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_Unused
    "Status of DFC / "
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F66

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80c7
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80c7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F67

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80c8
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80c8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F68

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80c9
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80c9"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F69

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ca
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ca"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80cb
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80cb"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80cc
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80cc"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80cd
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80cd"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ce
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ce"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80cf
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80cf"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F6F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80d0
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80d0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F70

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80d1
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80d1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F71

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80d2
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80d2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F72

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80d3
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80d3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F73

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80d4
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80d4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F74

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80d5
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80d5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F75

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80d6
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80d6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F76

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80d7
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80d7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F77

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80d8
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80d8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F78

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80d9
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80d9"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F79

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80da
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80da"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80db
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80db"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80dc
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80dc"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80dd
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80dd"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80de
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80de"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80df
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80df"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F7F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80e0
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80e0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F80

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80e1
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80e1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F81

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80e2
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80e2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F82

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80e3
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80e3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F83

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80e4
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80e4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F84

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80e5
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80e5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F85

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80e6
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80e6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F86

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80e7
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80e7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F87

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80e8
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80e8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F88

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80e9
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80e9"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F89

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ea
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ea"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80eb
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80eb"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ec
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ec"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ed
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ed"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ee
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ee"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ef
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ef"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F8F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80f0
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80f0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F90

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80f1
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80f1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F91

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80f2
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80f2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F92

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80f3
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80f3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F93

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80f4
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80f4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F94

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80f5
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80f5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F95

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80f6
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80f6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F96

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80f7
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80f7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F97

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80f8
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80f8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F98

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80f9
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80f9"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F99

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80fa
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80fa"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80fb
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80fb"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80fc
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80fc"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80fd
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80fd"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80fe
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80fe"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ff
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ff"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036F9F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8100
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8100"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8101
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8101"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8102
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8102"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8103
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8103"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8104
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8104"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8105
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8105"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8106
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8106"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8107
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8107"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8108
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8108"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8109
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8109"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FA9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x810a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x810a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x810b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x810b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x810c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x810c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x810d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x810d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x810e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x810e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x810f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x810f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FAF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8110
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8110"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8111
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8111"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8112
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8112"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8113
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8113"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8114
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8114"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8115
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8115"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8116
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8116"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8117
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8117"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8118
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8118"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8119
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8119"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FB9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x811a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x811a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x811b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x811b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x811c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x811c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x811d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x811d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x811e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x811e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x811f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x811f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FBF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8120
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8120"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8121
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8121"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8122
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8122"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8123
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8123"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8124
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8124"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8125
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8125"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8126
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8126"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8127
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8127"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8128
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8128"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8129
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8129"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FC9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x812a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x812a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_TiInRow0x8B01
    "Status of DFC / Status of diagnostic fault check DFC_bds_TiInRow0x8B01"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_TiInRow0x8B02
    "Status of DFC / Status of diagnostic fault check DFC_bds_TiInRow0x8B02"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_TiInRow0x8B03
    "Status of DFC / Status of diagnostic fault check DFC_bds_TiInRow0x8B03"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_DevLibBattUHi
    "Status of DFC / Status of diagnostic fault check DFC_DevLibBattUHi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_DevLibBattULo
    "Status of DFC / Status of diagnostic fault check DFC_DevLibBattULo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FCF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8063
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8063"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8064
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8064"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8065
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8065"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8066
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8066"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8067
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8067"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8068
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8068"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8069
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8069"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x806a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x806a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x806b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x806b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x806c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x806c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FD9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x806d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x806d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x806e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x806e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x806f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x806f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8070
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8070"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8071
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8071"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8072
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8072"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FDF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8073
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8073"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8074
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8074"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8075
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8075"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8076
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8076"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8077
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8077"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8078
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8078"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8079
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8079"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x807a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x807a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x807b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x807b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x807c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x807c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FE9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x807d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x807d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FEA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x807e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x807e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FEB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x807f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x807f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FEC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8080
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8080"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FED

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8081
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8081"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FEE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8082
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8082"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FEF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8083
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8083"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8084
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8084"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8085
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8085"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8086
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8086"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8087
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8087"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8088
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8088"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8089
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8089"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x808a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x808a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x808b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x808b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x808c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x808c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FF9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x808d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x808d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x808e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x808e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x808f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x808f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8090
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8090"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8091
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8091"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8092
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8092"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036FFF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8093
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8093"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037000

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8094
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8094"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037001

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8095
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8095"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037002

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8096
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8096"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037003

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8097
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8097"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037004

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8098
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8098"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037005

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8099
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8099"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037006

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x809a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x809a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037007

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x809b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x809b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037008

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x809c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x809c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037009

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x809d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x809d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x809e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x809e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x809f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x809f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80a0
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80a0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80a1
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80a1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80a2
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80a2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003700F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80a3
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80a3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037010

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80a4
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80a4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037011

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80a5
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80a5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037012

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80a6
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80a6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037013

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80a7
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80a7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037014

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80a8
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80a8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037015

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80a9
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80a9"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037016

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80aa
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80aa"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037017

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ab
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ab"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037018

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ac
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ac"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037019

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ad
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ad"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ae
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ae"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80af
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80af"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80b0
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80b0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80b1
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80b1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80b2
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80b2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003701F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80b3
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80b3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037020

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80b4
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80b4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037021

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80b5
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80b5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037022

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80b6
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80b6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037023

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80b7
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80b7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037024

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80b8
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80b8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037025

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80b9
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80b9"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037026

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80ba
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80ba"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037027

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80bb
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80bb"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037028

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80bc
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80bc"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037029

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80bd
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80bd"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80be
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80be"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80bf
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80bf"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80c0
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80c0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80c1
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80c1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80c2
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80c2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003702F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80c3
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80c3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037030

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80c4
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80c4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037031

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80c5
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80c5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037032

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x80c6
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x80c6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037033

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_TiUpDwn0x8A01
    "Status of DFC / Status of diagnostic fault check DFC_bds_TiUpDwn0x8A01"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037034

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_TiUpDwn0x8A02
    "Status of DFC / Status of diagnostic fault check DFC_bds_TiUpDwn0x8A02"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037035

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_TiUpDwn0x8A03
    "Status of DFC / Status of diagnostic fault check DFC_bds_TiUpDwn0x8A03"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037036

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA13OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA13OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037037

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA13SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA13SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037038

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA13SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA13SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037039

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA14OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA14OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA14SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA14SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA14SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA14SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA21OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA21OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA21SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA21SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA21SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA21SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003703F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA22OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA22OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037040

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA22SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA22SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037041

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA22SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA22SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037042

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA23OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA23OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037043

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA23SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA23SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037044

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA23SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA23SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037045

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA24OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA24OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037046

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA24SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA24SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037047

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA24SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA24SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037048

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA25OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA25OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037049

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA25SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA25SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA25SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA25SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA26OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA26OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA26SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA26SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA26SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA26SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA27OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA27OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003704F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA27SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA27SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037050

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA27SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA27SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037051

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA28OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA28OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037052

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA28SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA28SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037053

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA28SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA28SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037054

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA29OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA29OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037055

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA29SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA29SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037056

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA29SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA29SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037057

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037058

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037059

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA36ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA36ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003705F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037060

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037061

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037062

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA37ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA37ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037063

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037064

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037065

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037066

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037067

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037068

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA38ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA38ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037069

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA39ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA39ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003706F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA40OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA40OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037070

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA40SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA40SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037071

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA40SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA40SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037072

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA41OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA41OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037073

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA41SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA41SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037074

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA41SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA41SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037075

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA42OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA42OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037076

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA42SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA42SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037077

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA42SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA42SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037078

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037079

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA43ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA43ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA44OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA44OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003707F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA44SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA44SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037080

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA44SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA44SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037081

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA57OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA57OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037082

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA57SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA57SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037083

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA57SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA57SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037084

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA59OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA59OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037085

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA59SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA59SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037086

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inA59SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inA59SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037087

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK10OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK10OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037088

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK10SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK10SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037089

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK10SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK10SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK11OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK11OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK11SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK11SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK11SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK11SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003708F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037090

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037091

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037092

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK30ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK30ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037093

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK31OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK31OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037094

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK31SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK31SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037095

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK31SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK31SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037096

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK32OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK32OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037097

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK32SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK32SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037098

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK32SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK32SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037099

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK33OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK33OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK33SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK33SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK33SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK33SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK34OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK34OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK34SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK34SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK34SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK34SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003709F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK35OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK35OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK35SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK35SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK35SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK35SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK36OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK36OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK36SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK36SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK36SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK36SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370A9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK37ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK37ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370AF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK38ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK38ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK39ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK39ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370B9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK40ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK40ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370BF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK41ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK41ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK42ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK42ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370C9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK43OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK43OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
