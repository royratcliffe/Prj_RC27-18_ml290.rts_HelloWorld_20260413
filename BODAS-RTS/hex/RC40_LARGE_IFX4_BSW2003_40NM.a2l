    "AUTOSAR: DTC severity class / Check DFC_rbr_inA23SCG"
    VALUE
    0x80808B33
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA24OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA24OR"
    VALUE
    0x80808B34
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA24SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA24SCB"
    VALUE
    0x80808B35
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA24SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA24SCG"
    VALUE
    0x80808B36
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA25OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA25OR"
    VALUE
    0x80808B37
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA25SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA25SCB"
    VALUE
    0x80808B38
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA25SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA25SCG"
    VALUE
    0x80808B39
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA26OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA26OR"
    VALUE
    0x80808B3A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA26SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA26SCB"
    VALUE
    0x80808B3B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA26SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA26SCG"
    VALUE
    0x80808B3C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA27OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA27OR"
    VALUE
    0x80808B3D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA27SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA27SCB"
    VALUE
    0x80808B3E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA27SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA27SCG"
    VALUE
    0x80808B3F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA28OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA28OR"
    VALUE
    0x80808B40
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA28SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA28SCB"
    VALUE
    0x80808B41
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA28SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA28SCG"
    VALUE
    0x80808B42
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA29OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA29OR"
    VALUE
    0x80808B43
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA29SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA29SCB"
    VALUE
    0x80808B44
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA29SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA29SCG"
    VALUE
    0x80808B45
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36AicSCB"
    VALUE
    0x80808B46
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36AicSCG"
    VALUE
    0x80808B47
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36OR"
    VALUE
    0x80808B48
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36SCB"
    VALUE
    0x80808B49
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36SCG"
    VALUE
    0x80808B4A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA36ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80808B4B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37AicSCB"
    VALUE
    0x80808B4C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37AicSCG"
    VALUE
    0x80808B4D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37OR"
    VALUE
    0x80808B4E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37SCB"
    VALUE
    0x80808B4F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37SCG"
    VALUE
    0x80808B50
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA37ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80808B51
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38AicSCB"
    VALUE
    0x80808B52
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38AicSCG"
    VALUE
    0x80808B53
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38OR"
    VALUE
    0x80808B54
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38SCB"
    VALUE
    0x80808B55
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38SCG"
    VALUE
    0x80808B56
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA38ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80808B57
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39AicSCB"
    VALUE
    0x80808B58
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39AicSCG"
    VALUE
    0x80808B59
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39OR"
    VALUE
    0x80808B5A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39SCB"
    VALUE
    0x80808B5B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39SCG"
    VALUE
    0x80808B5C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA39ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80808B5D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA40OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA40OR"
    VALUE
    0x80808B5E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA40SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA40SCB"
    VALUE
    0x80808B5F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA40SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA40SCG"
    VALUE
    0x80808B60
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA41OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA41OR"
    VALUE
    0x80808B61
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA41SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA41SCB"
    VALUE
    0x80808B62
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA41SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA41SCG"
    VALUE
    0x80808B63
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA42OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA42OR"
    VALUE
    0x80808B64
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA42SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA42SCB"
    VALUE
    0x80808B65
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA42SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA42SCG"
    VALUE
    0x80808B66
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43AicSCB"
    VALUE
    0x80808B67
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43AicSCG"
    VALUE
    0x80808B68
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43OR"
    VALUE
    0x80808B69
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43SCB"
    VALUE
    0x80808B6A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43SCG"
    VALUE
    0x80808B6B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA43ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80808B6C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA44OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA44OL"
    VALUE
    0x80808B6D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA44SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA44SCB"
    VALUE
    0x80808B6E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA44SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA44SCG"
    VALUE
    0x80808B6F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA57OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA57OR"
    VALUE
    0x80808B70
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA57SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA57SCB"
    VALUE
    0x80808B71
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA57SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA57SCG"
    VALUE
    0x80808B72
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA59OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA59OL"
    VALUE
    0x80808B73
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA59SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA59SCB"
    VALUE
    0x80808B74
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA59SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA59SCG"
    VALUE
    0x80808B75
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK10OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK10OR"
    VALUE
    0x80808B76
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK10SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK10SCB"
    VALUE
    0x80808B77
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK10SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK10SCG"
    VALUE
    0x80808B78
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK11OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK11OR"
    VALUE
    0x80808B79
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK11SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK11SCB"
    VALUE
    0x80808B7A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK11SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK11SCG"
    VALUE
    0x80808B7B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30AicSCB"
    VALUE
    0x80808B7C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30AicSCG"
    VALUE
    0x80808B7D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30OR"
    VALUE
    0x80808B7E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30SCB"
    VALUE
    0x80808B7F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30SCG"
    VALUE
    0x80808B80
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK30ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80808B81
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK31OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK31OR"
    VALUE
    0x80808B82
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK31SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK31SCB"
    VALUE
    0x80808B83
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK31SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK31SCG"
    VALUE
    0x80808B84
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK32OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK32OR"
    VALUE
    0x80808B85
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK32SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK32SCB"
    VALUE
    0x80808B86
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK32SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK32SCG"
    VALUE
    0x80808B87
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK33OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK33OR"
    VALUE
    0x80808B88
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK33SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK33SCB"
    VALUE
    0x80808B89
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK33SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK33SCG"
    VALUE
    0x80808B8A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK34OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK34OR"
    VALUE
    0x80808B8B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK34SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK34SCB"
    VALUE
    0x80808B8C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK34SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK34SCG"
    VALUE
    0x80808B8D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK35OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK35OR"
    VALUE
    0x80808B8E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK35SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK35SCB"
    VALUE
    0x80808B8F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK35SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK35SCG"
    VALUE
    0x80808B90
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK36OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK36OR"
    VALUE
    0x80808B91
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK36SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK36SCB"
    VALUE
    0x80808B92
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK36SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK36SCG"
    VALUE
    0x80808B93
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37AicSCB"
    VALUE
    0x80808B94
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37AicSCG"
    VALUE
    0x80808B95
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37OR"
    VALUE
    0x80808B96
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37SCB"
    VALUE
    0x80808B97
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37SCG"
    VALUE
    0x80808B98
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK37ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80808B99
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38AicSCB"
    VALUE
    0x80808B9A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38AicSCG"
    VALUE
    0x80808B9B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38OR"
    VALUE
    0x80808B9C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38SCB"
    VALUE
    0x80808B9D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38SCG"
    VALUE
    0x80808B9E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK38ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80808B9F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39AicSCB"
    VALUE
    0x80808BA0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39AicSCG"
    VALUE
    0x80808BA1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39OR"
    VALUE
    0x80808BA2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39SCB"
    VALUE
    0x80808BA3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39SCG"
    VALUE
    0x80808BA4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK39ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80808BA5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40AicSCB"
    VALUE
    0x80808BA6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40AicSCG"
    VALUE
    0x80808BA7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40OR"
    VALUE
    0x80808BA8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40SCB"
    VALUE
    0x80808BA9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40SCG"
    VALUE
    0x80808BAA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK40ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80808BAB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41AicSCB"
    VALUE
    0x80808BAC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41AicSCG"
    VALUE
    0x80808BAD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41OR"
    VALUE
    0x80808BAE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41SCB"
    VALUE
    0x80808BAF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41SCG"
    VALUE
    0x80808BB0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK41ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80808BB1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42AicSCB"
    VALUE
    0x80808BB2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42AicSCG"
    VALUE
    0x80808BB3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42OR"
    VALUE
    0x80808BB4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42SCB"
    VALUE
    0x80808BB5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42SCG"
    VALUE
    0x80808BB6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK42ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80808BB7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK43OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK43OR"
    VALUE
    0x80808BB8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK43SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK43SCB"
    VALUE
    0x80808BB9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK43SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK43SCG"
    VALUE
    0x80808BBA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44AicSCB"
    VALUE
    0x80808BBB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44AicSCG"
    VALUE
    0x80808BBC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44OR"
    VALUE
    0x80808BBD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44SCB"
    VALUE
    0x80808BBE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44SCG"
    VALUE
    0x80808BBF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK44ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80808BC0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45AicSCB"
    VALUE
    0x80808BC1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45AicSCG"
    VALUE
    0x80808BC2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45OR"
    VALUE
    0x80808BC3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45SCB"
    VALUE
    0x80808BC4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45SCG"
    VALUE
    0x80808BC5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK45ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80808BC6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK52OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK52OR"
    VALUE
    0x80808BC7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK52SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK52SCB"
    VALUE
    0x80808BC8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK52SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK52SCG"
    VALUE
    0x80808BC9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK53OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK53OR"
    VALUE
    0x80808BCA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK53SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK53SCB"
    VALUE
    0x80808BCB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK53SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK53SCG"
    VALUE
    0x80808BCC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54AicSCB"
    VALUE
    0x80808BCD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54AicSCG"
    VALUE
    0x80808BCE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54OR"
    VALUE
    0x80808BCF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54SCB"
    VALUE
    0x80808BD0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54SCG"
    VALUE
    0x80808BD1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK54ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80808BD2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55AicSCB"
    VALUE
    0x80808BD3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55AicSCG"
    VALUE
    0x80808BD4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55OR"
    VALUE
    0x80808BD5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55SCB"
    VALUE
    0x80808BD6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55SCG"
    VALUE
    0x80808BD7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK55ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80808BD8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK56OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK56OR"
    VALUE
    0x80808BD9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK56SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK56SCB"
    VALUE
    0x80808BDA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK56SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK56SCG"
    VALUE
    0x80808BDB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK57OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK57OR"
    VALUE
    0x80808BDC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK57SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK57SCB"
    VALUE
    0x80808BDD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK57SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK57SCG"
    VALUE
    0x80808BDE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK58OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK58OR"
    VALUE
    0x80808BDF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK58SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK58SCB"
    VALUE
    0x80808BE0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK58SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK58SCG"
    VALUE
    0x80808BE1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK59OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK59OR"
    VALUE
    0x80808BE2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK59SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK59SCB"
    VALUE
    0x80808BE3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK59SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK59SCG"
    VALUE
    0x80808BE4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK60OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK60OR"
    VALUE
    0x80808BE5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK60SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK60SCB"
    VALUE
    0x80808BE6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK60SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK60SCG"
    VALUE
    0x80808BE7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61AicSCB"
    VALUE
    0x80808BE8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61AicSCG"
    VALUE
    0x80808BE9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61OR"
    VALUE
    0x80808BEA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61SCB"
    VALUE
    0x80808BEB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61SCG"
    VALUE
    0x80808BEC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK61ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80808BED
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK62OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK62OR"
    VALUE
    0x80808BEE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK62SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK62SCB"
    VALUE
    0x80808BEF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK62SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK62SCG"
    VALUE
    0x80808BF0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63AicSCB"
    VALUE
    0x80808BF1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63AicSCG"
    VALUE
    0x80808BF2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63OR"
    VALUE
    0x80808BF3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63SCB"
    VALUE
    0x80808BF4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63SCG"
    VALUE
    0x80808BF5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK63ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80808BF6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64AicSCB"
    VALUE
    0x80808BF7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64AicSCG"
    VALUE
    0x80808BF8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64OR"
    VALUE
    0x80808BF9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64SCB"
    VALUE
    0x80808BFA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64SCG"
    VALUE
    0x80808BFB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK64ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80808BFC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65AicSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65AicSCB"
    VALUE
    0x80808BFD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65AicSCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65AicSCG"
    VALUE
    0x80808BFE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65OR"
    VALUE
    0x80808BFF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65SCB"
    VALUE
    0x80808C00
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65SCG"
    VALUE
    0x80808C01
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK65ShuntSCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80808C02
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK74OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK74OR"
    VALUE
    0x80808C03
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK74SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK74SCB"
    VALUE
    0x80808C04
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK74SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK74SCG"
    VALUE
    0x80808C05
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK75OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK75OR"
    VALUE
    0x80808C06
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK75SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK75SCB"
    VALUE
    0x80808C07
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK75SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK75SCG"
    VALUE
    0x80808C08
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK76OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK76OR"
    VALUE
    0x80808C09
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK76SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK76SCB"
    VALUE
    0x80808C0A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK76SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK76SCG"
    VALUE
    0x80808C0B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK77OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK77OR"
    VALUE
    0x80808C0C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK77SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK77SCB"
    VALUE
    0x80808C0D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK77SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK77SCG"
    VALUE
    0x80808C0E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK78OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK78OR"
    VALUE
    0x80808C0F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK78SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK78SCB"
    VALUE
    0x80808C10
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inK78SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inK78SCG"
    VALUE
    0x80808C11
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_DvUBAT_FWs_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80808C12
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OVErr_VPR6_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80808C13
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OVWarn_VPR6_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80808C14
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80808C15
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80808C16
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_UBAT_MON_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80808C17
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80808C18
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80808C19
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_UBRM24_MON_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80808C1A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VDD5_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80808C1B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VDD5_IN_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80808C1C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VPR6_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80808C1D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VSS3_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80808C1E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VSS4_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80808C1F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_Temp1_HTErr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80808C20
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_Temp1_HTWarn_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80808C21
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_Temp2_HTErr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80808C22
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_Temp2_HTWarn_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80808C23
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80808C24
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80808C25
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VDD5_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80808C26
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VDD5_IN_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80808C27
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VPR6_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80808C28
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VSS3_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80808C29
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VSS4_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80808C2A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA01OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA01OL"
    VALUE
    0x80808C2B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA01OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA01OT"
    VALUE
    0x80808C2C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA01SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA01SCB"
    VALUE
    0x80808C2D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA01SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA01SCG"
    VALUE
    0x80808C2E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02OL"
    VALUE
    0x80808C2F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02OR"
    VALUE
    0x80808C30
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02OT"
    VALUE
    0x80808C31
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02SCB"
    VALUE
    0x80808C32
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02SCG"
    VALUE
    0x80808C33
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03OL"
    VALUE
    0x80808C34
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03OT"
    VALUE
    0x80808C35
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03SCB"
    VALUE
    0x80808C36
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03SCG"
    VALUE
    0x80808C37
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04OL"
    VALUE
    0x80808C38
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04OT"
    VALUE
    0x80808C39
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04SCB"
    VALUE
    0x80808C3A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04SCG"
    VALUE
    0x80808C3B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05OL"
    VALUE
    0x80808C3C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05OR"
    VALUE
    0x80808C3D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05OT"
    VALUE
    0x80808C3E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05SCB"
    VALUE
    0x80808C3F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05SCG"
    VALUE
    0x80808C40
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA06OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA06OL"
    VALUE
    0x80808C41
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA06OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA06OR"
    VALUE
    0x80808C42
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA06OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA06OT"
    VALUE
    0x80808C43
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA06SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA06SCB"
    VALUE
    0x80808C44
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA06SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA06SCG"
    VALUE
    0x80808C45
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07OL"
    VALUE
    0x80808C46
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07OT"
    VALUE
    0x80808C47
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07SCB"
    VALUE
    0x80808C48
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07SCG"
    VALUE
    0x80808C49
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08OL"
    VALUE
    0x80808C4A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08OT"
    VALUE
    0x80808C4B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08SCB"
    VALUE
    0x80808C4C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08SCG"
    VALUE
    0x80808C4D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09OL"
    VALUE
    0x80808C4E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09OR"
    VALUE
    0x80808C4F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09OT"
    VALUE
    0x80808C50
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09SCB"
    VALUE
    0x80808C51
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09SCG"
    VALUE
    0x80808C52
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10OL"
    VALUE
    0x80808C53
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10OT"
    VALUE
    0x80808C54
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10SCB"
    VALUE
    0x80808C55
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10SCG"
    VALUE
    0x80808C56
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA11OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA11OL"
    VALUE
    0x80808C57
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA11OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA11OT"
    VALUE
    0x80808C58
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA11SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA11SCB"
    VALUE
    0x80808C59
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA11SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA11SCG"
    VALUE
    0x80808C5A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA12OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA12OR"
    VALUE
    0x80808C5B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA12SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA12SCB"
    VALUE
    0x80808C5C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA12SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA12SCG"
    VALUE
    0x80808C5D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA16OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA16OL"
    VALUE
    0x80808C5E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA16OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA16OT"
    VALUE
    0x80808C5F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA16SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA16SCB"
    VALUE
    0x80808C60
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA16SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA16SCG"
    VALUE
    0x80808C61
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17OL"
    VALUE
    0x80808C62
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17OR"
    VALUE
    0x80808C63
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17OT"
    VALUE
    0x80808C64
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17SCB"
    VALUE
    0x80808C65
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17SCG"
    VALUE
    0x80808C66
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18OL"
    VALUE
    0x80808C67
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18OT"
    VALUE
    0x80808C68
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18SCB"
    VALUE
    0x80808C69
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18SCG"
    VALUE
    0x80808C6A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19OL"
    VALUE
    0x80808C6B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19OR"
    VALUE
    0x80808C6C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19OT"
    VALUE
    0x80808C6D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19SCB"
    VALUE
    0x80808C6E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19SCG"
    VALUE
    0x80808C6F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20OL"
    VALUE
    0x80808C70
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20OR"
    VALUE
    0x80808C71
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20OT"
    VALUE
    0x80808C72
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20SCB"
    VALUE
    0x80808C73
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20SCG"
    VALUE
    0x80808C74
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31OL"
    VALUE
    0x80808C75
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31OR"
    VALUE
    0x80808C76
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31OT"
    VALUE
    0x80808C77
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31SCB"
    VALUE
    0x80808C78
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31SCG"
    VALUE
    0x80808C79
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32OL"
    VALUE
    0x80808C7A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32OR"
    VALUE
    0x80808C7B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32OT"
    VALUE
    0x80808C7C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32SCB"
    VALUE
    0x80808C7D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32SCG"
    VALUE
    0x80808C7E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33OL"
    VALUE
    0x80808C7F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33OR"
    VALUE
    0x80808C80
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33OT"
    VALUE
    0x80808C81
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33SCB"
    VALUE
    0x80808C82
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33SCG"
    VALUE
    0x80808C83
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34OL"
    VALUE
    0x80808C84
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34OR"
    VALUE
    0x80808C85
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34OT"
    VALUE
    0x80808C86
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34SCB"
    VALUE
    0x80808C87
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34SCG"
    VALUE
    0x80808C88
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35OL"
    VALUE
    0x80808C89
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35OR"
    VALUE
    0x80808C8A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35OT"
    VALUE
    0x80808C8B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35SCB"
    VALUE
    0x80808C8C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35SCG"
    VALUE
    0x80808C8D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46OL"
    VALUE
    0x80808C8E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46OR"
    VALUE
    0x80808C8F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46OT"
    VALUE
    0x80808C90
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46SCB"
    VALUE
    0x80808C91
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46SCG"
    VALUE
    0x80808C92
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47OL"
    VALUE
    0x80808C93
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47OR"
    VALUE
    0x80808C94
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47OT"
    VALUE
    0x80808C95
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47SCB"
    VALUE
    0x80808C96
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47SCG"
    VALUE
    0x80808C97
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48OL"
    VALUE
    0x80808C98
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48OR"
    VALUE
    0x80808C99
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48OT"
    VALUE
    0x80808C9A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48SCB"
    VALUE
    0x80808C9B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48SCG"
    VALUE
    0x80808C9C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA49OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA49OL"
    VALUE
    0x80808C9D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA49OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA49OT"
    VALUE
    0x80808C9E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA49SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA49SCB"
    VALUE
    0x80808C9F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA49SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA49SCG"
    VALUE
    0x80808CA0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA50OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA50OL"
    VALUE
    0x80808CA1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA50OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA50OT"
    VALUE
    0x80808CA2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA50SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA50SCB"
    VALUE
    0x80808CA3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA50SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA50SCG"
    VALUE
    0x80808CA4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51OL"
    VALUE
    0x80808CA5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51OR"
    VALUE
    0x80808CA6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51OT"
    VALUE
    0x80808CA7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51SCB"
    VALUE
    0x80808CA8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51SCG"
    VALUE
    0x80808CA9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52OL"
    VALUE
    0x80808CAA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52OR"
    VALUE
    0x80808CAB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52OT"
    VALUE
    0x80808CAC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52SCB"
    VALUE
    0x80808CAD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52SCG"
    VALUE
    0x80808CAE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53OL"
    VALUE
    0x80808CAF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53OR"
    VALUE
    0x80808CB0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53OT"
    VALUE
    0x80808CB1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53SCB"
    VALUE
    0x80808CB2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53SCG"
    VALUE
    0x80808CB3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54OL"
    VALUE
    0x80808CB4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54OR"
    VALUE
    0x80808CB5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54OT"
    VALUE
    0x80808CB6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54SCB"
    VALUE
    0x80808CB7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54SCG"
    VALUE
    0x80808CB8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA55OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA55OL"
    VALUE
    0x80808CB9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA55OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA55OT"
    VALUE
    0x80808CBA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA55SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA55SCB"
    VALUE
    0x80808CBB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA55SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA55SCG"
    VALUE
    0x80808CBC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA56OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA56OL"
    VALUE
    0x80808CBD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA56OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA56OT"
    VALUE
    0x80808CBE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA56SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA56SCB"
    VALUE
    0x80808CBF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA56SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA56SCG"
    VALUE
    0x80808CC0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA58OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA58OL"
    VALUE
    0x80808CC1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA58OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA58OT"
    VALUE
    0x80808CC2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA58SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA58SCB"
    VALUE
    0x80808CC3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA58SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA58SCG"
    VALUE
    0x80808CC4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07OL"
    VALUE
    0x80808CC5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07OR"
    VALUE
    0x80808CC6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07OT"
    VALUE
    0x80808CC7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07SCB"
    VALUE
    0x80808CC8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07SCG"
    VALUE
    0x80808CC9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08OL"
    VALUE
    0x80808CCA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08OR"
    VALUE
    0x80808CCB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08OT"
    VALUE
    0x80808CCC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08SCB"
    VALUE
    0x80808CCD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08SCG"
    VALUE
    0x80808CCE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09OL"
    VALUE
    0x80808CCF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09OR"
    VALUE
    0x80808CD0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09OT"
    VALUE
    0x80808CD1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09SCB"
    VALUE
    0x80808CD2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09SCG"
    VALUE
    0x80808CD3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12OL"
    VALUE
    0x80808CD4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12OT"
    VALUE
    0x80808CD5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12SCB"
    VALUE
    0x80808CD6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12SCG"
    VALUE
    0x80808CD7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13OL"
    VALUE
    0x80808CD8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13OT"
    VALUE
    0x80808CD9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13SCB"
    VALUE
    0x80808CDA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13SCG"
    VALUE
    0x80808CDB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14OL"
    VALUE
    0x80808CDC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14OR"
    VALUE
    0x80808CDD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14OT"
    VALUE
    0x80808CDE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14SCB"
    VALUE
    0x80808CDF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14SCG"
    VALUE
    0x80808CE0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15OL"
    VALUE
    0x80808CE1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15OR"
    VALUE
    0x80808CE2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15OT"
    VALUE
    0x80808CE3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15SCB"
    VALUE
    0x80808CE4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15SCG"
    VALUE
    0x80808CE5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16OL"
    VALUE
    0x80808CE6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16OR"
    VALUE
    0x80808CE7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16OT"
    VALUE
    0x80808CE8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16SCB"
    VALUE
    0x80808CE9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16SCG"
    VALUE
    0x80808CEA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17OL"
    VALUE
    0x80808CEB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17OR"
    VALUE
    0x80808CEC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17OT"
    VALUE
    0x80808CED
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17SCB"
    VALUE
    0x80808CEE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17SCG"
    VALUE
    0x80808CEF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK25OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK25OR"
    VALUE
    0x80808CF0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK25SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK25SCB"
    VALUE
    0x80808CF1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK25SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK25SCG"
    VALUE
    0x80808CF2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29OL"
    VALUE
    0x80808CF3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29OR"
    VALUE
    0x80808CF4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29OT"
    VALUE
    0x80808CF5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29SCB"
    VALUE
    0x80808CF6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29SCG"
    VALUE
    0x80808CF7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51OL"
    VALUE
    0x80808CF8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51OT"
    VALUE
    0x80808CF9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51SCB"
    VALUE
    0x80808CFA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51SCG"
    VALUE
    0x80808CFB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK62OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK62OR"
    VALUE
    0x80808CFC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK62SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK62SCB"
    VALUE
    0x80808CFD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK62SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK62SCG"
    VALUE
    0x80808CFE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73OL"
    VALUE
    0x80808CFF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73OR"
    VALUE
    0x80808D00
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73OT"
    VALUE
    0x80808D01
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73SCB"
    VALUE
    0x80808D02
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73SCG"
    VALUE
    0x80808D03
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK80OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK80OL"
    VALUE
    0x80808D04
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK80OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK80OT"
    VALUE
    0x80808D05
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK80SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK80SCB"
    VALUE
    0x80808D06
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK80SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK80SCG"
    VALUE
    0x80808D07
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK81OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK81OL"
    VALUE
    0x80808D08
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK81OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK81OT"
    VALUE
    0x80808D09
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK81SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK81SCB"
    VALUE
    0x80808D0A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK81SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK81SCG"
    VALUE
    0x80808D0B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK82OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK82OL"
    VALUE
    0x80808D0C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK82OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK82OT"
    VALUE
    0x80808D0D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK82SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK82SCB"
    VALUE
    0x80808D0E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK82SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK82SCG"
    VALUE
    0x80808D0F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK83OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK83OL"
    VALUE
    0x80808D10
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK83OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK83OT"
    VALUE
    0x80808D11
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK83SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK83SCB"
    VALUE
    0x80808D12
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK83SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK83SCG"
    VALUE
    0x80808D13
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK84OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK84OL"
    VALUE
    0x80808D14
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK84OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK84OT"
    VALUE
    0x80808D15
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK84SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK84SCB"
    VALUE
    0x80808D16
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK84SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK84SCG"
    VALUE
    0x80808D17
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK85OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK85OL"
    VALUE
    0x80808D18
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK85OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK85OT"
    VALUE
    0x80808D19
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK85SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK85SCB"
    VALUE
    0x80808D1A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK85SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK85SCG"
    VALUE
    0x80808D1B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK86OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK86OL"
    VALUE
    0x80808D1C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK86OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK86OT"
    VALUE
    0x80808D1D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK86SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK86SCB"
    VALUE
    0x80808D1E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK86SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK86SCG"
    VALUE
    0x80808D1F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK87OL_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK87OL"
    VALUE
    0x80808D20
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK87OT_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK87OT"
    VALUE
    0x80808D21
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK87SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK87SCB"
    VALUE
    0x80808D22
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK87SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK87SCG"
    VALUE
    0x80808D23
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_DSMDummy_C
    "AUTOSAR: DTC severity class / Check DFC_DSMDummy"
    VALUE
    0x80808D24
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8000_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8000"
    VALUE
    0x80808D25
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8001_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8001"
    VALUE
    0x80808D26
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8002_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8002"
    VALUE
    0x80808D27
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8003_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8003"
    VALUE
    0x80808D28
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8004_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8004"
    VALUE
    0x80808D29
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8005_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8005"
    VALUE
    0x80808D2A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8006_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8006"
    VALUE
    0x80808D2B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8007_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8007"
    VALUE
    0x80808D2C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8008_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8008"
    VALUE
    0x80808D2D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8009_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8009"
    VALUE
    0x80808D2E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x800a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x800a"
    VALUE
    0x80808D2F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x800b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x800b"
    VALUE
    0x80808D30
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x800c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x800c"
    VALUE
    0x80808D31
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x800d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x800d"
    VALUE
    0x80808D32
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x800e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x800e"
    VALUE
    0x80808D33
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x800f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x800f"
    VALUE
    0x80808D34
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8010_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8010"
    VALUE
    0x80808D35
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8011_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8011"
    VALUE
    0x80808D36
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8012_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8012"
    VALUE
    0x80808D37
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8013_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8013"
    VALUE
    0x80808D38
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8014_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8014"
    VALUE
    0x80808D39
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8015_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8015"
    VALUE
    0x80808D3A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8016_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8016"
    VALUE
    0x80808D3B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8017_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8017"
    VALUE
    0x80808D3C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8018_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8018"
    VALUE
    0x80808D3D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8019_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8019"
    VALUE
    0x80808D3E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x801a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x801a"
    VALUE
    0x80808D3F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x801b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x801b"
    VALUE
    0x80808D40
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x801c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x801c"
    VALUE
    0x80808D41
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x801d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x801d"
    VALUE
    0x80808D42
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x801e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x801e"
    VALUE
    0x80808D43
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x801f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x801f"
    VALUE
    0x80808D44
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8020_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8020"
    VALUE
    0x80808D45
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8021_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8021"
    VALUE
    0x80808D46
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8022_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8022"
    VALUE
    0x80808D47
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8023_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8023"
    VALUE
    0x80808D48
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8024_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8024"
    VALUE
    0x80808D49
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8025_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8025"
    VALUE
    0x80808D4A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8026_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8026"
    VALUE
    0x80808D4B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8027_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8027"
    VALUE
    0x80808D4C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8028_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8028"
    VALUE
    0x80808D4D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8029_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8029"
    VALUE
    0x80808D4E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x802a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x802a"
    VALUE
    0x80808D4F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x802b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x802b"
    VALUE
    0x80808D50
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x802c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x802c"
    VALUE
    0x80808D51
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x802d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x802d"
    VALUE
    0x80808D52
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x802e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x802e"
    VALUE
    0x80808D53
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x802f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x802f"
    VALUE
    0x80808D54
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8030_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8030"
    VALUE
    0x80808D55
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8031_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8031"
    VALUE
    0x80808D56
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8032_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8032"
    VALUE
    0x80808D57
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8033_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8033"
    VALUE
    0x80808D58
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8034_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8034"
    VALUE
    0x80808D59
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8035_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8035"
    VALUE
    0x80808D5A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8036_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8036"
    VALUE
    0x80808D5B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8037_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8037"
    VALUE
    0x80808D5C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8038_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8038"
    VALUE
    0x80808D5D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8039_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8039"
    VALUE
    0x80808D5E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x803a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x803a"
    VALUE
    0x80808D5F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x803b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x803b"
    VALUE
    0x80808D60
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x803c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x803c"
    VALUE
    0x80808D61
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x803d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x803d"
    VALUE
    0x80808D62
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x803e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x803e"
    VALUE
    0x80808D63
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x803f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x803f"
    VALUE
    0x80808D64
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8040_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8040"
    VALUE
    0x80808D65
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8041_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8041"
    VALUE
    0x80808D66
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8042_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8042"
    VALUE
    0x80808D67
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8043_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8043"
    VALUE
    0x80808D68
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8044_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8044"
    VALUE
    0x80808D69
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8045_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8045"
    VALUE
    0x80808D6A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8046_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8046"
    VALUE
    0x80808D6B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8047_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8047"
    VALUE
    0x80808D6C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8048_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8048"
    VALUE
    0x80808D6D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8049_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8049"
    VALUE
    0x80808D6E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x804a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x804a"
    VALUE
    0x80808D6F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x804b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x804b"
    VALUE
    0x80808D70
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x804c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x804c"
    VALUE
    0x80808D71
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x804d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x804d"
    VALUE
    0x80808D72
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x804e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x804e"
    VALUE
    0x80808D73
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x804f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x804f"
    VALUE
    0x80808D74
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8050_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8050"
    VALUE
    0x80808D75
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8051_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8051"
    VALUE
    0x80808D76
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8052_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8052"
    VALUE
    0x80808D77
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8053_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8053"
    VALUE
    0x80808D78
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8054_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8054"
    VALUE
    0x80808D79
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8055_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8055"
    VALUE
    0x80808D7A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8056_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8056"
    VALUE
    0x80808D7B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8057_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8057"
    VALUE
    0x80808D7C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8058_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8058"
    VALUE
    0x80808D7D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8059_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8059"
    VALUE
    0x80808D7E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x805a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x805a"
    VALUE
    0x80808D7F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x805b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x805b"
    VALUE
    0x80808D80
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x805c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x805c"
    VALUE
    0x80808D81
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x805d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x805d"
    VALUE
    0x80808D82
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x805e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x805e"
    VALUE
    0x80808D83
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x805f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x805f"
    VALUE
    0x80808D84
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8060_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8060"
    VALUE
    0x80808D85
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8061_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8061"
    VALUE
    0x80808D86
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8062_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8062"
    VALUE
    0x80808D87
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8C01_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8C01"
    VALUE
    0x80808D88
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8C02_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8C02"
    VALUE
    0x80808D89
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8C03_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8C03"
    VALUE
    0x80808D8A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetDataNoBuf_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80808D8B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetDataParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetDataParam"
    VALUE
    0x80808D8C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetDataboxNoInit_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80808D8D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80808D8E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetRxBufStatusParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80808D8F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetStatusParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetStatusParam"
    VALUE
    0x80808D90
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canGetTxBufStatusParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80808D91
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canInitParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canInitParam"
    VALUE
    0x80808D92
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canInitRxDataboxOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80808D93
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canInitRxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80808D94
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canInitTxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80808D95
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canIpduGroupControl_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80808D96
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canIsDataboxFreeNoInit_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80808D97
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canIsDataboxFreeParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80808D98
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canIsTxEmptyParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80808D99
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegBusOffCallbInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80808D9A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegBusOffCallbParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80808D9B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxBufInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80808D9C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxBufOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80808D9D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxBufParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80808D9E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxCallbInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80808D9F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxCallbParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80808DA0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxDataboxInvNumb_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80808DA1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxDataboxInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80808DA2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxDataboxOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80808DA3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegRxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80808DA4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxBufInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80808DA5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxBufOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80808DA6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxBufParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80808DA7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxDataboxInvNumb_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80808DA8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxDataboxInvState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80808DA9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxDataboxOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x80808DAA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canRegTxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80808DAB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canResetTxBufParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80808DAC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canSendDataBufOvfl_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80808DAD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canSendDataParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canSendDataParam"
    VALUE
    0x80808DAE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canSendDataboxNoInit_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80808DAF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canSendDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80808DB0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canSetTxCycleParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80808DB1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canStartParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canStartParam"
    VALUE
    0x80808DB2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_canStopParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_canStopParam"
    VALUE
    0x80808DB3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_can_ClearIpduGroup_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80808DB4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_can_ReceiveSignal_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80808DB5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_can_SendSignal_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_can_SendSignal"
    VALUE
    0x80808DB6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_can_SetIpduGroup_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80808DB7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmDTCJ1939_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80808DB8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmDelDTCJ1939_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80808DB9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmDelErrors_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmDelErrors"
    VALUE
    0x80808DBA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmGetDFES_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmGetDFES"
    VALUE
    0x80808DBB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmGetDTCJ1939_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80808DBC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmGetErrors_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmGetErrors"
    VALUE
    0x80808DBD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmGetNumErrors_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80808DBE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmInitQueueOverflow_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80808DBF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmNumDTCJ1939_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80808DC0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmTesterror_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmTesterror"
    VALUE
    0x80808DC1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmUpdateDebError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80808DC2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmUpdateError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmUpdateError"
    VALUE
    0x80808DC3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmgetDFCStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80808DC4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_dsmtestErrorDFC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80808DC5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAi_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAi"
    VALUE
    0x80808DC6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAic_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAic"
    VALUE
    0x80808DC7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAicCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAicCfg"
    VALUE
    0x80808DC8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAicGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAicGetStatus"
    VALUE
    0x80808DC9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAid_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAid"
    VALUE
    0x80808DCA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAidCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAidCfg"
    VALUE
    0x80808DCB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAiv_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAiv"
    VALUE
    0x80808DCC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAivCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAivCfg"
    VALUE
    0x80808DCD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inAivGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inAivGetStatus"
    VALUE
    0x80808DCE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inDi_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inDi"
    VALUE
    0x80808DCF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inFi_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inFi"
    VALUE
    0x80808DD0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inFiCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inFiCfg"
    VALUE
    0x80808DD1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inFiGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inFiGetStatus"
    VALUE
    0x80808DD2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inFi_Buffered_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inFi_Buffered"
    VALUE
    0x80808DD3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inPhase_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inPhase"
    VALUE
    0x80808DD4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inPhaseGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80808DD5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inPhaseResetCounter_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80808DD6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inRi_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inRi"
    VALUE
    0x80808DD7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inRiCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inRiCfg"
    VALUE
    0x80808DD8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inRiCfgTemp_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inRiCfgTemp"
    VALUE
    0x80808DD9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inRiGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inRiGetStatus"
    VALUE
    0x80808DDA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inRiGetTemp_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inRiGetTemp"
    VALUE
    0x80808DDB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentCopyFDFifo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80808DDC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentDisable_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentDisable"
    VALUE
    0x80808DDD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentEnable_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentEnable"
    VALUE
    0x80808DDE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentGetErrorStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80808DDF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentGetFD_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentGetFD"
    VALUE
    0x80808DE0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentGetSD_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentGetSD"
    VALUE
    0x80808DE1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentGetSDDatabox_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80808DE2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentGetStatus"
    VALUE
    0x80808DE3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentInitSDDatabox_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80808DE4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentRegisterCopyFDFifo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80808DE5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentRegisterFDFifo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x80808DE6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inSentRegisterSDDataboxes_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x80808DE7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusCanRxBufferOverflow_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x80808DE8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusGetCaAddrParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x80808DE9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusGetDiagnosticParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x80808DEA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x80808DEB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusGetStatusParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80808DEC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitCommCaMissing_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80808DED
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitCommParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80808DEE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitCommState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitCommState"
    VALUE
    0x80808DEF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitDiagnosticParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80808DF0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitFailureListParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80808DF1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitRxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80808DF2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusInitTxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80808DF3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegRxDataboxOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80808DF4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegRxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80808DF5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegRxDataboxState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80808DF6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegTxDataboxOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80808DF7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegTxDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80808DF8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegTxDataboxState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80808DF9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x80808DFA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegisterInstancesOverlap_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x80808DFB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegisterInstancesParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80808DFC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusRegisterInstancesState_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80808DFD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSendDataboxParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80808DFE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSendRequestPGNParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80808DFF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaAddrCaUsed_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80808E00
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaAddrComm_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80808E01
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaAddrInvCan_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80808E02
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaAddrParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80808E03
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaInfoParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80808E04
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSetCaNameParam_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80808E05
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_isobusSftyCanTxErr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80808E06
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_ReceiveSignal_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80808E07
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_SendSignal_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_SendSignal"
    VALUE
    0x80808E08
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_getStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_getStatus"
    VALUE
    0x80808E09
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_gotoSleep_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80808E0A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_scheduleRequest_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80808E0B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_lin_wakeUp_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_lin_wakeUp"
    VALUE
    0x80808E0C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memFlsCfgShr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80808E0D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memGetStatus"
    VALUE
    0x80808E0E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memMarkBlock_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memMarkBlock"
    VALUE
    0x80808E0F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadApi1Error_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadApi1Error"
    VALUE
    0x80808E10
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadApi2Error_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadApi2Error"
    VALUE
    0x80808E11
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadBlock_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadBlock"
    VALUE
    0x80808E12
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadCalibInputError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80808E13
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadCalibOuputError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80808E14
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memReadSystemError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memReadSystemError"
    VALUE
    0x80808E15
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_memWriteBlock_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_memWriteBlock"
    VALUE
    0x80808E16
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_moOV_FirstConstADC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80808E17
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_moOV_SecondConstADC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80808E18
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_moUV_FirstConstADC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80808E19
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_moUV_SecondConstADC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80808E1A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_INH_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_INH"
    VALUE
    0x80808E1B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_INHLatch_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_INHLatch"
    VALUE
    0x80808E1C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_adcPDD_fail_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80808E1D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_memoryProtection_err_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80808E1E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02OC"
    VALUE
    0x80808E1F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA02Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA02Unintended"
    VALUE
    0x80808E20
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03OC"
    VALUE
    0x80808E21
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA03Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA03Unintended"
    VALUE
    0x80808E22
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04OC"
    VALUE
    0x80808E23
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA04Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA04Unintended"
    VALUE
    0x80808E24
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05OC"
    VALUE
    0x80808E25
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA05Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA05Unintended"
    VALUE
    0x80808E26
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07OC"
    VALUE
    0x80808E27
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA07Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA07Unintended"
    VALUE
    0x80808E28
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08OC"
    VALUE
    0x80808E29
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA08Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA08Unintended"
    VALUE
    0x80808E2A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09OC"
    VALUE
    0x80808E2B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA09Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA09Unintended"
    VALUE
    0x80808E2C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10OC"
    VALUE
    0x80808E2D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA10Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA10Unintended"
    VALUE
    0x80808E2E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17OC"
    VALUE
    0x80808E2F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA17Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA17Unintended"
    VALUE
    0x80808E30
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18OC"
    VALUE
    0x80808E31
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA18Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA18Unintended"
    VALUE
    0x80808E32
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19OC"
    VALUE
    0x80808E33
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA19Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA19Unintended"
    VALUE
    0x80808E34
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20OC"
    VALUE
    0x80808E35
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA20Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA20Unintended"
    VALUE
    0x80808E36
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31OC"
    VALUE
    0x80808E37
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA31Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA31Unintended"
    VALUE
    0x80808E38
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32OC"
    VALUE
    0x80808E39
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA32Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA32Unintended"
    VALUE
    0x80808E3A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33OC"
    VALUE
    0x80808E3B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA33Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA33Unintended"
    VALUE
    0x80808E3C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34OC"
    VALUE
    0x80808E3D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA34Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA34Unintended"
    VALUE
    0x80808E3E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35OC"
    VALUE
    0x80808E3F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA35Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA35Unintended"
    VALUE
    0x80808E40
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46OC"
    VALUE
    0x80808E41
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA46Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA46Unintended"
    VALUE
    0x80808E42
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47OC"
    VALUE
    0x80808E43
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA47Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA47Unintended"
    VALUE
    0x80808E44
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48OC"
    VALUE
    0x80808E45
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA48Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA48Unintended"
    VALUE
    0x80808E46
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51OC"
    VALUE
    0x80808E47
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA51Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA51Unintended"
    VALUE
    0x80808E48
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52OC"
    VALUE
    0x80808E49
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA52Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA52Unintended"
    VALUE
    0x80808E4A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53OC"
    VALUE
    0x80808E4B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA53Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA53Unintended"
    VALUE
    0x80808E4C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54OC"
    VALUE
    0x80808E4D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outA54Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outA54Unintended"
    VALUE
    0x80808E4E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAov_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAov"
    VALUE
    0x80808E4F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAovCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAovCfg"
    VALUE
    0x80808E50
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAovCfgPI_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAovCfgPI"
    VALUE
    0x80808E51
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAovGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAovGetStatus"
    VALUE
    0x80808E52
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAovGetVoltage_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80808E53
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outAovResetError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outAovResetError"
    VALUE
    0x80808E54
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDo"
    VALUE
    0x80808E55
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDoCfgPwrLs_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80808E56
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDoDisable_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDoDisable"
    VALUE
    0x80808E57
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDoGetCurrent_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80808E58
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDoGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDoGetStatus"
    VALUE
    0x80808E59
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outDoResetError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outDoResetError"
    VALUE
    0x80808E5A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07OC"
    VALUE
    0x80808E5B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK07Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK07Unintended"
    VALUE
    0x80808E5C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08OC"
    VALUE
    0x80808E5D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK08Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK08Unintended"
    VALUE
    0x80808E5E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09OC"
    VALUE
    0x80808E5F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK09Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK09Unintended"
    VALUE
    0x80808E60
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12OC"
    VALUE
    0x80808E61
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK12Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK12Unintended"
    VALUE
    0x80808E62
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13OC"
    VALUE
    0x80808E63
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK13Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK13Unintended"
    VALUE
    0x80808E64
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14OC"
    VALUE
    0x80808E65
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK14Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK14Unintended"
    VALUE
    0x80808E66
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15OC"
    VALUE
    0x80808E67
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK15Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK15Unintended"
    VALUE
    0x80808E68
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16OC"
    VALUE
    0x80808E69
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK16Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK16Unintended"
    VALUE
    0x80808E6A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17OC"
    VALUE
    0x80808E6B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK17Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK17Unintended"
    VALUE
    0x80808E6C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29OC"
    VALUE
    0x80808E6D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK29Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK29Unintended"
    VALUE
    0x80808E6E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51OC"
    VALUE
    0x80808E6F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK51Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK51Unintended"
    VALUE
    0x80808E70
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73OC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73OC"
    VALUE
    0x80808E71
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outK73Unintended_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outK73Unintended"
    VALUE
    0x80808E72
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPo"
    VALUE
    0x80808E73
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoCfg"
    VALUE
    0x80808E74
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoCfgPeriod_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80808E75
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoCfgPwrLs_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80808E76
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoDisable_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoDisable"
    VALUE
    0x80808E77
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoGetCurrent_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80808E78
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoGetStatus"
    VALUE
    0x80808E79
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoResetError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoResetError"
    VALUE
    0x80808E7A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPoc_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPoc"
    VALUE
    0x80808E7B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPocCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPocCfg"
    VALUE
    0x80808E7C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPocCfgDither_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPocCfgDither"
    VALUE
    0x80808E7D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPocCfgPI_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPocCfgPI"
    VALUE
    0x80808E7E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPod_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPod"
    VALUE
    0x80808E7F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPodCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPodCfg"
    VALUE
    0x80808E80
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_outPodCfgPeriod_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80808E81
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_rsmFfiApiCallErr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80808E82
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safout_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safout"
    VALUE
    0x80808E83
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutCfg_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutCfg"
    VALUE
    0x80808E84
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl1_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl1"
    VALUE
    0x80808E85
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl10_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl10"
    VALUE
    0x80808E86
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl10Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80808E87
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl10OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80808E88
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl11_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl11"
    VALUE
    0x80808E89
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl11Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80808E8A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl11OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80808E8B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl12_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl12"
    VALUE
    0x80808E8C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl12Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80808E8D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl12OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80808E8E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl13_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl13"
    VALUE
    0x80808E8F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl13Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80808E90
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl13OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80808E91
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl14_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl14"
    VALUE
    0x80808E92
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl14Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80808E93
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl14OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80808E94
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl15_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl15"
    VALUE
    0x80808E95
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl15Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80808E96
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl15OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80808E97
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl16_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl16"
    VALUE
    0x80808E98
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl16Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80808E99
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl16OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80808E9A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl17_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl17"
    VALUE
    0x80808E9B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl17Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80808E9C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl17OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80808E9D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl18_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl18"
    VALUE
    0x80808E9E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl18Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80808E9F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl18OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80808EA0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl1Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80808EA1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl1OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80808EA2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl2_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl2"
    VALUE
    0x80808EA3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl2Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80808EA4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl2OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80808EA5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl3_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl3"
    VALUE
    0x80808EA6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl3Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80808EA7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl3OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80808EA8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl4_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl4"
    VALUE
    0x80808EA9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl4Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x80808EAA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl4OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80808EAB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl5_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl5"
    VALUE
    0x80808EAC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl5Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80808EAD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl5OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80808EAE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl6_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl6"
    VALUE
    0x80808EAF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl6Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80808EB0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl6OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80808EB1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl7_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl7"
    VALUE
    0x80808EB2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl7Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80808EB3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl7OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80808EB4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl8_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl8"
    VALUE
    0x80808EB5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl8Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80808EB6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl8OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80808EB7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl9_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl9"
    VALUE
    0x80808EB8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl9Dev_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80808EB9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutChnl9OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutChnl9OR"
    VALUE
    0x80808EBA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutDevError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutDevError"
    VALUE
    0x80808EBB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutGetStatus_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutGetStatus"
    VALUE
    0x80808EBC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutIgnoreError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80808EBD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutResetError_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutResetError"
    VALUE
    0x80808EBE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safoutUnlock_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safoutUnlock"
    VALUE
    0x80808EBF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_safout_cfgDiag_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80808EC0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secAccessDenied_RC_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80808EC1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secAccessDenied_WDBI_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80808EC2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secEvalRespKey_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secEvalRespKey"
    VALUE
    0x80808EC3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secFlashingFailure_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secFlashingFailure"
    VALUE
    0x80808EC4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secGetLevel_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secGetLevel"
    VALUE
    0x80808EC5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secGetRnd_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secGetRnd"
    VALUE
    0x80808EC6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secGetSeed_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secGetSeed"
    VALUE
    0x80808EC7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secInvalidPassword_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secInvalidPassword"
    VALUE
    0x80808EC8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secIsRequestAllowed_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80808EC9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secResetLevel_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secResetLevel"
    VALUE
    0x80808ECA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secSaveSecret_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secSaveSecret"
    VALUE
    0x80808ECB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_secSetLevel_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_secSetLevel"
    VALUE
    0x80808ECC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysAit_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysAit"
    VALUE
    0x80808ECD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysAiv_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysAiv"
    VALUE
    0x80808ECE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysDi_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysDi"
    VALUE
    0x80808ECF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysDo_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysDo"
    VALUE
    0x80808ED0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysGetVss_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysGetVss"
    VALUE
    0x80808ED1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysInit_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysInit"
    VALUE
    0x80808ED2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysOperHrIntegrityErr_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80808ED3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysOperHrsSaturated_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80808ED4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sysSetVss_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sysSetVss"
    VALUE
    0x80808ED5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sys_coreload_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sys_coreload"
    VALUE
    0x80808ED6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_sys_taskload_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_sys_taskload"
    VALUE
    0x80808ED7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VSS1_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80808ED8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_OV_VSS2_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80808ED9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VSS1_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80808EDA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_mo_UV_VSS2_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x80808EDB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "AUTOSAR: DTC severity class / Check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80808EDC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "AUTOSAR: DTC severity class / Check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80808EDD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "AUTOSAR: DTC severity class / Check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80808EDE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "AUTOSAR: DTC severity class / Check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80808EDF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "AUTOSAR: DTC severity class / Check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80808EE0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_CAN_E_TIMEOUT_C
    "AUTOSAR: DTC severity class / Check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80808EE1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80808EE2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80808EE3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80808EE4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80808EE5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80808EE6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "AUTOSAR: DTC severity class / Check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80808EE7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_LIN_E_TIMEOUT_C
    "AUTOSAR: DTC severity class / Check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80808EE8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_MultiStackTrace_Threshold_C
    "AUTOSAR: DTC severity class / Check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80808EE9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_ETH_E_ACCESS_0_C
    "AUTOSAR: DTC severity class / Check DFC_ETH_E_ACCESS_0"
    VALUE
    0x80808EEA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "AUTOSAR: DTC severity class / Check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x80808EEB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "AUTOSAR: DTC severity class / Check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80808EEC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_MRly_Diag_Stk_Event_C
    "AUTOSAR: DTC severity class / Check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80808EED
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "AUTOSAR: DTC severity class / Check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80808EEE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_MemDiag_MemReadErr_C
    "AUTOSAR: DTC severity class / Check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80808EEF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_MemDiag_MemWrErr_C
    "AUTOSAR: DTC severity class / Check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80808EF0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "AUTOSAR: DTC severity class / Check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80808EF1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_T15_Diag_ComInVld_Event_C
    "AUTOSAR: DTC severity class / Check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80808EF2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "AUTOSAR: DTC severity class / Check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80808EF3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "AUTOSAR: DTC severity class / Check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80808EF4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80808EF5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80808EF6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_10_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80808EF7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80808EF8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80808EF9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x80808EFA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x80808EFB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_22_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80808EFC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_23_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80808EFD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80808EFE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80808EFF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_7_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80808F00
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM0_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80808F01
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM10_16_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80808F02
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM10_17_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80808F03
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM10_21_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80808F04
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80808F05
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80808F06
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80808F07
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_3_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80808F08
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80808F09
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x80808F0A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x80808F0B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM11_9_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80808F0C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80808F0D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80808F0E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_10_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80808F0F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80808F10
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80808F11
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80808F12
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80808F13
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_22_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80808F14
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_23_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80808F15
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80808F16
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80808F17
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_7_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80808F18
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM1_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80808F19
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM21_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x80808F1A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM21_16_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x80808F1B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM21_3_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80808F1C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80808F1D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_10_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80808F1E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80808F1F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80808F20
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80808F21
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80808F22
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_22_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80808F23
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_23_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80808F24
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80808F25
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80808F26
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_7_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80808F27
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM2_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80808F28
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80808F29
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_10_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x80808F2A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x80808F2B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80808F2C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80808F2D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80808F2E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_22_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80808F2F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_23_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80808F30
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80808F31
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80808F32
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_7_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80808F33
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM3_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80808F34
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80808F35
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80808F36
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_12_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80808F37
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80808F38
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_15_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80808F39
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_17_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x80808F3A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_18_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x80808F3B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80808F3C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_20_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80808F3D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_21_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80808F3E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_25_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80808F3F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80808F40
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_5_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80808F41
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_7_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80808F42
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM6_8_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80808F43
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80808F44
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_12_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80808F45
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80808F46
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_14_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80808F47
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_15_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80808F48
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_16_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80808F49
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_17_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80808F4A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80808F4B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_20_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80808F4C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_25_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80808F4D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_26_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80808F4E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_28_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80808F4F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_29_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80808F50
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_30_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80808F51
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM7_31_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80808F52
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80808F53
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80808F54
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_10_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80808F55
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_11_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80808F56
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_12_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80808F57
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_13_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80808F58
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_16_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80808F59
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_18_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80808F5A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_2_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80808F5B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_3_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80808F5C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_30_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80808F5D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_31_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80808F5E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM8_4_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80808F5F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM9_0_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80808F60
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM9_1_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80808F61
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM9_15_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80808F62
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MOXEMM_SMU_ALM9_3_C
    "AUTOSAR: DTC severity class / Check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80808F63
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoCSOPICO_C
    "AUTOSAR: DTC severity class / Check DFC_MoCSOPICO"
    VALUE
    0x80808F64
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoFVarPostBldSel_C
    "AUTOSAR: DTC severity class / Check DFC_MoFVarPostBldSel"
    VALUE
    0x80808F65
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoSysCtrlReIni_C
    "AUTOSAR: DTC severity class / Check DFC_MoSysCtrlReIni"
    VALUE
    0x80808F66
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTMCUFW_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80808F67
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTMonBIST_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80808F68
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTRegMonTest_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80808F69
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80808F6A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTTempSens_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80808F6B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_MoXEMMHwLTUCBCfg_C
    "AUTOSAR: DTC severity class / Check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80808F6C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_OCWDAABEActv_C
    "AUTOSAR: DTC severity class / Check DFC_OCWDAABEActv"
    VALUE
    0x80808F6D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_OCWDACom_C
    "AUTOSAR: DTC severity class / Check DFC_OCWDACom"
    VALUE
    0x80808F6E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_OCWDAErrPin_C
    "AUTOSAR: DTC severity class / Check DFC_OCWDAErrPin"
    VALUE
    0x80808F6F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_SWReset_0_C
    "AUTOSAR: DTC severity class / Check DFC_SWReset_0"
    VALUE
    0x80808F70
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_SWReset_1_C
    "AUTOSAR: DTC severity class / Check DFC_SWReset_1"
    VALUE
    0x80808F71
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_SWReset_2_C
    "AUTOSAR: DTC severity class / Check DFC_SWReset_2"
    VALUE
    0x80808F72
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_Unused_C
    "fault class per DFC / "
    VALUE
    0x80801354
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80c7_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80801355
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80c8_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80c8"
    VALUE
    0x80801356
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80c9_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80c9"
    VALUE
    0x80801357
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ca_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ca"
    VALUE
    0x80801358
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80cb_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80cb"
    VALUE
    0x80801359
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80cc_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80cc"
    VALUE
    0x8080135A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80cd_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80cd"
    VALUE
    0x8080135B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ce_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ce"
    VALUE
    0x8080135C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80cf_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80cf"
    VALUE
    0x8080135D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80d0_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80d0"
    VALUE
    0x8080135E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80d1_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80d1"
    VALUE
    0x8080135F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80d2_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80801360
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80d3_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80801361
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80d4_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80801362
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80d5_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80801363
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80d6_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80801364
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80d7_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80d7"
    VALUE
    0x80801365
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80d8_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80d8"
    VALUE
    0x80801366
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80d9_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80d9"
    VALUE
    0x80801367
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80da_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80da"
    VALUE
    0x80801368
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80db_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80db"
    VALUE
    0x80801369
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80dc_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80dc"
    VALUE
    0x8080136A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80dd_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80dd"
    VALUE
    0x8080136B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80de_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80de"
    VALUE
    0x8080136C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80df_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80df"
    VALUE
    0x8080136D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80e0_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80e0"
    VALUE
    0x8080136E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80e1_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80e1"
    VALUE
    0x8080136F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80e2_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80801370
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80e3_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80801371
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80e4_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80801372
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80e5_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80801373
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80e6_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80801374
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80e7_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80e7"
    VALUE
    0x80801375
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80e8_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80e8"
    VALUE
    0x80801376
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80e9_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80e9"
    VALUE
    0x80801377
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ea_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ea"
    VALUE
    0x80801378
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80eb_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80eb"
    VALUE
    0x80801379
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ec_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ec"
    VALUE
    0x8080137A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ed_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ed"
    VALUE
    0x8080137B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ee_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ee"
    VALUE
    0x8080137C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ef_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ef"
    VALUE
    0x8080137D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80f0_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80f0"
    VALUE
    0x8080137E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80f1_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80f1"
    VALUE
    0x8080137F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80f2_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80801380
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80f3_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80801381
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80f4_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80801382
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80f5_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80801383
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80f6_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80f6"
    VALUE
    0x80801384
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80f7_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80f7"
    VALUE
    0x80801385
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80f8_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80f8"
    VALUE
    0x80801386
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80f9_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80f9"
    VALUE
    0x80801387
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80fa_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80fa"
    VALUE
    0x80801388
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80fb_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80fb"
    VALUE
    0x80801389
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80fc_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80fc"
    VALUE
    0x8080138A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80fd_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80fd"
    VALUE
    0x8080138B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80fe_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80fe"
    VALUE
    0x8080138C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ff_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ff"
    VALUE
    0x8080138D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8100_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8100"
    VALUE
    0x8080138E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8101_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8101"
    VALUE
    0x8080138F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8102_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8102"
    VALUE
    0x80801390
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8103_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8103"
    VALUE
    0x80801391
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8104_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8104"
    VALUE
    0x80801392
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8105_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8105"
    VALUE
    0x80801393
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8106_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8106"
    VALUE
    0x80801394
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8107_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8107"
    VALUE
    0x80801395
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8108_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8108"
    VALUE
    0x80801396
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8109_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8109"
    VALUE
    0x80801397
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x810a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x810a"
    VALUE
    0x80801398
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x810b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x810b"
    VALUE
    0x80801399
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x810c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x810c"
    VALUE
    0x8080139A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x810d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x810d"
    VALUE
    0x8080139B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x810e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x810e"
    VALUE
    0x8080139C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x810f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x810f"
    VALUE
    0x8080139D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8110_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8110"
    VALUE
    0x8080139E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8111_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8111"
    VALUE
    0x8080139F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8112_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8112"
    VALUE
    0x808013A0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8113_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8113"
    VALUE
    0x808013A1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8114_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8114"
    VALUE
    0x808013A2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8115_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8115"
    VALUE
    0x808013A3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8116_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8116"
    VALUE
    0x808013A4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8117_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8117"
    VALUE
    0x808013A5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8118_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8118"
    VALUE
    0x808013A6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8119_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8119"
    VALUE
    0x808013A7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x811a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x811a"
    VALUE
    0x808013A8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x811b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x811b"
    VALUE
    0x808013A9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x811c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x811c"
    VALUE
    0x808013AA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x811d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x811d"
    VALUE
    0x808013AB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x811e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x811e"
    VALUE
    0x808013AC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x811f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x811f"
    VALUE
    0x808013AD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8120_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8120"
    VALUE
    0x808013AE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8121_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8121"
    VALUE
    0x808013AF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8122_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8122"
    VALUE
    0x808013B0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8123_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8123"
    VALUE
    0x808013B1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8124_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8124"
    VALUE
    0x808013B2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8125_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8125"
    VALUE
    0x808013B3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8126_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8126"
    VALUE
    0x808013B4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8127_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8127"
    VALUE
    0x808013B5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8128_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8128"
    VALUE
    0x808013B6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8129_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8129"
    VALUE
    0x808013B7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x812a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x812a"
    VALUE
    0x808013B8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_TiInRow0x8B01_C
    "fault class per DFC / Fault class for check DFC_bds_TiInRow0x8B01"
    VALUE
    0x808013B9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_TiInRow0x8B02_C
    "fault class per DFC / Fault class for check DFC_bds_TiInRow0x8B02"
    VALUE
    0x808013BA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_TiInRow0x8B03_C
    "fault class per DFC / Fault class for check DFC_bds_TiInRow0x8B03"
    VALUE
    0x808013BB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_DevLibBattUHi_C
    "fault class per DFC / Fault class for check DFC_DevLibBattUHi"
    VALUE
    0x808013BC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_DevLibBattULo_C
    "fault class per DFC / Fault class for check DFC_DevLibBattULo"
    VALUE
    0x808013BD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8063_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8063"
    VALUE
    0x808013BE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8064_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8064"
    VALUE
    0x808013BF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8065_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8065"
    VALUE
    0x808013C0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8066_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8066"
    VALUE
    0x808013C1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8067_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8067"
    VALUE
    0x808013C2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8068_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8068"
    VALUE
    0x808013C3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8069_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8069"
    VALUE
    0x808013C4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x806a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x806a"
    VALUE
    0x808013C5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x806b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x806b"
    VALUE
    0x808013C6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x806c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x806c"
    VALUE
    0x808013C7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x806d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x806d"
    VALUE
    0x808013C8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x806e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x806e"
    VALUE
    0x808013C9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x806f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x806f"
    VALUE
    0x808013CA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8070_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8070"
    VALUE
    0x808013CB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8071_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8071"
    VALUE
    0x808013CC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8072_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8072"
    VALUE
    0x808013CD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8073_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8073"
    VALUE
    0x808013CE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8074_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8074"
    VALUE
    0x808013CF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8075_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8075"
    VALUE
    0x808013D0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8076_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8076"
    VALUE
    0x808013D1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8077_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8077"
    VALUE
    0x808013D2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8078_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8078"
    VALUE
    0x808013D3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8079_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8079"
    VALUE
    0x808013D4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x807a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x807a"
    VALUE
    0x808013D5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x807b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x807b"
    VALUE
    0x808013D6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x807c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x807c"
    VALUE
    0x808013D7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x807d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x807d"
    VALUE
    0x808013D8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x807e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x807e"
    VALUE
    0x808013D9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x807f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x807f"
    VALUE
    0x808013DA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8080_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8080"
    VALUE
    0x808013DB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8081_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8081"
    VALUE
    0x808013DC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8082_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8082"
    VALUE
    0x808013DD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8083_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8083"
    VALUE
    0x808013DE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8084_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8084"
    VALUE
    0x808013DF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8085_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8085"
    VALUE
    0x808013E0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8086_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8086"
    VALUE
    0x808013E1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8087_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8087"
    VALUE
    0x808013E2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8088_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8088"
    VALUE
    0x808013E3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8089_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8089"
    VALUE
    0x808013E4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x808a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x808a"
    VALUE
    0x808013E5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x808b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x808b"
    VALUE
    0x808013E6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x808c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x808c"
    VALUE
    0x808013E7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x808d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x808d"
    VALUE
    0x808013E8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x808e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x808e"
    VALUE
    0x808013E9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x808f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x808f"
    VALUE
    0x808013EA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8090_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8090"
    VALUE
    0x808013EB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8091_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8091"
    VALUE
    0x808013EC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8092_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8092"
    VALUE
    0x808013ED
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8093_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8093"
    VALUE
    0x808013EE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8094_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8094"
    VALUE
    0x808013EF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8095_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8095"
    VALUE
    0x808013F0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8096_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8096"
    VALUE
    0x808013F1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8097_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8097"
    VALUE
    0x808013F2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8098_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8098"
    VALUE
    0x808013F3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8099_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8099"
    VALUE
    0x808013F4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x809a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x809a"
    VALUE
    0x808013F5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x809b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x809b"
    VALUE
    0x808013F6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x809c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x809c"
    VALUE
    0x808013F7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x809d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x809d"
    VALUE
    0x808013F8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x809e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x809e"
    VALUE
    0x808013F9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x809f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x809f"
    VALUE
    0x808013FA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80a0_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80a0"
    VALUE
    0x808013FB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80a1_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80a1"
    VALUE
    0x808013FC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80a2_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80a2"
    VALUE
    0x808013FD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80a3_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80a3"
    VALUE
    0x808013FE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80a4_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80a4"
    VALUE
    0x808013FF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80a5_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80801400
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80a6_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80a6"
    VALUE
    0x80801401
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80a7_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80a7"
    VALUE
    0x80801402
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80a8_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80a8"
    VALUE
    0x80801403
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80a9_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80a9"
    VALUE
    0x80801404
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80aa_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80aa"
    VALUE
    0x80801405
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ab_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ab"
    VALUE
    0x80801406
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ac_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ac"
    VALUE
    0x80801407
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ad_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ad"
    VALUE
    0x80801408
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ae_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ae"
    VALUE
    0x80801409
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80af_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80af"
    VALUE
    0x8080140A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80b0_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80b0"
    VALUE
    0x8080140B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80b1_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80b1"
    VALUE
    0x8080140C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80b2_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80b2"
    VALUE
    0x8080140D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80b3_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80b3"
    VALUE
    0x8080140E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80b4_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80b4"
    VALUE
    0x8080140F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80b5_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80b5"
    VALUE
    0x80801410
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80b6_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80b6"
    VALUE
    0x80801411
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80b7_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80b7"
    VALUE
    0x80801412
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80b8_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80b8"
    VALUE
    0x80801413
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80b9_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80b9"
    VALUE
    0x80801414
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80ba_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80ba"
    VALUE
    0x80801415
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80bb_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80bb"
    VALUE
    0x80801416
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80bc_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80bc"
    VALUE
    0x80801417
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80bd_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80bd"
    VALUE
    0x80801418
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80be_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80be"
    VALUE
    0x80801419
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80bf_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80bf"
    VALUE
    0x8080141A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80c0_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80c0"
    VALUE
    0x8080141B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80c1_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80c1"
    VALUE
    0x8080141C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80c2_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80c2"
    VALUE
    0x8080141D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80c3_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80c3"
    VALUE
    0x8080141E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80c4_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80c4"
    VALUE
    0x8080141F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80c5_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80c5"
    VALUE
    0x80801420
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x80c6_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x80c6"
    VALUE
    0x80801421
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_TiUpDwn0x8A01_C
    "fault class per DFC / Fault class for check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x80801422
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_TiUpDwn0x8A02_C
    "fault class per DFC / Fault class for check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x80801423
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_TiUpDwn0x8A03_C
    "fault class per DFC / Fault class for check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x80801424
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA13OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA13OR"
    VALUE
    0x80801425
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA13SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA13SCB"
    VALUE
    0x80801426
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA13SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA13SCG"
    VALUE
    0x80801427
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA14OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA14OR"
    VALUE
    0x80801428
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA14SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA14SCB"
    VALUE
    0x80801429
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA14SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA14SCG"
    VALUE
    0x8080142A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA21OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA21OR"
    VALUE
    0x8080142B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA21SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA21SCB"
    VALUE
    0x8080142C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA21SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA21SCG"
    VALUE
    0x8080142D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA22OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA22OR"
    VALUE
    0x8080142E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA22SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA22SCB"
    VALUE
    0x8080142F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA22SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA22SCG"
    VALUE
    0x80801430
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA23OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA23OR"
    VALUE
    0x80801431
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA23SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA23SCB"
    VALUE
    0x80801432
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA23SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA23SCG"
    VALUE
    0x80801433
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA24OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA24OR"
    VALUE
    0x80801434
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA24SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA24SCB"
    VALUE
    0x80801435
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA24SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA24SCG"
    VALUE
    0x80801436
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA25OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA25OR"
    VALUE
    0x80801437
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA25SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA25SCB"
    VALUE
    0x80801438
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA25SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA25SCG"
    VALUE
    0x80801439
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA26OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA26OR"
    VALUE
    0x8080143A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA26SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA26SCB"
    VALUE
    0x8080143B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA26SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA26SCG"
    VALUE
    0x8080143C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA27OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA27OR"
    VALUE
    0x8080143D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA27SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA27SCB"
    VALUE
    0x8080143E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA27SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA27SCG"
    VALUE
    0x8080143F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA28OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA28OR"
    VALUE
    0x80801440
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA28SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA28SCB"
    VALUE
    0x80801441
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA28SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA28SCG"
    VALUE
    0x80801442
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA29OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA29OR"
    VALUE
    0x80801443
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA29SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA29SCB"
    VALUE
    0x80801444
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA29SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA29SCG"
    VALUE
    0x80801445
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36AicSCB"
    VALUE
    0x80801446
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36AicSCG"
    VALUE
    0x80801447
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36OR"
    VALUE
    0x80801448
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36SCB"
    VALUE
    0x80801449
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36SCG"
    VALUE
    0x8080144A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA36ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x8080144B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37AicSCB"
    VALUE
    0x8080144C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37AicSCG"
    VALUE
    0x8080144D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37OR"
    VALUE
    0x8080144E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37SCB"
    VALUE
    0x8080144F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37SCG"
    VALUE
    0x80801450
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA37ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80801451
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80801452
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38AicSCG"
    VALUE
    0x80801453
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38OR"
    VALUE
    0x80801454
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38SCB"
    VALUE
    0x80801455
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38SCG"
    VALUE
    0x80801456
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA38ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80801457
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39AicSCB"
    VALUE
    0x80801458
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80801459
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39OR"
    VALUE
    0x8080145A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39SCB"
    VALUE
    0x8080145B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39SCG"
    VALUE
    0x8080145C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA39ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x8080145D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA40OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA40OR"
    VALUE
    0x8080145E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA40SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA40SCB"
    VALUE
    0x8080145F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA40SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA40SCG"
    VALUE
    0x80801460
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA41OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA41OR"
    VALUE
    0x80801461
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA41SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA41SCB"
    VALUE
    0x80801462
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA41SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA41SCG"
    VALUE
    0x80801463
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA42OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA42OR"
    VALUE
    0x80801464
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA42SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA42SCB"
    VALUE
    0x80801465
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA42SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA42SCG"
    VALUE
    0x80801466
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80801467
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43AicSCG"
    VALUE
    0x80801468
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43OR"
    VALUE
    0x80801469
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43SCB"
    VALUE
    0x8080146A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43SCG"
    VALUE
    0x8080146B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA43ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x8080146C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA44OL_C
    "fault class per DFC / Fault class for check DFC_rbr_inA44OL"
    VALUE
    0x8080146D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA44SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA44SCB"
    VALUE
    0x8080146E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA44SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA44SCG"
    VALUE
    0x8080146F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA57OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inA57OR"
    VALUE
    0x80801470
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA57SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA57SCB"
    VALUE
    0x80801471
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA57SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA57SCG"
    VALUE
    0x80801472
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA59OL_C
    "fault class per DFC / Fault class for check DFC_rbr_inA59OL"
    VALUE
    0x80801473
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA59SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inA59SCB"
    VALUE
    0x80801474
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inA59SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inA59SCG"
    VALUE
    0x80801475
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK10OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK10OR"
    VALUE
    0x80801476
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK10SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK10SCB"
    VALUE
    0x80801477
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK10SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK10SCG"
    VALUE
    0x80801478
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK11OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK11OR"
    VALUE
    0x80801479
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK11SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK11SCB"
    VALUE
    0x8080147A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK11SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK11SCG"
    VALUE
    0x8080147B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30AicSCB"
    VALUE
    0x8080147C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30AicSCG"
    VALUE
    0x8080147D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30OR"
    VALUE
    0x8080147E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30SCB"
    VALUE
    0x8080147F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30SCG"
    VALUE
    0x80801480
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK30ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80801481
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK31OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK31OR"
    VALUE
    0x80801482
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK31SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK31SCB"
    VALUE
    0x80801483
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK31SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK31SCG"
    VALUE
    0x80801484
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK32OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK32OR"
    VALUE
    0x80801485
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK32SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK32SCB"
    VALUE
    0x80801486
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK32SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK32SCG"
    VALUE
    0x80801487
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK33OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK33OR"
    VALUE
    0x80801488
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK33SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK33SCB"
    VALUE
    0x80801489
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK33SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK33SCG"
    VALUE
    0x8080148A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK34OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK34OR"
    VALUE
    0x8080148B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK34SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK34SCB"
    VALUE
    0x8080148C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK34SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK34SCG"
    VALUE
    0x8080148D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK35OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK35OR"
    VALUE
    0x8080148E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK35SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK35SCB"
    VALUE
    0x8080148F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK35SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK35SCG"
    VALUE
    0x80801490
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK36OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK36OR"
    VALUE
    0x80801491
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK36SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK36SCB"
    VALUE
    0x80801492
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK36SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK36SCG"
    VALUE
    0x80801493
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37AicSCB"
    VALUE
    0x80801494
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37AicSCG"
    VALUE
    0x80801495
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37OR"
    VALUE
    0x80801496
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37SCB"
    VALUE
    0x80801497
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37SCG"
    VALUE
    0x80801498
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK37ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80801499
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38AicSCB"
    VALUE
    0x8080149A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38AicSCG"
    VALUE
    0x8080149B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38OR"
    VALUE
    0x8080149C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38SCB"
    VALUE
    0x8080149D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38SCG"
    VALUE
    0x8080149E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK38ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x8080149F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39AicSCB"
    VALUE
    0x808014A0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39AicSCG"
    VALUE
    0x808014A1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39OR"
    VALUE
    0x808014A2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39SCB"
    VALUE
    0x808014A3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39SCG"
    VALUE
    0x808014A4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK39ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x808014A5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40AicSCB"
    VALUE
    0x808014A6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40AicSCG"
    VALUE
    0x808014A7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40OR"
    VALUE
    0x808014A8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40SCB"
    VALUE
    0x808014A9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40SCG"
    VALUE
    0x808014AA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK40ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x808014AB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41AicSCB"
    VALUE
    0x808014AC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41AicSCG"
    VALUE
    0x808014AD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41OR"
    VALUE
    0x808014AE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41SCB"
    VALUE
    0x808014AF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41SCG"
    VALUE
    0x808014B0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK41ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x808014B1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42AicSCB"
    VALUE
    0x808014B2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42AicSCG"
    VALUE
    0x808014B3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42OR"
    VALUE
    0x808014B4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42SCB"
    VALUE
    0x808014B5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42SCG"
    VALUE
    0x808014B6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK42ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x808014B7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK43OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK43OR"
    VALUE
    0x808014B8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK43SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK43SCB"
    VALUE
    0x808014B9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK43SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK43SCG"
    VALUE
    0x808014BA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK44AicSCB"
    VALUE
    0x808014BB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK44AicSCG"
    VALUE
    0x808014BC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK44OR"
    VALUE
    0x808014BD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK44SCB"
    VALUE
    0x808014BE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44SCG_C
