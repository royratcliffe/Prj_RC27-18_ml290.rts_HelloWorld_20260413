    DINH_FId.DFC_rbr_outA08SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08SCG"
    VAL_BLK
    0x808020BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09OL"
    VAL_BLK
    0x808020C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09OR"
    VAL_BLK
    0x808020C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09OT"
    VAL_BLK
    0x808020C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09SCB"
    VAL_BLK
    0x808020CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09SCG"
    VAL_BLK
    0x808020D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10OL"
    VAL_BLK
    0x808020D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10OT"
    VAL_BLK
    0x808020D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10SCB"
    VAL_BLK
    0x808020DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10SCG"
    VAL_BLK
    0x808020E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA11OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA11OL"
    VAL_BLK
    0x808020E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA11OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA11OT"
    VAL_BLK
    0x808020E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA11SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA11SCB"
    VAL_BLK
    0x808020EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA11SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA11SCG"
    VAL_BLK
    0x808020F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA12OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA12OR"
    VAL_BLK
    0x808020F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA12SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA12SCB"
    VAL_BLK
    0x808020F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA12SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA12SCG"
    VAL_BLK
    0x808020FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA16OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA16OL"
    VAL_BLK
    0x80802100
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA16OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA16OT"
    VAL_BLK
    0x80802104
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA16SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA16SCB"
    VAL_BLK
    0x80802108
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA16SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA16SCG"
    VAL_BLK
    0x8080210C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17OL"
    VAL_BLK
    0x80802110
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17OR"
    VAL_BLK
    0x80802114
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17OT"
    VAL_BLK
    0x80802118
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17SCB"
    VAL_BLK
    0x8080211C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17SCG"
    VAL_BLK
    0x80802120
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18OL"
    VAL_BLK
    0x80802124
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18OT"
    VAL_BLK
    0x80802128
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18SCB"
    VAL_BLK
    0x8080212C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18SCG"
    VAL_BLK
    0x80802130
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19OL"
    VAL_BLK
    0x80802134
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19OR"
    VAL_BLK
    0x80802138
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19OT"
    VAL_BLK
    0x8080213C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19SCB"
    VAL_BLK
    0x80802140
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19SCG"
    VAL_BLK
    0x80802144
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20OL"
    VAL_BLK
    0x80802148
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20OR"
    VAL_BLK
    0x8080214C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20OT"
    VAL_BLK
    0x80802150
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20SCB"
    VAL_BLK
    0x80802154
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20SCG"
    VAL_BLK
    0x80802158
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31OL"
    VAL_BLK
    0x8080215C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31OR"
    VAL_BLK
    0x80802160
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31OT"
    VAL_BLK
    0x80802164
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31SCB"
    VAL_BLK
    0x80802168
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31SCG"
    VAL_BLK
    0x8080216C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32OL"
    VAL_BLK
    0x80802170
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32OR"
    VAL_BLK
    0x80802174
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32OT"
    VAL_BLK
    0x80802178
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32SCB"
    VAL_BLK
    0x8080217C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32SCG"
    VAL_BLK
    0x80802180
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33OL"
    VAL_BLK
    0x80802184
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33OR"
    VAL_BLK
    0x80802188
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33OT"
    VAL_BLK
    0x8080218C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33SCB"
    VAL_BLK
    0x80802190
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33SCG"
    VAL_BLK
    0x80802194
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34OL"
    VAL_BLK
    0x80802198
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34OR"
    VAL_BLK
    0x8080219C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34OT"
    VAL_BLK
    0x808021A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34SCB"
    VAL_BLK
    0x808021A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34SCG"
    VAL_BLK
    0x808021A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35OL"
    VAL_BLK
    0x808021AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35OR"
    VAL_BLK
    0x808021B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35OT"
    VAL_BLK
    0x808021B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35SCB"
    VAL_BLK
    0x808021B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35SCG"
    VAL_BLK
    0x808021BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46OL"
    VAL_BLK
    0x808021C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46OR"
    VAL_BLK
    0x808021C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46OT"
    VAL_BLK
    0x808021C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46SCB"
    VAL_BLK
    0x808021CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46SCG"
    VAL_BLK
    0x808021D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47OL"
    VAL_BLK
    0x808021D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47OR"
    VAL_BLK
    0x808021D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47OT"
    VAL_BLK
    0x808021DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47SCB"
    VAL_BLK
    0x808021E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47SCG"
    VAL_BLK
    0x808021E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48OL"
    VAL_BLK
    0x808021E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48OR"
    VAL_BLK
    0x808021EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48OT"
    VAL_BLK
    0x808021F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48SCB"
    VAL_BLK
    0x808021F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48SCG"
    VAL_BLK
    0x808021F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA49OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA49OL"
    VAL_BLK
    0x808021FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA49OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA49OT"
    VAL_BLK
    0x80802200
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA49SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA49SCB"
    VAL_BLK
    0x80802204
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA49SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA49SCG"
    VAL_BLK
    0x80802208
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA50OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA50OL"
    VAL_BLK
    0x8080220C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA50OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA50OT"
    VAL_BLK
    0x80802210
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA50SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA50SCB"
    VAL_BLK
    0x80802214
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA50SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA50SCG"
    VAL_BLK
    0x80802218
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51OL"
    VAL_BLK
    0x8080221C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51OR"
    VAL_BLK
    0x80802220
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51OT"
    VAL_BLK
    0x80802224
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51SCB"
    VAL_BLK
    0x80802228
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51SCG"
    VAL_BLK
    0x8080222C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52OL"
    VAL_BLK
    0x80802230
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52OR"
    VAL_BLK
    0x80802234
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52OT"
    VAL_BLK
    0x80802238
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52SCB"
    VAL_BLK
    0x8080223C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52SCG"
    VAL_BLK
    0x80802240
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53OL"
    VAL_BLK
    0x80802244
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53OR"
    VAL_BLK
    0x80802248
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53OT"
    VAL_BLK
    0x8080224C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53SCB"
    VAL_BLK
    0x80802250
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53SCG"
    VAL_BLK
    0x80802254
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54OL"
    VAL_BLK
    0x80802258
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54OR"
    VAL_BLK
    0x8080225C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54OT"
    VAL_BLK
    0x80802260
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54SCB"
    VAL_BLK
    0x80802264
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54SCG"
    VAL_BLK
    0x80802268
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA55OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA55OL"
    VAL_BLK
    0x8080226C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA55OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA55OT"
    VAL_BLK
    0x80802270
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA55SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA55SCB"
    VAL_BLK
    0x80802274
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA55SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA55SCG"
    VAL_BLK
    0x80802278
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA56OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA56OL"
    VAL_BLK
    0x8080227C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA56OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA56OT"
    VAL_BLK
    0x80802280
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA56SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA56SCB"
    VAL_BLK
    0x80802284
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA56SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA56SCG"
    VAL_BLK
    0x80802288
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA58OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA58OL"
    VAL_BLK
    0x8080228C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA58OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA58OT"
    VAL_BLK
    0x80802290
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA58SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA58SCB"
    VAL_BLK
    0x80802294
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA58SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA58SCG"
    VAL_BLK
    0x80802298
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07OL"
    VAL_BLK
    0x8080229C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07OR"
    VAL_BLK
    0x808022A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07OT"
    VAL_BLK
    0x808022A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07SCB"
    VAL_BLK
    0x808022A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07SCG"
    VAL_BLK
    0x808022AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08OL"
    VAL_BLK
    0x808022B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08OR"
    VAL_BLK
    0x808022B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08OT"
    VAL_BLK
    0x808022B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08SCB"
    VAL_BLK
    0x808022BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08SCG"
    VAL_BLK
    0x808022C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09OL"
    VAL_BLK
    0x808022C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09OR"
    VAL_BLK
    0x808022C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09OT"
    VAL_BLK
    0x808022CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09SCB"
    VAL_BLK
    0x808022D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09SCG"
    VAL_BLK
    0x808022D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12OL"
    VAL_BLK
    0x808022D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12OT"
    VAL_BLK
    0x808022DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12SCB"
    VAL_BLK
    0x808022E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12SCG"
    VAL_BLK
    0x808022E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13OL"
    VAL_BLK
    0x808022E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13OT"
    VAL_BLK
    0x808022EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13SCB"
    VAL_BLK
    0x808022F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13SCG"
    VAL_BLK
    0x808022F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14OL"
    VAL_BLK
    0x808022F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14OR"
    VAL_BLK
    0x808022FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14OT"
    VAL_BLK
    0x80802300
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14SCB"
    VAL_BLK
    0x80802304
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14SCG"
    VAL_BLK
    0x80802308
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15OL"
    VAL_BLK
    0x8080230C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15OR"
    VAL_BLK
    0x80802310
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15OT"
    VAL_BLK
    0x80802314
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15SCB"
    VAL_BLK
    0x80802318
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15SCG"
    VAL_BLK
    0x8080231C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16OL"
    VAL_BLK
    0x80802320
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16OR"
    VAL_BLK
    0x80802324
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16OT"
    VAL_BLK
    0x80802328
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16SCB"
    VAL_BLK
    0x8080232C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16SCG"
    VAL_BLK
    0x80802330
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17OL"
    VAL_BLK
    0x80802334
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17OR"
    VAL_BLK
    0x80802338
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17OT"
    VAL_BLK
    0x8080233C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17SCB"
    VAL_BLK
    0x80802340
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17SCG"
    VAL_BLK
    0x80802344
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK25OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK25OR"
    VAL_BLK
    0x80802348
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK25SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK25SCB"
    VAL_BLK
    0x8080234C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK25SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK25SCG"
    VAL_BLK
    0x80802350
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29OL"
    VAL_BLK
    0x80802354
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29OR"
    VAL_BLK
    0x80802358
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29OT"
    VAL_BLK
    0x8080235C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29SCB"
    VAL_BLK
    0x80802360
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29SCG"
    VAL_BLK
    0x80802364
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51OL"
    VAL_BLK
    0x80802368
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51OT"
    VAL_BLK
    0x8080236C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51SCB"
    VAL_BLK
    0x80802370
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51SCG"
    VAL_BLK
    0x80802374
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK62OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK62OR"
    VAL_BLK
    0x80802378
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK62SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK62SCB"
    VAL_BLK
    0x8080237C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK62SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK62SCG"
    VAL_BLK
    0x80802380
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73OL"
    VAL_BLK
    0x80802384
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73OR"
    VAL_BLK
    0x80802388
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73OT"
    VAL_BLK
    0x8080238C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73SCB"
    VAL_BLK
    0x80802390
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73SCG"
    VAL_BLK
    0x80802394
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK80OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK80OL"
    VAL_BLK
    0x80802398
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK80OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK80OT"
    VAL_BLK
    0x8080239C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK80SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK80SCB"
    VAL_BLK
    0x808023A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK80SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK80SCG"
    VAL_BLK
    0x808023A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK81OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK81OL"
    VAL_BLK
    0x808023A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK81OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK81OT"
    VAL_BLK
    0x808023AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK81SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK81SCB"
    VAL_BLK
    0x808023B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK81SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK81SCG"
    VAL_BLK
    0x808023B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK82OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK82OL"
    VAL_BLK
    0x808023B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK82OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK82OT"
    VAL_BLK
    0x808023BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK82SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK82SCB"
    VAL_BLK
    0x808023C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK82SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK82SCG"
    VAL_BLK
    0x808023C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK83OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK83OL"
    VAL_BLK
    0x808023C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK83OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK83OT"
    VAL_BLK
    0x808023CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK83SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK83SCB"
    VAL_BLK
    0x808023D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK83SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK83SCG"
    VAL_BLK
    0x808023D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK84OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK84OL"
    VAL_BLK
    0x808023D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK84OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK84OT"
    VAL_BLK
    0x808023DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK84SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK84SCB"
    VAL_BLK
    0x808023E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK84SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK84SCG"
    VAL_BLK
    0x808023E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK85OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK85OL"
    VAL_BLK
    0x808023E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK85OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK85OT"
    VAL_BLK
    0x808023EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK85SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK85SCB"
    VAL_BLK
    0x808023F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK85SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK85SCG"
    VAL_BLK
    0x808023F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK86OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK86OL"
    VAL_BLK
    0x808023F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK86OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK86OT"
    VAL_BLK
    0x808023FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK86SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK86SCB"
    VAL_BLK
    0x80802400
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK86SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK86SCG"
    VAL_BLK
    0x80802404
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK87OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK87OL"
    VAL_BLK
    0x80802408
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK87OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK87OT"
    VAL_BLK
    0x8080240C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK87SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK87SCB"
    VAL_BLK
    0x80802410
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK87SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK87SCG"
    VAL_BLK
    0x80802414
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_DSMDummy_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_DSMDummy"
    VAL_BLK
    0x80802418
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8000_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8000"
    VAL_BLK
    0x8080241C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8001_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8001"
    VAL_BLK
    0x80802420
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8002_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8002"
    VAL_BLK
    0x80802424
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8003_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8003"
    VAL_BLK
    0x80802428
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8004_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8004"
    VAL_BLK
    0x8080242C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8005_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8005"
    VAL_BLK
    0x80802430
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8006_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8006"
    VAL_BLK
    0x80802434
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8007_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8007"
    VAL_BLK
    0x80802438
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8008_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8008"
    VAL_BLK
    0x8080243C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8009_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8009"
    VAL_BLK
    0x80802440
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x800a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x800a"
    VAL_BLK
    0x80802444
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x800b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x800b"
    VAL_BLK
    0x80802448
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x800c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x800c"
    VAL_BLK
    0x8080244C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x800d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x800d"
    VAL_BLK
    0x80802450
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x800e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x800e"
    VAL_BLK
    0x80802454
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x800f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x800f"
    VAL_BLK
    0x80802458
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8010_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8010"
    VAL_BLK
    0x8080245C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8011_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8011"
    VAL_BLK
    0x80802460
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8012_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8012"
    VAL_BLK
    0x80802464
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8013_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8013"
    VAL_BLK
    0x80802468
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8014_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8014"
    VAL_BLK
    0x8080246C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8015_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8015"
    VAL_BLK
    0x80802470
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8016_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8016"
    VAL_BLK
    0x80802474
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8017_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8017"
    VAL_BLK
    0x80802478
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8018_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8018"
    VAL_BLK
    0x8080247C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8019_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8019"
    VAL_BLK
    0x80802480
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x801a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x801a"
    VAL_BLK
    0x80802484
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x801b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x801b"
    VAL_BLK
    0x80802488
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x801c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x801c"
    VAL_BLK
    0x8080248C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x801d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x801d"
    VAL_BLK
    0x80802490
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x801e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x801e"
    VAL_BLK
    0x80802494
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x801f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x801f"
    VAL_BLK
    0x80802498
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8020_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8020"
    VAL_BLK
    0x8080249C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8021_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8021"
    VAL_BLK
    0x808024A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8022_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8022"
    VAL_BLK
    0x808024A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8023_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8023"
    VAL_BLK
    0x808024A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8024_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8024"
    VAL_BLK
    0x808024AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8025_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8025"
    VAL_BLK
    0x808024B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8026_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8026"
    VAL_BLK
    0x808024B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8027_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8027"
    VAL_BLK
    0x808024B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8028_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8028"
    VAL_BLK
    0x808024BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8029_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8029"
    VAL_BLK
    0x808024C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x802a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x802a"
    VAL_BLK
    0x808024C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x802b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x802b"
    VAL_BLK
    0x808024C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x802c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x802c"
    VAL_BLK
    0x808024CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x802d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x802d"
    VAL_BLK
    0x808024D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x802e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x802e"
    VAL_BLK
    0x808024D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x802f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x802f"
    VAL_BLK
    0x808024D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8030_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8030"
    VAL_BLK
    0x808024DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8031_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8031"
    VAL_BLK
    0x808024E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8032_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8032"
    VAL_BLK
    0x808024E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8033_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8033"
    VAL_BLK
    0x808024E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8034_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8034"
    VAL_BLK
    0x808024EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8035_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8035"
    VAL_BLK
    0x808024F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8036_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8036"
    VAL_BLK
    0x808024F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8037_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8037"
    VAL_BLK
    0x808024F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8038_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8038"
    VAL_BLK
    0x808024FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8039_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8039"
    VAL_BLK
    0x80802500
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x803a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x803a"
    VAL_BLK
    0x80802504
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x803b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x803b"
    VAL_BLK
    0x80802508
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x803c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x803c"
    VAL_BLK
    0x8080250C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x803d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x803d"
    VAL_BLK
    0x80802510
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x803e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x803e"
    VAL_BLK
    0x80802514
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x803f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x803f"
    VAL_BLK
    0x80802518
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8040_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8040"
    VAL_BLK
    0x8080251C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8041_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8041"
    VAL_BLK
    0x80802520
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8042_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8042"
    VAL_BLK
    0x80802524
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8043_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8043"
    VAL_BLK
    0x80802528
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8044_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8044"
    VAL_BLK
    0x8080252C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8045_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8045"
    VAL_BLK
    0x80802530
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8046_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8046"
    VAL_BLK
    0x80802534
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8047_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8047"
    VAL_BLK
    0x80802538
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8048_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8048"
    VAL_BLK
    0x8080253C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8049_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8049"
    VAL_BLK
    0x80802540
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x804a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x804a"
    VAL_BLK
    0x80802544
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x804b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x804b"
    VAL_BLK
    0x80802548
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x804c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x804c"
    VAL_BLK
    0x8080254C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x804d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x804d"
    VAL_BLK
    0x80802550
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x804e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x804e"
    VAL_BLK
    0x80802554
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x804f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x804f"
    VAL_BLK
    0x80802558
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8050_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8050"
    VAL_BLK
    0x8080255C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8051_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8051"
    VAL_BLK
    0x80802560
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8052_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8052"
    VAL_BLK
    0x80802564
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8053_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8053"
    VAL_BLK
    0x80802568
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8054_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8054"
    VAL_BLK
    0x8080256C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8055_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8055"
    VAL_BLK
    0x80802570
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8056_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8056"
    VAL_BLK
    0x80802574
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8057_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8057"
    VAL_BLK
    0x80802578
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8058_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8058"
    VAL_BLK
    0x8080257C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8059_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8059"
    VAL_BLK
    0x80802580
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x805a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x805a"
    VAL_BLK
    0x80802584
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x805b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x805b"
    VAL_BLK
    0x80802588
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x805c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x805c"
    VAL_BLK
    0x8080258C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x805d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x805d"
    VAL_BLK
    0x80802590
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x805e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x805e"
    VAL_BLK
    0x80802594
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x805f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x805f"
    VAL_BLK
    0x80802598
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8060_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8060"
    VAL_BLK
    0x8080259C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8061_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8061"
    VAL_BLK
    0x808025A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8062_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8062"
    VAL_BLK
    0x808025A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8C01_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8C01"
    VAL_BLK
    0x808025A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8C02_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8C02"
    VAL_BLK
    0x808025AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8C03_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8C03"
    VAL_BLK
    0x808025B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetDataNoBuf_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetDataNoBuf"
    VAL_BLK
    0x808025B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetDataParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetDataParam"
    VAL_BLK
    0x808025B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetDataboxNoInit_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetDataboxNoInit"
    VAL_BLK
    0x808025BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetDataboxParam"
    VAL_BLK
    0x808025C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetRxBufStatusParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetRxBufStatusParam"
    VAL_BLK
    0x808025C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetStatusParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetStatusParam"
    VAL_BLK
    0x808025C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canGetTxBufStatusParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canGetTxBufStatusParam"
    VAL_BLK
    0x808025CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canInitParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canInitParam"
    VAL_BLK
    0x808025D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canInitRxDataboxOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canInitRxDataboxOverlap"
    VAL_BLK
    0x808025D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canInitRxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canInitRxDataboxParam"
    VAL_BLK
    0x808025D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canInitTxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canInitTxDataboxParam"
    VAL_BLK
    0x808025DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canIpduGroupControl_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canIpduGroupControl"
    VAL_BLK
    0x808025E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canIsDataboxFreeNoInit_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canIsDataboxFreeNoInit"
    VAL_BLK
    0x808025E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canIsDataboxFreeParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canIsDataboxFreeParam"
    VAL_BLK
    0x808025E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canIsTxEmptyParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canIsTxEmptyParam"
    VAL_BLK
    0x808025EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegBusOffCallbInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegBusOffCallbInvState"
    VAL_BLK
    0x808025F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegBusOffCallbParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegBusOffCallbParam"
    VAL_BLK
    0x808025F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxBufInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxBufInvState"
    VAL_BLK
    0x808025F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxBufOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxBufOverlap"
    VAL_BLK
    0x808025FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxBufParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxBufParam"
    VAL_BLK
    0x80802600
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxCallbInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxCallbInvState"
    VAL_BLK
    0x80802604
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxCallbParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxCallbParam"
    VAL_BLK
    0x80802608
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxDataboxInvNumb_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxDataboxInvNumb"
    VAL_BLK
    0x8080260C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxDataboxInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxDataboxInvState"
    VAL_BLK
    0x80802610
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxDataboxOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxDataboxOverlap"
    VAL_BLK
    0x80802614
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegRxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegRxDataboxParam"
    VAL_BLK
    0x80802618
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxBufInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxBufInvState"
    VAL_BLK
    0x8080261C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxBufOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxBufOverlap"
    VAL_BLK
    0x80802620
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxBufParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxBufParam"
    VAL_BLK
    0x80802624
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxDataboxInvNumb_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxDataboxInvNumb"
    VAL_BLK
    0x80802628
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxDataboxInvState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxDataboxInvState"
    VAL_BLK
    0x8080262C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxDataboxOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxDataboxOverlap"
    VAL_BLK
    0x80802630
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canRegTxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canRegTxDataboxParam"
    VAL_BLK
    0x80802634
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canResetTxBufParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canResetTxBufParam"
    VAL_BLK
    0x80802638
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canSendDataBufOvfl_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canSendDataBufOvfl"
    VAL_BLK
    0x8080263C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canSendDataParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canSendDataParam"
    VAL_BLK
    0x80802640
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canSendDataboxNoInit_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canSendDataboxNoInit"
    VAL_BLK
    0x80802644
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canSendDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canSendDataboxParam"
    VAL_BLK
    0x80802648
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canSetTxCycleParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canSetTxCycleParam"
    VAL_BLK
    0x8080264C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canStartParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canStartParam"
    VAL_BLK
    0x80802650
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_canStopParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_canStopParam"
    VAL_BLK
    0x80802654
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_can_ClearIpduGroup_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_can_ClearIpduGroup"
    VAL_BLK
    0x80802658
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_can_ReceiveSignal_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_can_ReceiveSignal"
    VAL_BLK
    0x8080265C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_can_SendSignal_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_can_SendSignal"
    VAL_BLK
    0x80802660
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_can_SetIpduGroup_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_can_SetIpduGroup"
    VAL_BLK
    0x80802664
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmDTCJ1939_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmDTCJ1939"
    VAL_BLK
    0x80802668
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmDelDTCJ1939_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmDelDTCJ1939"
    VAL_BLK
    0x8080266C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmDelErrors_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmDelErrors"
    VAL_BLK
    0x80802670
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmGetDFES_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmGetDFES"
    VAL_BLK
    0x80802674
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmGetDTCJ1939_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmGetDTCJ1939"
    VAL_BLK
    0x80802678
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmGetErrors_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmGetErrors"
    VAL_BLK
    0x8080267C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmGetNumErrors_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmGetNumErrors"
    VAL_BLK
    0x80802680
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmInitQueueOverflow_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmInitQueueOverflow"
    VAL_BLK
    0x80802684
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmNumDTCJ1939_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmNumDTCJ1939"
    VAL_BLK
    0x80802688
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmTesterror_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmTesterror"
    VAL_BLK
    0x8080268C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmUpdateDebError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmUpdateDebError"
    VAL_BLK
    0x80802690
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmUpdateError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmUpdateError"
    VAL_BLK
    0x80802694
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmgetDFCStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmgetDFCStatus"
    VAL_BLK
    0x80802698
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_dsmtestErrorDFC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_dsmtestErrorDFC"
    VAL_BLK
    0x8080269C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAi"
    VAL_BLK
    0x808026A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAic_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAic"
    VAL_BLK
    0x808026A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAicCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAicCfg"
    VAL_BLK
    0x808026A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAicGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAicGetStatus"
    VAL_BLK
    0x808026AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAid_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAid"
    VAL_BLK
    0x808026B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAidCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAidCfg"
    VAL_BLK
    0x808026B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAiv_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAiv"
    VAL_BLK
    0x808026B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAivCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAivCfg"
    VAL_BLK
    0x808026BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inAivGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inAivGetStatus"
    VAL_BLK
    0x808026C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inDi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inDi"
    VAL_BLK
    0x808026C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inFi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inFi"
    VAL_BLK
    0x808026C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inFiCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inFiCfg"
    VAL_BLK
    0x808026CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inFiGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inFiGetStatus"
    VAL_BLK
    0x808026D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inFi_Buffered_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inFi_Buffered"
    VAL_BLK
    0x808026D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inPhase_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inPhase"
    VAL_BLK
    0x808026D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inPhaseGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inPhaseGetStatus"
    VAL_BLK
    0x808026DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inPhaseResetCounter_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inPhaseResetCounter"
    VAL_BLK
    0x808026E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inRi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inRi"
    VAL_BLK
    0x808026E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inRiCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inRiCfg"
    VAL_BLK
    0x808026E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inRiCfgTemp_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inRiCfgTemp"
    VAL_BLK
    0x808026EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inRiGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inRiGetStatus"
    VAL_BLK
    0x808026F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inRiGetTemp_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inRiGetTemp"
    VAL_BLK
    0x808026F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentCopyFDFifo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentCopyFDFifo"
    VAL_BLK
    0x808026F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentDisable_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentDisable"
    VAL_BLK
    0x808026FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentEnable_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentEnable"
    VAL_BLK
    0x80802700
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentGetErrorStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentGetErrorStatus"
    VAL_BLK
    0x80802704
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentGetFD_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentGetFD"
    VAL_BLK
    0x80802708
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentGetSD_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentGetSD"
    VAL_BLK
    0x8080270C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentGetSDDatabox_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentGetSDDatabox"
    VAL_BLK
    0x80802710
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentGetStatus"
    VAL_BLK
    0x80802714
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentInitSDDatabox_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentInitSDDatabox"
    VAL_BLK
    0x80802718
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentRegisterCopyFDFifo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentRegisterCopyFDFifo"
    VAL_BLK
    0x8080271C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentRegisterFDFifo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentRegisterFDFifo"
    VAL_BLK
    0x80802720
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inSentRegisterSDDataboxes_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inSentRegisterSDDataboxes"
    VAL_BLK
    0x80802724
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusCanRxBufferOverflow_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusCanRxBufferOverflow"
    VAL_BLK
    0x80802728
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusGetCaAddrParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusGetCaAddrParam"
    VAL_BLK
    0x8080272C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusGetDiagnosticParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusGetDiagnosticParam"
    VAL_BLK
    0x80802730
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusGetRxDataboxStatusParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusGetRxDataboxStatusParam"
    VAL_BLK
    0x80802734
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusGetStatusParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusGetStatusParam"
    VAL_BLK
    0x80802738
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitCommCaMissing_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitCommCaMissing"
    VAL_BLK
    0x8080273C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitCommParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitCommParam"
    VAL_BLK
    0x80802740
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitCommState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitCommState"
    VAL_BLK
    0x80802744
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitDiagnosticParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitDiagnosticParam"
    VAL_BLK
    0x80802748
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitFailureListParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitFailureListParam"
    VAL_BLK
    0x8080274C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitRxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitRxDataboxParam"
    VAL_BLK
    0x80802750
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusInitTxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusInitTxDataboxParam"
    VAL_BLK
    0x80802754
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegRxDataboxOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegRxDataboxOverlap"
    VAL_BLK
    0x80802758
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegRxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegRxDataboxParam"
    VAL_BLK
    0x8080275C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegRxDataboxState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegRxDataboxState"
    VAL_BLK
    0x80802760
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegTxDataboxOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegTxDataboxOverlap"
    VAL_BLK
    0x80802764
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegTxDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegTxDataboxParam"
    VAL_BLK
    0x80802768
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegTxDataboxState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegTxDataboxState"
    VAL_BLK
    0x8080276C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegisterErrClrCallbackParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegisterErrClrCallbackParam"
    VAL_BLK
    0x80802770
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegisterInstancesOverlap_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegisterInstancesOverlap"
    VAL_BLK
    0x80802774
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegisterInstancesParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegisterInstancesParam"
    VAL_BLK
    0x80802778
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusRegisterInstancesState_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusRegisterInstancesState"
    VAL_BLK
    0x8080277C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSendDataboxParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSendDataboxParam"
    VAL_BLK
    0x80802780
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSendRequestPGNParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSendRequestPGNParam"
    VAL_BLK
    0x80802784
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaAddrCaUsed_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaAddrCaUsed"
    VAL_BLK
    0x80802788
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaAddrComm_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaAddrComm"
    VAL_BLK
    0x8080278C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaAddrInvCan_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaAddrInvCan"
    VAL_BLK
    0x80802790
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaAddrParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaAddrParam"
    VAL_BLK
    0x80802794
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaInfoParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaInfoParam"
    VAL_BLK
    0x80802798
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSetCaNameParam_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSetCaNameParam"
    VAL_BLK
    0x8080279C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_isobusSftyCanTxErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_isobusSftyCanTxErr"
    VAL_BLK
    0x808027A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_ReceiveSignal_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_ReceiveSignal"
    VAL_BLK
    0x808027A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_SendSignal_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_SendSignal"
    VAL_BLK
    0x808027A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_getStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_getStatus"
    VAL_BLK
    0x808027AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_gotoSleep_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_gotoSleep"
    VAL_BLK
    0x808027B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_scheduleRequest_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_scheduleRequest"
    VAL_BLK
    0x808027B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_lin_wakeUp_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_lin_wakeUp"
    VAL_BLK
    0x808027B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memFlsCfgShr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memFlsCfgShr"
    VAL_BLK
    0x808027BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memGetStatus"
    VAL_BLK
    0x808027C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memMarkBlock_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memMarkBlock"
    VAL_BLK
    0x808027C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadApi1Error_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadApi1Error"
    VAL_BLK
    0x808027C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadApi2Error_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadApi2Error"
    VAL_BLK
    0x808027CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadBlock_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadBlock"
    VAL_BLK
    0x808027D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadCalibInputError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadCalibInputError"
    VAL_BLK
    0x808027D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadCalibOuputError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadCalibOuputError"
    VAL_BLK
    0x808027D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memReadSystemError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memReadSystemError"
    VAL_BLK
    0x808027DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_memWriteBlock_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_memWriteBlock"
    VAL_BLK
    0x808027E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_moOV_FirstConstADC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_moOV_FirstConstADC"
    VAL_BLK
    0x808027E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_moOV_SecondConstADC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_moOV_SecondConstADC"
    VAL_BLK
    0x808027E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_moUV_FirstConstADC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_moUV_FirstConstADC"
    VAL_BLK
    0x808027EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_moUV_SecondConstADC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_moUV_SecondConstADC"
    VAL_BLK
    0x808027F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_INH_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_INH"
    VAL_BLK
    0x808027F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_INHLatch_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_INHLatch"
    VAL_BLK
    0x808027F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_adcPDD_fail_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_adcPDD_fail"
    VAL_BLK
    0x808027FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_memoryProtection_err_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_memoryProtection_err"
    VAL_BLK
    0x80802800
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02OC"
    VAL_BLK
    0x80802804
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02Unintended"
    VAL_BLK
    0x80802808
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03OC"
    VAL_BLK
    0x8080280C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03Unintended"
    VAL_BLK
    0x80802810
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04OC"
    VAL_BLK
    0x80802814
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04Unintended"
    VAL_BLK
    0x80802818
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05OC"
    VAL_BLK
    0x8080281C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05Unintended"
    VAL_BLK
    0x80802820
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07OC"
    VAL_BLK
    0x80802824
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07Unintended"
    VAL_BLK
    0x80802828
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA08OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08OC"
    VAL_BLK
    0x8080282C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA08Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08Unintended"
    VAL_BLK
    0x80802830
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09OC"
    VAL_BLK
    0x80802834
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA09Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA09Unintended"
    VAL_BLK
    0x80802838
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10OC"
    VAL_BLK
    0x8080283C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA10Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA10Unintended"
    VAL_BLK
    0x80802840
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17OC"
    VAL_BLK
    0x80802844
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA17Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA17Unintended"
    VAL_BLK
    0x80802848
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18OC"
    VAL_BLK
    0x8080284C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA18Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA18Unintended"
    VAL_BLK
    0x80802850
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19OC"
    VAL_BLK
    0x80802854
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA19Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA19Unintended"
    VAL_BLK
    0x80802858
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20OC"
    VAL_BLK
    0x8080285C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA20Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA20Unintended"
    VAL_BLK
    0x80802860
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31OC"
    VAL_BLK
    0x80802864
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA31Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA31Unintended"
    VAL_BLK
    0x80802868
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32OC"
    VAL_BLK
    0x8080286C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA32Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA32Unintended"
    VAL_BLK
    0x80802870
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33OC"
    VAL_BLK
    0x80802874
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA33Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA33Unintended"
    VAL_BLK
    0x80802878
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34OC"
    VAL_BLK
    0x8080287C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA34Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA34Unintended"
    VAL_BLK
    0x80802880
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35OC"
    VAL_BLK
    0x80802884
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA35Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA35Unintended"
    VAL_BLK
    0x80802888
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46OC"
    VAL_BLK
    0x8080288C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA46Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA46Unintended"
    VAL_BLK
    0x80802890
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47OC"
    VAL_BLK
    0x80802894
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA47Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA47Unintended"
    VAL_BLK
    0x80802898
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48OC"
    VAL_BLK
    0x8080289C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA48Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA48Unintended"
    VAL_BLK
    0x808028A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51OC"
    VAL_BLK
    0x808028A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA51Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA51Unintended"
    VAL_BLK
    0x808028A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52OC"
    VAL_BLK
    0x808028AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA52Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA52Unintended"
    VAL_BLK
    0x808028B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53OC"
    VAL_BLK
    0x808028B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA53Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA53Unintended"
    VAL_BLK
    0x808028B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54OC"
    VAL_BLK
    0x808028BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA54Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA54Unintended"
    VAL_BLK
    0x808028C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAov_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAov"
    VAL_BLK
    0x808028C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAovCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAovCfg"
    VAL_BLK
    0x808028C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAovCfgPI_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAovCfgPI"
    VAL_BLK
    0x808028CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAovGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAovGetStatus"
    VAL_BLK
    0x808028D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAovGetVoltage_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAovGetVoltage"
    VAL_BLK
    0x808028D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outAovResetError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outAovResetError"
    VAL_BLK
    0x808028D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDo"
    VAL_BLK
    0x808028DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDoCfgPwrLs_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDoCfgPwrLs"
    VAL_BLK
    0x808028E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDoDisable_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDoDisable"
    VAL_BLK
    0x808028E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDoGetCurrent_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDoGetCurrent"
    VAL_BLK
    0x808028E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDoGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDoGetStatus"
    VAL_BLK
    0x808028EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outDoResetError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outDoResetError"
    VAL_BLK
    0x808028F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07OC"
    VAL_BLK
    0x808028F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK07Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK07Unintended"
    VAL_BLK
    0x808028F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08OC"
    VAL_BLK
    0x808028FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK08Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK08Unintended"
    VAL_BLK
    0x80802900
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09OC"
    VAL_BLK
    0x80802904
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK09Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK09Unintended"
    VAL_BLK
    0x80802908
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12OC"
    VAL_BLK
    0x8080290C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK12Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK12Unintended"
    VAL_BLK
    0x80802910
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13OC"
    VAL_BLK
    0x80802914
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK13Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK13Unintended"
    VAL_BLK
    0x80802918
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14OC"
    VAL_BLK
    0x8080291C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK14Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK14Unintended"
    VAL_BLK
    0x80802920
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15OC"
    VAL_BLK
    0x80802924
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK15Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK15Unintended"
    VAL_BLK
    0x80802928
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16OC"
    VAL_BLK
    0x8080292C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK16Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK16Unintended"
    VAL_BLK
    0x80802930
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17OC"
    VAL_BLK
    0x80802934
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK17Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK17Unintended"
    VAL_BLK
    0x80802938
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29OC"
    VAL_BLK
    0x8080293C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK29Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK29Unintended"
    VAL_BLK
    0x80802940
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51OC"
    VAL_BLK
    0x80802944
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK51Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK51Unintended"
    VAL_BLK
    0x80802948
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73OC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73OC"
    VAL_BLK
    0x8080294C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outK73Unintended_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outK73Unintended"
    VAL_BLK
    0x80802950
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPo"
    VAL_BLK
    0x80802954
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoCfg"
    VAL_BLK
    0x80802958
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoCfgPeriod_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoCfgPeriod"
    VAL_BLK
    0x8080295C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoCfgPwrLs_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoCfgPwrLs"
    VAL_BLK
    0x80802960
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoDisable_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoDisable"
    VAL_BLK
    0x80802964
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoGetCurrent_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoGetCurrent"
    VAL_BLK
    0x80802968
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoGetStatus"
    VAL_BLK
    0x8080296C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoResetError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoResetError"
    VAL_BLK
    0x80802970
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPoc_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPoc"
    VAL_BLK
    0x80802974
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPocCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPocCfg"
    VAL_BLK
    0x80802978
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPocCfgDither_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPocCfgDither"
    VAL_BLK
    0x8080297C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPocCfgPI_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPocCfgPI"
    VAL_BLK
    0x80802980
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPod_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPod"
    VAL_BLK
    0x80802984
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPodCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPodCfg"
    VAL_BLK
    0x80802988
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outPodCfgPeriod_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outPodCfgPeriod"
    VAL_BLK
    0x8080298C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_rsmFfiApiCallErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_rsmFfiApiCallErr"
    VAL_BLK
    0x80802990
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safout_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safout"
    VAL_BLK
    0x80802994
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutCfg"
    VAL_BLK
    0x80802998
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl1"
    VAL_BLK
    0x8080299C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl10"
    VAL_BLK
    0x808029A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl10Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl10Dev"
    VAL_BLK
    0x808029A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl10OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl10OR"
    VAL_BLK
    0x808029A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl11"
    VAL_BLK
    0x808029AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl11Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl11Dev"
    VAL_BLK
    0x808029B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl11OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl11OR"
    VAL_BLK
    0x808029B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl12_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl12"
    VAL_BLK
    0x808029B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl12Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl12Dev"
    VAL_BLK
    0x808029BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl12OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl12OR"
    VAL_BLK
    0x808029C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl13"
    VAL_BLK
    0x808029C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl13Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl13Dev"
    VAL_BLK
    0x808029C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl13OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl13OR"
    VAL_BLK
    0x808029CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl14"
    VAL_BLK
    0x808029D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl14Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl14Dev"
    VAL_BLK
    0x808029D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl14OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl14OR"
    VAL_BLK
    0x808029D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl15_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl15"
    VAL_BLK
    0x808029DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl15Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl15Dev"
    VAL_BLK
    0x808029E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl15OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl15OR"
    VAL_BLK
    0x808029E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl16_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl16"
    VAL_BLK
    0x808029E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl16Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl16Dev"
    VAL_BLK
    0x808029EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl16OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl16OR"
    VAL_BLK
    0x808029F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl17_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl17"
    VAL_BLK
    0x808029F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl17Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl17Dev"
    VAL_BLK
    0x808029F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl17OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl17OR"
    VAL_BLK
    0x808029FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl18_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl18"
    VAL_BLK
    0x80802A00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl18Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl18Dev"
    VAL_BLK
    0x80802A04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl18OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl18OR"
    VAL_BLK
    0x80802A08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl1Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl1Dev"
    VAL_BLK
    0x80802A0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl1OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl1OR"
    VAL_BLK
    0x80802A10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl2"
    VAL_BLK
    0x80802A14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl2Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl2Dev"
    VAL_BLK
    0x80802A18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl2OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl2OR"
    VAL_BLK
    0x80802A1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl3"
    VAL_BLK
    0x80802A20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl3Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl3Dev"
    VAL_BLK
    0x80802A24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl3OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl3OR"
    VAL_BLK
    0x80802A28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl4"
    VAL_BLK
    0x80802A2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl4Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl4Dev"
    VAL_BLK
    0x80802A30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl4OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl4OR"
    VAL_BLK
    0x80802A34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl5"
    VAL_BLK
    0x80802A38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl5Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl5Dev"
    VAL_BLK
    0x80802A3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl5OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl5OR"
    VAL_BLK
    0x80802A40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl6"
    VAL_BLK
    0x80802A44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl6Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl6Dev"
    VAL_BLK
    0x80802A48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl6OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl6OR"
    VAL_BLK
    0x80802A4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl7"
    VAL_BLK
    0x80802A50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl7Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl7Dev"
    VAL_BLK
    0x80802A54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl7OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl7OR"
    VAL_BLK
    0x80802A58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl8"
    VAL_BLK
    0x80802A5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl8Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl8Dev"
    VAL_BLK
    0x80802A60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl8OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl8OR"
    VAL_BLK
    0x80802A64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl9_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl9"
    VAL_BLK
    0x80802A68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl9Dev_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl9Dev"
    VAL_BLK
    0x80802A6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutChnl9OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutChnl9OR"
    VAL_BLK
    0x80802A70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutDevError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutDevError"
    VAL_BLK
    0x80802A74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutGetStatus_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutGetStatus"
    VAL_BLK
    0x80802A78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutIgnoreError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutIgnoreError"
    VAL_BLK
    0x80802A7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutResetError_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutResetError"
    VAL_BLK
    0x80802A80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safoutUnlock_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safoutUnlock"
    VAL_BLK
    0x80802A84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_safout_cfgDiag_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_safout_cfgDiag"
    VAL_BLK
    0x80802A88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secAccessDenied_RC_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secAccessDenied_RC"
    VAL_BLK
    0x80802A8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secAccessDenied_WDBI_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secAccessDenied_WDBI"
    VAL_BLK
    0x80802A90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secEvalRespKey_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secEvalRespKey"
    VAL_BLK
    0x80802A94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secFlashingFailure_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secFlashingFailure"
    VAL_BLK
    0x80802A98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secGetLevel_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secGetLevel"
    VAL_BLK
    0x80802A9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secGetRnd_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secGetRnd"
    VAL_BLK
    0x80802AA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secGetSeed_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secGetSeed"
    VAL_BLK
    0x80802AA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secInvalidPassword_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secInvalidPassword"
    VAL_BLK
    0x80802AA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secIsRequestAllowed_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secIsRequestAllowed"
    VAL_BLK
    0x80802AAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secResetLevel_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secResetLevel"
    VAL_BLK
    0x80802AB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secSaveSecret_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secSaveSecret"
    VAL_BLK
    0x80802AB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_secSetLevel_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_secSetLevel"
    VAL_BLK
    0x80802AB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysAit_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysAit"
    VAL_BLK
    0x80802ABC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysAiv_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysAiv"
    VAL_BLK
    0x80802AC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysDi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysDi"
    VAL_BLK
    0x80802AC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysDo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysDo"
    VAL_BLK
    0x80802AC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysGetVss_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysGetVss"
    VAL_BLK
    0x80802ACC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysInit_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysInit"
    VAL_BLK
    0x80802AD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysOperHrIntegrityErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysOperHrIntegrityErr"
    VAL_BLK
    0x80802AD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysOperHrsSaturated_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysOperHrsSaturated"
    VAL_BLK
    0x80802AD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sysSetVss_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sysSetVss"
    VAL_BLK
    0x80802ADC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sys_coreload_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sys_coreload"
    VAL_BLK
    0x80802AE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_sys_taskload_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_sys_taskload"
    VAL_BLK
    0x80802AE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VSS1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VSS1"
    VAL_BLK
    0x80802AE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VSS2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VSS2"
    VAL_BLK
    0x80802AEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VSS1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VSS1"
    VAL_BLK
    0x80802AF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VSS2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VSS2"
    VAL_BLK
    0x80802AF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VAL_BLK
    0x80802AF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VAL_BLK
    0x80802AFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VAL_BLK
    0x80802B00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CANSM_E_BUS_OFF_NETWORK_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VAL_BLK
    0x80802B04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VAL_BLK
    0x80802B08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_CAN_E_TIMEOUT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_CAN_E_TIMEOUT"
    VAL_BLK
    0x80802B0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VAL_BLK
    0x80802B10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VAL_BLK
    0x80802B14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VAL_BLK
    0x80802B18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VAL_BLK
    0x80802B1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VAL_BLK
    0x80802B20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_COMM_E_NET_START_IND_CHANNEL_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VAL_BLK
    0x80802B24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_LIN_E_TIMEOUT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_LIN_E_TIMEOUT"
    VAL_BLK
    0x80802B28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_MultiStackTrace_Threshold_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_MultiStackTrace_Threshold"
    VAL_BLK
    0x80802B2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_ETH_E_ACCESS_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_ETH_E_ACCESS_0"
    VAL_BLK
    0x80802B30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VAL_BLK
    0x80802B34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VAL_BLK
    0x80802B38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_MRly_Diag_Stk_Event_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_MRly_Diag_Stk_Event"
    VAL_BLK
    0x80802B3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_MemDiagExtd_MemReadSngErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_MemDiagExtd_MemReadSngErr"
    VAL_BLK
    0x80802B40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_MemDiag_MemReadErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_MemDiag_MemReadErr"
    VAL_BLK
    0x80802B44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_MemDiag_MemWrErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_MemDiag_MemWrErr"
    VAL_BLK
    0x80802B48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VAL_BLK
    0x80802B4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_T15_Diag_ComInVld_Event_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_T15_Diag_ComInVld_Event"
    VAL_BLK
    0x80802B50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_T15_Diag_ComOff_HwOn_Event_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VAL_BLK
    0x80802B54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rba_T15_Diag_ComOn_HwOff_Event_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VAL_BLK
    0x80802B58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_0"
    VAL_BLK
    0x80802B5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_1"
    VAL_BLK
    0x80802B60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_10"
    VAL_BLK
    0x80802B64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_11"
    VAL_BLK
    0x80802B68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_13"
    VAL_BLK
    0x80802B6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_14"
    VAL_BLK
    0x80802B70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_2"
    VAL_BLK
    0x80802B74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_22_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_22"
    VAL_BLK
    0x80802B78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_23_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_23"
    VAL_BLK
    0x80802B7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_4"
    VAL_BLK
    0x80802B80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_5"
    VAL_BLK
    0x80802B84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_7"
    VAL_BLK
    0x80802B88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM0_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM0_8"
    VAL_BLK
    0x80802B8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM10_16_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM10_16"
    VAL_BLK
    0x80802B90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM10_17_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM10_17"
    VAL_BLK
    0x80802B94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM10_21_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM10_21"
    VAL_BLK
    0x80802B98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_0"
    VAL_BLK
    0x80802B9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_1"
    VAL_BLK
    0x80802BA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_2"
    VAL_BLK
    0x80802BA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_3"
    VAL_BLK
    0x80802BA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_4"
    VAL_BLK
    0x80802BAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_5"
    VAL_BLK
    0x80802BB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_8"
    VAL_BLK
    0x80802BB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM11_9_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM11_9"
    VAL_BLK
    0x80802BB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_0"
    VAL_BLK
    0x80802BBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_1"
    VAL_BLK
    0x80802BC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_10"
    VAL_BLK
    0x80802BC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_11"
    VAL_BLK
    0x80802BC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_13"
    VAL_BLK
    0x80802BCC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_14"
    VAL_BLK
    0x80802BD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_2"
    VAL_BLK
    0x80802BD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_22_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_22"
    VAL_BLK
    0x80802BD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_23_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_23"
    VAL_BLK
    0x80802BDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_4"
    VAL_BLK
    0x80802BE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_5"
    VAL_BLK
    0x80802BE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_7"
    VAL_BLK
    0x80802BE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM1_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM1_8"
    VAL_BLK
    0x80802BEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM21_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM21_0"
    VAL_BLK
    0x80802BF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM21_16_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM21_16"
    VAL_BLK
    0x80802BF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM21_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM21_3"
    VAL_BLK
    0x80802BF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_1"
    VAL_BLK
    0x80802BFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_10"
    VAL_BLK
    0x80802C00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_11"
    VAL_BLK
    0x80802C04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_13"
    VAL_BLK
    0x80802C08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_14"
    VAL_BLK
    0x80802C0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_2"
    VAL_BLK
    0x80802C10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_22_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_22"
    VAL_BLK
    0x80802C14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_23_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_23"
    VAL_BLK
    0x80802C18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_4"
    VAL_BLK
    0x80802C1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_5"
    VAL_BLK
    0x80802C20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_7"
    VAL_BLK
    0x80802C24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM2_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM2_8"
    VAL_BLK
    0x80802C28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_1"
    VAL_BLK
    0x80802C2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_10"
    VAL_BLK
    0x80802C30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_11"
    VAL_BLK
    0x80802C34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_13"
    VAL_BLK
    0x80802C38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_14"
    VAL_BLK
    0x80802C3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_2"
    VAL_BLK
    0x80802C40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_22_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_22"
    VAL_BLK
    0x80802C44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_23_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_23"
    VAL_BLK
    0x80802C48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_4"
    VAL_BLK
    0x80802C4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_5"
    VAL_BLK
    0x80802C50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_7"
    VAL_BLK
    0x80802C54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM3_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM3_8"
    VAL_BLK
    0x80802C58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_0"
    VAL_BLK
    0x80802C5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_11"
    VAL_BLK
    0x80802C60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_12_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_12"
    VAL_BLK
    0x80802C64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_14"
    VAL_BLK
    0x80802C68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_15_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_15"
    VAL_BLK
    0x80802C6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_17_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_17"
    VAL_BLK
    0x80802C70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_18_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_18"
    VAL_BLK
    0x80802C74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_2"
    VAL_BLK
    0x80802C78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_20_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_20"
    VAL_BLK
    0x80802C7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_21_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_21"
    VAL_BLK
    0x80802C80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_25_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_25"
    VAL_BLK
    0x80802C84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_4"
    VAL_BLK
    0x80802C88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_5"
    VAL_BLK
    0x80802C8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_7"
    VAL_BLK
    0x80802C90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM6_8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM6_8"
    VAL_BLK
    0x80802C94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_1"
    VAL_BLK
    0x80802C98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_12_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_12"
    VAL_BLK
    0x80802C9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_13"
    VAL_BLK
    0x80802CA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_14_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_14"
    VAL_BLK
    0x80802CA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_15_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_15"
    VAL_BLK
    0x80802CA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_16_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_16"
    VAL_BLK
    0x80802CAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_17_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_17"
    VAL_BLK
    0x80802CB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_2"
    VAL_BLK
    0x80802CB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_20_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_20"
    VAL_BLK
    0x80802CB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_25_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_25"
    VAL_BLK
    0x80802CBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_26_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_26"
    VAL_BLK
    0x80802CC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_28_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_28"
    VAL_BLK
    0x80802CC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_29_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_29"
    VAL_BLK
    0x80802CC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_30_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_30"
    VAL_BLK
    0x80802CCC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM7_31_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM7_31"
    VAL_BLK
    0x80802CD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_0"
    VAL_BLK
    0x80802CD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_1"
    VAL_BLK
    0x80802CD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_10_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_10"
    VAL_BLK
    0x80802CDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_11_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_11"
    VAL_BLK
    0x80802CE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_12_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_12"
    VAL_BLK
    0x80802CE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_13_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_13"
    VAL_BLK
    0x80802CE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_16_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_16"
    VAL_BLK
    0x80802CEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_18_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_18"
    VAL_BLK
    0x80802CF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_2"
    VAL_BLK
    0x80802CF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_3"
    VAL_BLK
    0x80802CF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_30_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_30"
    VAL_BLK
    0x80802CFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_31_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_31"
    VAL_BLK
    0x80802D00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM8_4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM8_4"
    VAL_BLK
    0x80802D04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM9_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM9_0"
    VAL_BLK
    0x80802D08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM9_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM9_1"
    VAL_BLK
    0x80802D0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM9_15_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM9_15"
    VAL_BLK
    0x80802D10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MOXEMM_SMU_ALM9_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MOXEMM_SMU_ALM9_3"
    VAL_BLK
    0x80802D14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoCSOPICO_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoCSOPICO"
    VAL_BLK
    0x80802D18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoFVarPostBldSel_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoFVarPostBldSel"
    VAL_BLK
    0x80802D1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoSysCtrlReIni_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoSysCtrlReIni"
    VAL_BLK
    0x80802D20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTMCUFW_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTMCUFW"
    VAL_BLK
    0x80802D24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTMonBIST_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTMonBIST"
    VAL_BLK
    0x80802D28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTRegMonTest_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTRegMonTest"
    VAL_BLK
    0x80802D2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTStbySMUAlvTest_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTStbySMUAlvTest"
    VAL_BLK
    0x80802D30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTTempSens_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTTempSens"
    VAL_BLK
    0x80802D34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_MoXEMMHwLTUCBCfg_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_MoXEMMHwLTUCBCfg"
    VAL_BLK
    0x80802D38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_OCWDAABEActv_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_OCWDAABEActv"
    VAL_BLK
    0x80802D3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_OCWDACom_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_OCWDACom"
    VAL_BLK
    0x80802D40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_OCWDAErrPin_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_OCWDAErrPin"
    VAL_BLK
    0x80802D44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_SWReset_0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_SWReset_0"
    VAL_BLK
    0x80802D48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_SWReset_1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_SWReset_1"
    VAL_BLK
    0x80802D4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_SWReset_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_SWReset_2"
    VAL_BLK
    0x80802D50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_DSMInhibitAlways_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_DSMInhibitAlways"
    VAL_BLK
    0x80802D54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 3 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_ErrLmpActrMIL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_ErrLmpActrMIL"
    VAL_BLK
    0x80802D5A
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_ErrLmpActrSVS_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_ErrLmpActrSVS"
    VAL_BLK
    0x80802D5E
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_StopLmp_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_StopLmp"
    VAL_BLK
    0x80802D62
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_T15TurnOfDly_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_T15TurnOfDly"
    VAL_BLK
    0x80802D66
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DSQ_WrnLmp_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DSQ_WrnLmp"
    VAL_BLK
    0x80802D6A
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80c7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80c7"
    VAL_BLK
    0x80804176
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80c8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80c8"
    VAL_BLK
    0x80804178
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80c9_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80c9"
    VAL_BLK
    0x8080417A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ca_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ca"
    VAL_BLK
    0x8080417C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80cb_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80cb"
    VAL_BLK
    0x8080417E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80cc_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80cc"
    VAL_BLK
    0x80804180
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80cd_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80cd"
    VAL_BLK
    0x80804182
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ce_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ce"
    VAL_BLK
    0x80804184
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80cf_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80cf"
    VAL_BLK
    0x80804186
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80d0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80d0"
    VAL_BLK
    0x80804188
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80d1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80d1"
    VAL_BLK
    0x8080418A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80d2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80d2"
    VAL_BLK
    0x8080418C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80d3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80d3"
    VAL_BLK
    0x8080418E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80d4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80d4"
    VAL_BLK
    0x80804190
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80d5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80d5"
    VAL_BLK
    0x80804192
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80d6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80d6"
    VAL_BLK
    0x80804194
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80d7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80d7"
    VAL_BLK
    0x80804196
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80d8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80d8"
    VAL_BLK
    0x80804198
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80d9_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80d9"
    VAL_BLK
    0x8080419A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80da_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80da"
    VAL_BLK
    0x8080419C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80db_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80db"
    VAL_BLK
    0x8080419E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80dc_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80dc"
    VAL_BLK
    0x808041A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80dd_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80dd"
    VAL_BLK
    0x808041A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80de_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80de"
    VAL_BLK
    0x808041A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80df_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80df"
    VAL_BLK
    0x808041A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80e0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80e0"
    VAL_BLK
    0x808041A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80e1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80e1"
    VAL_BLK
    0x808041AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80e2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80e2"
    VAL_BLK
    0x808041AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80e3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80e3"
    VAL_BLK
    0x808041AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80e4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80e4"
    VAL_BLK
    0x808041B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80e5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80e5"
    VAL_BLK
    0x808041B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80e6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80e6"
    VAL_BLK
    0x808041B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80e7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80e7"
    VAL_BLK
    0x808041B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80e8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80e8"
    VAL_BLK
    0x808041B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80e9_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80e9"
    VAL_BLK
    0x808041BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ea_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ea"
    VAL_BLK
    0x808041BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80eb_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80eb"
    VAL_BLK
    0x808041BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ec_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ec"
    VAL_BLK
    0x808041C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ed_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ed"
    VAL_BLK
    0x808041C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ee_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ee"
    VAL_BLK
    0x808041C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ef_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ef"
    VAL_BLK
    0x808041C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80f0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80f0"
    VAL_BLK
    0x808041C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80f1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80f1"
    VAL_BLK
    0x808041CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80f2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80f2"
    VAL_BLK
    0x808041CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80f3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80f3"
    VAL_BLK
    0x808041CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80f4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80f4"
    VAL_BLK
    0x808041D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80f5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80f5"
    VAL_BLK
    0x808041D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80f6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80f6"
    VAL_BLK
    0x808041D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80f7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80f7"
    VAL_BLK
    0x808041D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80f8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80f8"
    VAL_BLK
    0x808041D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80f9_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80f9"
    VAL_BLK
    0x808041DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80fa_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80fa"
    VAL_BLK
    0x808041DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80fb_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80fb"
    VAL_BLK
    0x808041DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80fc_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80fc"
    VAL_BLK
    0x808041E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80fd_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80fd"
    VAL_BLK
    0x808041E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80fe_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80fe"
    VAL_BLK
    0x808041E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ff_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ff"
    VAL_BLK
    0x808041E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8100_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8100"
    VAL_BLK
    0x808041E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8101_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8101"
    VAL_BLK
    0x808041EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8102_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8102"
    VAL_BLK
    0x808041EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8103_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8103"
    VAL_BLK
    0x808041EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8104_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8104"
    VAL_BLK
    0x808041F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8105_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8105"
    VAL_BLK
    0x808041F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8106_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8106"
    VAL_BLK
    0x808041F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8107_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8107"
    VAL_BLK
    0x808041F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8108_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8108"
    VAL_BLK
    0x808041F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8109_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8109"
    VAL_BLK
    0x808041FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x810a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x810a"
    VAL_BLK
    0x808041FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x810b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x810b"
    VAL_BLK
    0x808041FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x810c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x810c"
    VAL_BLK
    0x80804200
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x810d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x810d"
    VAL_BLK
    0x80804202
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x810e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x810e"
    VAL_BLK
    0x80804204
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x810f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x810f"
    VAL_BLK
    0x80804206
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8110_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8110"
    VAL_BLK
    0x80804208
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8111_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8111"
    VAL_BLK
    0x8080420A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8112_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8112"
    VAL_BLK
    0x8080420C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8113_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8113"
    VAL_BLK
    0x8080420E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8114_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8114"
    VAL_BLK
    0x80804210
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8115_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8115"
    VAL_BLK
    0x80804212
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8116_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8116"
    VAL_BLK
    0x80804214
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8117_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8117"
    VAL_BLK
    0x80804216
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8118_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8118"
    VAL_BLK
    0x80804218
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8119_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8119"
    VAL_BLK
    0x8080421A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x811a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x811a"
    VAL_BLK
    0x8080421C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x811b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x811b"
    VAL_BLK
    0x8080421E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x811c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x811c"
    VAL_BLK
    0x80804220
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x811d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x811d"
    VAL_BLK
    0x80804222
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x811e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x811e"
    VAL_BLK
    0x80804224
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x811f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x811f"
    VAL_BLK
    0x80804226
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8120_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8120"
    VAL_BLK
    0x80804228
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8121_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8121"
    VAL_BLK
    0x8080422A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8122_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8122"
    VAL_BLK
    0x8080422C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8123_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8123"
    VAL_BLK
    0x8080422E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8124_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8124"
    VAL_BLK
    0x80804230
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8125_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8125"
    VAL_BLK
    0x80804232
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8126_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8126"
    VAL_BLK
    0x80804234
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8127_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8127"
    VAL_BLK
    0x80804236
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8128_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8128"
    VAL_BLK
    0x80804238
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8129_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8129"
    VAL_BLK
    0x8080423A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x812a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x812a"
    VAL_BLK
    0x8080423C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_TiInRow0x8B01_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_TiInRow0x8B01"
    VAL_BLK
    0x8080423E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_TiInRow0x8B02_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_TiInRow0x8B02"
    VAL_BLK
    0x80804240
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_TiInRow0x8B03_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_TiInRow0x8B03"
    VAL_BLK
    0x80804242
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_DevLibBattUHi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_DevLibBattUHi"
    VAL_BLK
    0x80804244
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_DevLibBattULo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_DevLibBattULo"
    VAL_BLK
    0x80804246
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8063_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8063"
    VAL_BLK
    0x80804248
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8064_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8064"
    VAL_BLK
    0x8080424A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8065_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8065"
    VAL_BLK
    0x8080424C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8066_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8066"
    VAL_BLK
    0x8080424E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8067_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8067"
    VAL_BLK
    0x80804250
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8068_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8068"
    VAL_BLK
    0x80804252
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8069_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8069"
    VAL_BLK
    0x80804254
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x806a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x806a"
    VAL_BLK
    0x80804256
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x806b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x806b"
    VAL_BLK
    0x80804258
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x806c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x806c"
    VAL_BLK
    0x8080425A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x806d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x806d"
    VAL_BLK
    0x8080425C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x806e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x806e"
    VAL_BLK
    0x8080425E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x806f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x806f"
    VAL_BLK
    0x80804260
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8070_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8070"
    VAL_BLK
    0x80804262
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8071_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8071"
    VAL_BLK
    0x80804264
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8072_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8072"
    VAL_BLK
    0x80804266
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8073_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8073"
    VAL_BLK
    0x80804268
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8074_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8074"
    VAL_BLK
    0x8080426A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8075_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8075"
    VAL_BLK
    0x8080426C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8076_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8076"
    VAL_BLK
    0x8080426E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8077_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8077"
    VAL_BLK
    0x80804270
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8078_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8078"
    VAL_BLK
    0x80804272
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8079_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8079"
    VAL_BLK
    0x80804274
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x807a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x807a"
    VAL_BLK
    0x80804276
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x807b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x807b"
    VAL_BLK
    0x80804278
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x807c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x807c"
    VAL_BLK
    0x8080427A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x807d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x807d"
    VAL_BLK
    0x8080427C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x807e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x807e"
    VAL_BLK
    0x8080427E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x807f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x807f"
    VAL_BLK
    0x80804280
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8080_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8080"
    VAL_BLK
    0x80804282
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8081_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8081"
    VAL_BLK
    0x80804284
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8082_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8082"
    VAL_BLK
    0x80804286
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8083_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8083"
    VAL_BLK
    0x80804288
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8084_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8084"
    VAL_BLK
    0x8080428A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8085_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8085"
    VAL_BLK
    0x8080428C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8086_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8086"
    VAL_BLK
    0x8080428E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8087_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8087"
    VAL_BLK
    0x80804290
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8088_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8088"
    VAL_BLK
    0x80804292
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8089_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8089"
    VAL_BLK
    0x80804294
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x808a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x808a"
    VAL_BLK
    0x80804296
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x808b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x808b"
    VAL_BLK
    0x80804298
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x808c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x808c"
    VAL_BLK
    0x8080429A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x808d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x808d"
    VAL_BLK
    0x8080429C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x808e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x808e"
    VAL_BLK
    0x8080429E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x808f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x808f"
    VAL_BLK
    0x808042A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8090_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8090"
    VAL_BLK
    0x808042A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8091_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8091"
    VAL_BLK
    0x808042A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8092_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8092"
    VAL_BLK
    0x808042A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8093_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8093"
    VAL_BLK
    0x808042A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8094_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8094"
    VAL_BLK
    0x808042AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8095_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8095"
    VAL_BLK
    0x808042AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8096_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8096"
    VAL_BLK
    0x808042AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8097_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8097"
    VAL_BLK
    0x808042B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8098_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8098"
    VAL_BLK
    0x808042B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8099_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8099"
    VAL_BLK
    0x808042B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x809a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x809a"
    VAL_BLK
    0x808042B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x809b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x809b"
    VAL_BLK
    0x808042B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x809c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x809c"
    VAL_BLK
    0x808042BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x809d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x809d"
    VAL_BLK
    0x808042BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x809e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x809e"
    VAL_BLK
    0x808042BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x809f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x809f"
    VAL_BLK
    0x808042C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80a0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80a0"
    VAL_BLK
    0x808042C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80a1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80a1"
    VAL_BLK
    0x808042C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80a2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80a2"
    VAL_BLK
    0x808042C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80a3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80a3"
    VAL_BLK
    0x808042C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80a4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80a4"
    VAL_BLK
    0x808042CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80a5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80a5"
    VAL_BLK
    0x808042CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80a6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80a6"
    VAL_BLK
    0x808042CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80a7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80a7"
    VAL_BLK
    0x808042D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80a8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80a8"
    VAL_BLK
    0x808042D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80a9_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80a9"
    VAL_BLK
    0x808042D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80aa_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80aa"
    VAL_BLK
    0x808042D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ab_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ab"
    VAL_BLK
    0x808042D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ac_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ac"
    VAL_BLK
    0x808042DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ad_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ad"
    VAL_BLK
    0x808042DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ae_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ae"
    VAL_BLK
    0x808042DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80af_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80af"
    VAL_BLK
    0x808042E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80b0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80b0"
    VAL_BLK
    0x808042E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80b1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80b1"
    VAL_BLK
    0x808042E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80b2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80b2"
    VAL_BLK
    0x808042E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80b3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80b3"
    VAL_BLK
    0x808042E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80b4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80b4"
    VAL_BLK
    0x808042EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80b5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80b5"
    VAL_BLK
    0x808042EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80b6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80b6"
    VAL_BLK
    0x808042EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80b7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80b7"
    VAL_BLK
    0x808042F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80b8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80b8"
    VAL_BLK
    0x808042F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80b9_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80b9"
    VAL_BLK
    0x808042F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80ba_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80ba"
    VAL_BLK
    0x808042F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80bb_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80bb"
    VAL_BLK
    0x808042F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80bc_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80bc"
    VAL_BLK
    0x808042FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80bd_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80bd"
    VAL_BLK
    0x808042FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80be_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80be"
    VAL_BLK
    0x808042FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80bf_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80bf"
    VAL_BLK
    0x80804300
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80c0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80c0"
    VAL_BLK
    0x80804302
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80c1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80c1"
    VAL_BLK
    0x80804304
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80c2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80c2"
    VAL_BLK
    0x80804306
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80c3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80c3"
    VAL_BLK
    0x80804308
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80c4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80c4"
    VAL_BLK
    0x8080430A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80c5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80c5"
    VAL_BLK
    0x8080430C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x80c6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x80c6"
    VAL_BLK
    0x8080430E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_TiUpDwn0x8A01_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_TiUpDwn0x8A01"
    VAL_BLK
    0x80804310
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_TiUpDwn0x8A02_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_TiUpDwn0x8A02"
    VAL_BLK
    0x80804312
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_TiUpDwn0x8A03_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_TiUpDwn0x8A03"
    VAL_BLK
    0x80804314
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA13OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA13OR"
    VAL_BLK
    0x80804316
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA13SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA13SCB"
    VAL_BLK
    0x80804318
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA13SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA13SCG"
    VAL_BLK
    0x8080431A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA14OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA14OR"
    VAL_BLK
    0x8080431C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA14SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA14SCB"
    VAL_BLK
    0x8080431E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA14SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA14SCG"
    VAL_BLK
    0x80804320
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA21OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA21OR"
    VAL_BLK
    0x80804322
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA21SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA21SCB"
    VAL_BLK
    0x80804324
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA21SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA21SCG"
    VAL_BLK
    0x80804326
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA22OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA22OR"
    VAL_BLK
    0x80804328
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA22SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA22SCB"
    VAL_BLK
    0x8080432A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA22SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA22SCG"
    VAL_BLK
    0x8080432C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA23OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA23OR"
    VAL_BLK
    0x8080432E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA23SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA23SCB"
    VAL_BLK
    0x80804330
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA23SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA23SCG"
    VAL_BLK
    0x80804332
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA24OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA24OR"
    VAL_BLK
    0x80804334
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA24SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA24SCB"
    VAL_BLK
    0x80804336
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA24SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA24SCG"
    VAL_BLK
    0x80804338
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA25OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA25OR"
    VAL_BLK
    0x8080433A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA25SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA25SCB"
    VAL_BLK
    0x8080433C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA25SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA25SCG"
    VAL_BLK
    0x8080433E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA26OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA26OR"
    VAL_BLK
    0x80804340
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA26SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA26SCB"
    VAL_BLK
    0x80804342
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA26SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA26SCG"
    VAL_BLK
    0x80804344
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA27OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA27OR"
    VAL_BLK
    0x80804346
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA27SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA27SCB"
    VAL_BLK
    0x80804348
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA27SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA27SCG"
    VAL_BLK
    0x8080434A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA28OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA28OR"
    VAL_BLK
    0x8080434C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA28SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA28SCB"
    VAL_BLK
    0x8080434E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA28SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA28SCG"
    VAL_BLK
    0x80804350
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA29OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA29OR"
    VAL_BLK
    0x80804352
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA29SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA29SCB"
    VAL_BLK
    0x80804354
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA29SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA29SCG"
    VAL_BLK
    0x80804356
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36AicSCB"
    VAL_BLK
    0x80804358
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36AicSCG"
    VAL_BLK
    0x8080435A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36OR"
    VAL_BLK
    0x8080435C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36SCB"
    VAL_BLK
    0x8080435E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36SCG"
    VAL_BLK
    0x80804360
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA36ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA36ShuntSCB"
    VAL_BLK
    0x80804362
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37AicSCB"
    VAL_BLK
    0x80804364
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37AicSCG"
    VAL_BLK
    0x80804366
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37OR"
    VAL_BLK
    0x80804368
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37SCB"
    VAL_BLK
    0x8080436A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37SCG"
    VAL_BLK
    0x8080436C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA37ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA37ShuntSCB"
    VAL_BLK
    0x8080436E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38AicSCB"
    VAL_BLK
    0x80804370
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38AicSCG"
    VAL_BLK
    0x80804372
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38OR"
    VAL_BLK
    0x80804374
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38SCB"
    VAL_BLK
    0x80804376
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38SCG"
    VAL_BLK
    0x80804378
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA38ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA38ShuntSCB"
    VAL_BLK
    0x8080437A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39AicSCB"
    VAL_BLK
    0x8080437C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39AicSCG"
    VAL_BLK
    0x8080437E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39OR"
    VAL_BLK
    0x80804380
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39SCB"
    VAL_BLK
    0x80804382
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39SCG"
    VAL_BLK
    0x80804384
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA39ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA39ShuntSCB"
    VAL_BLK
    0x80804386
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA40OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA40OR"
    VAL_BLK
    0x80804388
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA40SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA40SCB"
    VAL_BLK
    0x8080438A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA40SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA40SCG"
    VAL_BLK
    0x8080438C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA41OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA41OR"
    VAL_BLK
    0x8080438E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA41SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA41SCB"
    VAL_BLK
    0x80804390
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA41SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA41SCG"
    VAL_BLK
    0x80804392
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA42OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA42OR"
    VAL_BLK
    0x80804394
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA42SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA42SCB"
    VAL_BLK
    0x80804396
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA42SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA42SCG"
    VAL_BLK
    0x80804398
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43AicSCB"
    VAL_BLK
    0x8080439A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43AicSCG"
    VAL_BLK
    0x8080439C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43OR"
    VAL_BLK
    0x8080439E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43SCB"
    VAL_BLK
    0x808043A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43SCG"
    VAL_BLK
    0x808043A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA43ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA43ShuntSCB"
    VAL_BLK
    0x808043A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA44OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA44OL"
    VAL_BLK
    0x808043A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA44SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA44SCB"
    VAL_BLK
    0x808043A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA44SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA44SCG"
    VAL_BLK
    0x808043AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA57OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA57OR"
    VAL_BLK
    0x808043AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA57SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA57SCB"
    VAL_BLK
    0x808043AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA57SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA57SCG"
    VAL_BLK
    0x808043B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA59OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA59OL"
    VAL_BLK
    0x808043B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA59SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA59SCB"
    VAL_BLK
    0x808043B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inA59SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inA59SCG"
    VAL_BLK
    0x808043B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK10OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK10OR"
    VAL_BLK
    0x808043B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK10SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK10SCB"
    VAL_BLK
    0x808043BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK10SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK10SCG"
    VAL_BLK
    0x808043BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK11OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK11OR"
    VAL_BLK
    0x808043BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK11SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK11SCB"
    VAL_BLK
    0x808043C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK11SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK11SCG"
    VAL_BLK
    0x808043C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30AicSCB"
    VAL_BLK
    0x808043C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30AicSCG"
    VAL_BLK
    0x808043C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30OR"
    VAL_BLK
    0x808043C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30SCB"
    VAL_BLK
    0x808043CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30SCG"
    VAL_BLK
    0x808043CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK30ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK30ShuntSCB"
    VAL_BLK
    0x808043CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK31OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK31OR"
    VAL_BLK
    0x808043D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK31SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK31SCB"
    VAL_BLK
    0x808043D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK31SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK31SCG"
    VAL_BLK
    0x808043D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK32OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK32OR"
    VAL_BLK
    0x808043D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK32SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK32SCB"
    VAL_BLK
    0x808043D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK32SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK32SCG"
    VAL_BLK
    0x808043DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK33OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK33OR"
    VAL_BLK
    0x808043DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK33SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK33SCB"
    VAL_BLK
    0x808043DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK33SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK33SCG"
    VAL_BLK
    0x808043E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK34OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK34OR"
    VAL_BLK
    0x808043E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK34SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK34SCB"
    VAL_BLK
    0x808043E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK34SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK34SCG"
    VAL_BLK
    0x808043E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK35OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK35OR"
    VAL_BLK
    0x808043E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK35SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK35SCB"
    VAL_BLK
    0x808043EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK35SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK35SCG"
    VAL_BLK
    0x808043EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK36OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK36OR"
    VAL_BLK
    0x808043EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK36SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK36SCB"
    VAL_BLK
    0x808043F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK36SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK36SCG"
    VAL_BLK
    0x808043F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37AicSCB"
    VAL_BLK
    0x808043F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37AicSCG"
    VAL_BLK
    0x808043F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37OR"
    VAL_BLK
    0x808043F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37SCB"
    VAL_BLK
    0x808043FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37SCG"
    VAL_BLK
    0x808043FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK37ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK37ShuntSCB"
    VAL_BLK
    0x808043FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38AicSCB"
    VAL_BLK
    0x80804400
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38AicSCG"
    VAL_BLK
    0x80804402
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38OR"
    VAL_BLK
    0x80804404
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38SCB"
    VAL_BLK
    0x80804406
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38SCG"
    VAL_BLK
    0x80804408
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK38ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK38ShuntSCB"
    VAL_BLK
    0x8080440A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39AicSCB"
    VAL_BLK
    0x8080440C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39AicSCG"
    VAL_BLK
    0x8080440E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39OR"
    VAL_BLK
    0x80804410
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39SCB"
    VAL_BLK
    0x80804412
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39SCG"
    VAL_BLK
    0x80804414
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK39ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK39ShuntSCB"
    VAL_BLK
    0x80804416
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40AicSCB"
    VAL_BLK
    0x80804418
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40AicSCG"
    VAL_BLK
    0x8080441A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40OR"
    VAL_BLK
    0x8080441C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40SCB"
    VAL_BLK
    0x8080441E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40SCG"
    VAL_BLK
    0x80804420
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK40ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK40ShuntSCB"
    VAL_BLK
    0x80804422
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41AicSCB"
    VAL_BLK
    0x80804424
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41AicSCG"
    VAL_BLK
    0x80804426
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41OR"
    VAL_BLK
    0x80804428
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41SCB"
    VAL_BLK
    0x8080442A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41SCG"
    VAL_BLK
    0x8080442C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK41ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK41ShuntSCB"
    VAL_BLK
    0x8080442E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42AicSCB"
    VAL_BLK
    0x80804430
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42AicSCG"
    VAL_BLK
    0x80804432
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42OR"
    VAL_BLK
    0x80804434
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42SCB"
    VAL_BLK
    0x80804436
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42SCG"
    VAL_BLK
    0x80804438
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK42ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK42ShuntSCB"
    VAL_BLK
    0x8080443A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK43OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK43OR"
    VAL_BLK
    0x8080443C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK43SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK43SCB"
    VAL_BLK
    0x8080443E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK43SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK43SCG"
    VAL_BLK
    0x80804440
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44AicSCB"
    VAL_BLK
    0x80804442
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44AicSCG"
    VAL_BLK
    0x80804444
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44OR"
    VAL_BLK
    0x80804446
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44SCB"
    VAL_BLK
    0x80804448
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44SCG"
    VAL_BLK
    0x8080444A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK44ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK44ShuntSCB"
    VAL_BLK
    0x8080444C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45AicSCB"
    VAL_BLK
    0x8080444E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45AicSCG"
    VAL_BLK
    0x80804450
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45OR"
    VAL_BLK
    0x80804452
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45SCB"
    VAL_BLK
    0x80804454
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45SCG"
    VAL_BLK
    0x80804456
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK45ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK45ShuntSCB"
    VAL_BLK
    0x80804458
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK52OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK52OR"
    VAL_BLK
    0x8080445A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK52SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK52SCB"
    VAL_BLK
    0x8080445C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK52SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK52SCG"
    VAL_BLK
    0x8080445E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK53OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK53OR"
    VAL_BLK
    0x80804460
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK53SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK53SCB"
    VAL_BLK
    0x80804462
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK53SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK53SCG"
    VAL_BLK
    0x80804464
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54AicSCB"
    VAL_BLK
    0x80804466
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54AicSCG"
    VAL_BLK
    0x80804468
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54OR"
    VAL_BLK
    0x8080446A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54SCB"
    VAL_BLK
    0x8080446C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54SCG"
    VAL_BLK
    0x8080446E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK54ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK54ShuntSCB"
    VAL_BLK
    0x80804470
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55AicSCB"
    VAL_BLK
    0x80804472
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55AicSCG"
    VAL_BLK
    0x80804474
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55OR"
    VAL_BLK
    0x80804476
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55SCB"
    VAL_BLK
    0x80804478
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55SCG"
    VAL_BLK
    0x8080447A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK55ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK55ShuntSCB"
    VAL_BLK
    0x8080447C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK56OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK56OR"
    VAL_BLK
    0x8080447E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK56SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK56SCB"
    VAL_BLK
    0x80804480
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK56SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK56SCG"
    VAL_BLK
    0x80804482
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK57OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK57OR"
    VAL_BLK
    0x80804484
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK57SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK57SCB"
    VAL_BLK
    0x80804486
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK57SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK57SCG"
    VAL_BLK
    0x80804488
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK58OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK58OR"
    VAL_BLK
    0x8080448A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK58SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK58SCB"
    VAL_BLK
    0x8080448C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK58SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK58SCG"
    VAL_BLK
    0x8080448E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK59OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK59OR"
    VAL_BLK
    0x80804490
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK59SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK59SCB"
    VAL_BLK
    0x80804492
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK59SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK59SCG"
    VAL_BLK
    0x80804494
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK60OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK60OR"
    VAL_BLK
    0x80804496
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK60SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK60SCB"
    VAL_BLK
    0x80804498
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK60SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK60SCG"
    VAL_BLK
    0x8080449A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61AicSCB"
    VAL_BLK
    0x8080449C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61AicSCG"
    VAL_BLK
    0x8080449E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61OR"
    VAL_BLK
    0x808044A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61SCB"
    VAL_BLK
    0x808044A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61SCG"
    VAL_BLK
    0x808044A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK61ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK61ShuntSCB"
    VAL_BLK
    0x808044A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK62OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK62OR"
    VAL_BLK
    0x808044A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK62SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK62SCB"
    VAL_BLK
    0x808044AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK62SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK62SCG"
    VAL_BLK
    0x808044AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63AicSCB"
    VAL_BLK
    0x808044AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63AicSCG"
    VAL_BLK
    0x808044B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63OR"
    VAL_BLK
    0x808044B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63SCB"
    VAL_BLK
    0x808044B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63SCG"
    VAL_BLK
    0x808044B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK63ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK63ShuntSCB"
    VAL_BLK
    0x808044B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64AicSCB"
    VAL_BLK
    0x808044BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64AicSCG"
    VAL_BLK
    0x808044BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64OR"
    VAL_BLK
    0x808044BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64SCB"
    VAL_BLK
    0x808044C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64SCG"
    VAL_BLK
    0x808044C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK64ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK64ShuntSCB"
    VAL_BLK
    0x808044C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65AicSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65AicSCB"
    VAL_BLK
    0x808044C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65AicSCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65AicSCG"
    VAL_BLK
    0x808044C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65OR"
    VAL_BLK
    0x808044CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65SCB"
    VAL_BLK
    0x808044CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65SCG"
    VAL_BLK
    0x808044CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK65ShuntSCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK65ShuntSCB"
    VAL_BLK
    0x808044D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK74OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK74OR"
    VAL_BLK
    0x808044D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK74SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK74SCB"
    VAL_BLK
    0x808044D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK74SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK74SCG"
    VAL_BLK
    0x808044D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK75OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK75OR"
    VAL_BLK
    0x808044D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK75SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK75SCB"
    VAL_BLK
    0x808044DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK75SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK75SCG"
    VAL_BLK
    0x808044DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK76OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK76OR"
    VAL_BLK
    0x808044DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK76SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK76SCB"
    VAL_BLK
    0x808044E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK76SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK76SCG"
    VAL_BLK
    0x808044E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK77OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK77OR"
    VAL_BLK
    0x808044E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK77SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK77SCB"
    VAL_BLK
    0x808044E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK77SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK77SCG"
    VAL_BLK
    0x808044E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK78OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK78OR"
    VAL_BLK
    0x808044EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK78SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK78SCB"
    VAL_BLK
    0x808044EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inK78SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inK78SCG"
    VAL_BLK
    0x808044EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_DvUBAT_FWs_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_DvUBAT_FWs"
    VAL_BLK
    0x808044F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OVErr_VPR6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OVErr_VPR6"
    VAL_BLK
    0x808044F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OVWarn_VPR6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OVWarn_VPR6"
    VAL_BLK
    0x808044F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VAL_BLK
    0x808044F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VAL_BLK
    0x808044F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_UBAT_MON_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_UBAT_MON"
    VAL_BLK
    0x808044FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_UBRM24_FLEXIN_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VAL_BLK
    0x808044FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_UBRM24_LOADS_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_UBRM24_LOADS"
    VAL_BLK
    0x808044FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_UBRM24_MON_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_UBRM24_MON"
    VAL_BLK
    0x80804500
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VDD5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VDD5"
    VAL_BLK
    0x80804502
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VDD5_IN_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VDD5_IN"
    VAL_BLK
    0x80804504
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VPR6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VPR6"
    VAL_BLK
    0x80804506
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VSS3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VSS3"
    VAL_BLK
    0x80804508
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VSS4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VSS4"
    VAL_BLK
    0x8080450A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_Temp1_HTErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_Temp1_HTErr"
    VAL_BLK
    0x8080450C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_Temp1_HTWarn_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_Temp1_HTWarn"
    VAL_BLK
    0x8080450E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_Temp2_HTErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_Temp2_HTErr"
    VAL_BLK
    0x80804510
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_Temp2_HTWarn_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_Temp2_HTWarn"
    VAL_BLK
    0x80804512
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VAL_BLK
    0x80804514
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VAL_BLK
    0x80804516
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VDD5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VDD5"
    VAL_BLK
    0x80804518
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VDD5_IN_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VDD5_IN"
    VAL_BLK
    0x8080451A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VPR6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VPR6"
    VAL_BLK
    0x8080451C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VSS3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VSS3"
    VAL_BLK
    0x8080451E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VSS4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VSS4"
    VAL_BLK
    0x80804520
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA01OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA01OL"
    VAL_BLK
    0x80804522
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA01OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA01OT"
    VAL_BLK
    0x80804524
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA01SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA01SCB"
    VAL_BLK
    0x80804526
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA01SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA01SCG"
    VAL_BLK
    0x80804528
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02OL"
    VAL_BLK
    0x8080452A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02OR"
    VAL_BLK
    0x8080452C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02OT"
    VAL_BLK
    0x8080452E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02SCB"
    VAL_BLK
    0x80804530
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02SCG"
    VAL_BLK
    0x80804532
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03OL"
    VAL_BLK
    0x80804534
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03OT"
    VAL_BLK
    0x80804536
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03SCB"
    VAL_BLK
    0x80804538
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03SCG"
    VAL_BLK
    0x8080453A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04OL"
    VAL_BLK
    0x8080453C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04OT"
    VAL_BLK
    0x8080453E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04SCB"
    VAL_BLK
    0x80804540
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04SCG"
    VAL_BLK
    0x80804542
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05OL"
    VAL_BLK
    0x80804544
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05OR"
    VAL_BLK
    0x80804546
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05OT"
    VAL_BLK
    0x80804548
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05SCB"
    VAL_BLK
    0x8080454A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05SCG"
    VAL_BLK
    0x8080454C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA06OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA06OL"
    VAL_BLK
    0x8080454E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA06OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA06OR"
    VAL_BLK
    0x80804550
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA06OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA06OT"
    VAL_BLK
    0x80804552
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA06SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA06SCB"
    VAL_BLK
    0x80804554
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA06SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA06SCG"
    VAL_BLK
    0x80804556
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07OL"
    VAL_BLK
    0x80804558
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07OT"
    VAL_BLK
    0x8080455A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07SCB"
    VAL_BLK
    0x8080455C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07SCG"
    VAL_BLK
    0x8080455E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08OL"
    VAL_BLK
    0x80804560
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08OT"
    VAL_BLK
    0x80804562
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08SCB"
    VAL_BLK
    0x80804564
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08SCG"
    VAL_BLK
    0x80804566
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09OL"
    VAL_BLK
    0x80804568
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09OR"
    VAL_BLK
    0x8080456A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09OT"
    VAL_BLK
    0x8080456C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09SCB"
    VAL_BLK
    0x8080456E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

