    0x80808035
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8124_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8124"
    VALUE
    0x80808036
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8125_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8125"
    VALUE
    0x80808037
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8126_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8126"
    VALUE
    0x80808038
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8127_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8127"
    VALUE
    0x80808039
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8128_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8128"
    VALUE
    0x8080803A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8129_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8129"
    VALUE
    0x8080803B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x812a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x812a"
    VALUE
    0x8080803C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_TiInRow0x8B01_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_TiInRow0x8B01"
    VALUE
    0x8080803D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_TiInRow0x8B02_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_TiInRow0x8B02"
    VALUE
    0x8080803E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_TiInRow0x8B03_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_TiInRow0x8B03"
    VALUE
    0x8080803F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_DevLibBattUHi_C
    "AUTOSAR: Matching DTC group / Check DFC_DevLibBattUHi"
    VALUE
    0x80808040
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_DevLibBattULo_C
    "AUTOSAR: Matching DTC group / Check DFC_DevLibBattULo"
    VALUE
    0x80808041
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8063_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8063"
    VALUE
    0x80808042
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8064_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8064"
    VALUE
    0x80808043
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8065_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8065"
    VALUE
    0x80808044
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8066_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8066"
    VALUE
    0x80808045
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8067_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8067"
    VALUE
    0x80808046
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8068_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8068"
    VALUE
    0x80808047
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8069_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8069"
    VALUE
    0x80808048
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x806a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x806a"
    VALUE
    0x80808049
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x806b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x806b"
    VALUE
    0x8080804A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x806c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x806c"
    VALUE
    0x8080804B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x806d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x806d"
    VALUE
    0x8080804C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x806e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x806e"
    VALUE
    0x8080804D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x806f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x806f"
    VALUE
    0x8080804E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8070_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8070"
    VALUE
    0x8080804F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8071_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8071"
    VALUE
    0x80808050
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8072_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8072"
    VALUE
    0x80808051
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8073_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8073"
    VALUE
    0x80808052
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8074_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8074"
    VALUE
    0x80808053
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8075_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8075"
    VALUE
    0x80808054
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8076_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8076"
    VALUE
    0x80808055
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8077_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8077"
    VALUE
    0x80808056
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8078_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8078"
    VALUE
    0x80808057
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8079_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8079"
    VALUE
    0x80808058
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x807a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x807a"
    VALUE
    0x80808059
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x807b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x807b"
    VALUE
    0x8080805A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x807c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x807c"
    VALUE
    0x8080805B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x807d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x807d"
    VALUE
    0x8080805C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x807e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x807e"
    VALUE
    0x8080805D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x807f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x807f"
    VALUE
    0x8080805E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8080_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8080"
    VALUE
    0x8080805F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8081_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8081"
    VALUE
    0x80808060
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8082_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8082"
    VALUE
    0x80808061
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8083_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8083"
    VALUE
    0x80808062
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8084_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8084"
    VALUE
    0x80808063
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8085_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8085"
    VALUE
    0x80808064
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8086_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8086"
    VALUE
    0x80808065
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8087_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8087"
    VALUE
    0x80808066
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8088_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8088"
    VALUE
    0x80808067
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8089_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8089"
    VALUE
    0x80808068
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x808a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x808a"
    VALUE
    0x80808069
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x808b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x808b"
    VALUE
    0x8080806A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x808c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x808c"
    VALUE
    0x8080806B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x808d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x808d"
    VALUE
    0x8080806C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x808e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x808e"
    VALUE
    0x8080806D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x808f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x808f"
    VALUE
    0x8080806E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8090_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8090"
    VALUE
    0x8080806F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8091_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8091"
    VALUE
    0x80808070
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8092_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8092"
    VALUE
    0x80808071
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8093_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8093"
    VALUE
    0x80808072
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8094_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8094"
    VALUE
    0x80808073
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8095_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8095"
    VALUE
    0x80808074
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8096_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8096"
    VALUE
    0x80808075
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8097_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8097"
    VALUE
    0x80808076
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8098_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8098"
    VALUE
    0x80808077
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8099_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8099"
    VALUE
    0x80808078
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x809a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x809a"
    VALUE
    0x80808079
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x809b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x809b"
    VALUE
    0x8080807A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x809c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x809c"
    VALUE
    0x8080807B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x809d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x809d"
    VALUE
    0x8080807C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x809e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x809e"
    VALUE
    0x8080807D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x809f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x809f"
    VALUE
    0x8080807E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80a0_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80a0"
    VALUE
    0x8080807F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80a1_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80a1"
    VALUE
    0x80808080
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80a2_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80a2"
    VALUE
    0x80808081
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80a3_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80a3"
    VALUE
    0x80808082
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80a4_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80a4"
    VALUE
    0x80808083
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80a5_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80808084
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80a6_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80a6"
    VALUE
    0x80808085
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80a7_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80a7"
    VALUE
    0x80808086
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80a8_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80a8"
    VALUE
    0x80808087
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80a9_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80a9"
    VALUE
    0x80808088
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80aa_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80aa"
    VALUE
    0x80808089
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ab_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ab"
    VALUE
    0x8080808A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ac_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ac"
    VALUE
    0x8080808B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ad_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ad"
    VALUE
    0x8080808C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ae_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ae"
    VALUE
    0x8080808D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80af_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80af"
    VALUE
    0x8080808E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80b0_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80b0"
    VALUE
    0x8080808F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80b1_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80b1"
    VALUE
    0x80808090
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80b2_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80b2"
    VALUE
    0x80808091
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80b3_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80b3"
    VALUE
    0x80808092
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80b4_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80b4"
    VALUE
    0x80808093
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80b5_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80b5"
    VALUE
    0x80808094
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80b6_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80b6"
    VALUE
    0x80808095
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80b7_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80b7"
    VALUE
    0x80808096
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80b8_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80b8"
    VALUE
    0x80808097
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80b9_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80b9"
    VALUE
    0x80808098
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ba_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ba"
    VALUE
    0x80808099
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80bb_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80bb"
    VALUE
    0x8080809A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80bc_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80bc"
    VALUE
    0x8080809B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80bd_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80bd"
    VALUE
    0x8080809C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80be_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80be"
    VALUE
    0x8080809D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80bf_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80bf"
    VALUE
    0x8080809E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80c0_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80c0"
    VALUE
    0x8080809F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80c1_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80c1"
    VALUE
    0x808080A0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80c2_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80c2"
    VALUE
    0x808080A1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80c3_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80c3"
    VALUE
    0x808080A2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80c4_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80c4"
    VALUE
    0x808080A3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80c5_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80c5"
    VALUE
    0x808080A4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80c6_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80c6"
    VALUE
    0x808080A5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_TiUpDwn0x8A01_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x808080A6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_TiUpDwn0x8A02_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x808080A7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_TiUpDwn0x8A03_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x808080A8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA13OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA13OR"
    VALUE
    0x808080A9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA13SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA13SCB"
    VALUE
    0x808080AA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA13SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA13SCG"
    VALUE
    0x808080AB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA14OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA14OR"
    VALUE
    0x808080AC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA14SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA14SCB"
    VALUE
    0x808080AD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA14SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA14SCG"
    VALUE
    0x808080AE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA21OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA21OR"
    VALUE
    0x808080AF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA21SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA21SCB"
    VALUE
    0x808080B0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA21SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA21SCG"
    VALUE
    0x808080B1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA22OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA22OR"
    VALUE
    0x808080B2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA22SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA22SCB"
    VALUE
    0x808080B3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA22SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA22SCG"
    VALUE
    0x808080B4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA23OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA23OR"
    VALUE
    0x808080B5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA23SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA23SCB"
    VALUE
    0x808080B6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA23SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA23SCG"
    VALUE
    0x808080B7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA24OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA24OR"
    VALUE
    0x808080B8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA24SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA24SCB"
    VALUE
    0x808080B9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA24SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA24SCG"
    VALUE
    0x808080BA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA25OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA25OR"
    VALUE
    0x808080BB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA25SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA25SCB"
    VALUE
    0x808080BC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA25SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA25SCG"
    VALUE
    0x808080BD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA26OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA26OR"
    VALUE
    0x808080BE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA26SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA26SCB"
    VALUE
    0x808080BF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA26SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA26SCG"
    VALUE
    0x808080C0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA27OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA27OR"
    VALUE
    0x808080C1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA27SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA27SCB"
    VALUE
    0x808080C2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA27SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA27SCG"
    VALUE
    0x808080C3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA28OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA28OR"
    VALUE
    0x808080C4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA28SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA28SCB"
    VALUE
    0x808080C5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA28SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA28SCG"
    VALUE
    0x808080C6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA29OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA29OR"
    VALUE
    0x808080C7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA29SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA29SCB"
    VALUE
    0x808080C8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA29SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA29SCG"
    VALUE
    0x808080C9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36AicSCB"
    VALUE
    0x808080CA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36AicSCG"
    VALUE
    0x808080CB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36OR"
    VALUE
    0x808080CC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36SCB"
    VALUE
    0x808080CD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36SCG"
    VALUE
    0x808080CE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA36ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x808080CF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37AicSCB"
    VALUE
    0x808080D0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37AicSCG"
    VALUE
    0x808080D1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37OR"
    VALUE
    0x808080D2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37SCB"
    VALUE
    0x808080D3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37SCG"
    VALUE
    0x808080D4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA37ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x808080D5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38AicSCB"
    VALUE
    0x808080D6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38AicSCG"
    VALUE
    0x808080D7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38OR"
    VALUE
    0x808080D8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38SCB"
    VALUE
    0x808080D9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38SCG"
    VALUE
    0x808080DA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA38ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x808080DB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39AicSCB"
    VALUE
    0x808080DC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39AicSCG"
    VALUE
    0x808080DD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39OR"
    VALUE
    0x808080DE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39SCB"
    VALUE
    0x808080DF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39SCG"
    VALUE
    0x808080E0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA39ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x808080E1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA40OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA40OR"
    VALUE
    0x808080E2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA40SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA40SCB"
    VALUE
    0x808080E3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA40SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA40SCG"
    VALUE
    0x808080E4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA41OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA41OR"
    VALUE
    0x808080E5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA41SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA41SCB"
    VALUE
    0x808080E6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA41SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA41SCG"
    VALUE
    0x808080E7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA42OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA42OR"
    VALUE
    0x808080E8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA42SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA42SCB"
    VALUE
    0x808080E9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA42SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA42SCG"
    VALUE
    0x808080EA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43AicSCB"
    VALUE
    0x808080EB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43AicSCG"
    VALUE
    0x808080EC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43OR"
    VALUE
    0x808080ED
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43SCB"
    VALUE
    0x808080EE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43SCG"
    VALUE
    0x808080EF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA43ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x808080F0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA44OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA44OL"
    VALUE
    0x808080F1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA44SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA44SCB"
    VALUE
    0x808080F2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA44SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA44SCG"
    VALUE
    0x808080F3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA57OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA57OR"
    VALUE
    0x808080F4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA57SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA57SCB"
    VALUE
    0x808080F5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA57SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA57SCG"
    VALUE
    0x808080F6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA59OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA59OL"
    VALUE
    0x808080F7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA59SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA59SCB"
    VALUE
    0x808080F8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inA59SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inA59SCG"
    VALUE
    0x808080F9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK10OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK10OR"
    VALUE
    0x808080FA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK10SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK10SCB"
    VALUE
    0x808080FB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK10SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK10SCG"
    VALUE
    0x808080FC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK11OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK11OR"
    VALUE
    0x808080FD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK11SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK11SCB"
    VALUE
    0x808080FE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK11SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK11SCG"
    VALUE
    0x808080FF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30AicSCB"
    VALUE
    0x80808100
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30AicSCG"
    VALUE
    0x80808101
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30OR"
    VALUE
    0x80808102
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30SCB"
    VALUE
    0x80808103
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30SCG"
    VALUE
    0x80808104
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK30ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80808105
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK31OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK31OR"
    VALUE
    0x80808106
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK31SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK31SCB"
    VALUE
    0x80808107
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK31SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK31SCG"
    VALUE
    0x80808108
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK32OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK32OR"
    VALUE
    0x80808109
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK32SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK32SCB"
    VALUE
    0x8080810A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK32SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK32SCG"
    VALUE
    0x8080810B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK33OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK33OR"
    VALUE
    0x8080810C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK33SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK33SCB"
    VALUE
    0x8080810D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK33SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK33SCG"
    VALUE
    0x8080810E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK34OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK34OR"
    VALUE
    0x8080810F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK34SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK34SCB"
    VALUE
    0x80808110
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK34SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK34SCG"
    VALUE
    0x80808111
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK35OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK35OR"
    VALUE
    0x80808112
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK35SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK35SCB"
    VALUE
    0x80808113
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK35SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK35SCG"
    VALUE
    0x80808114
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK36OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK36OR"
    VALUE
    0x80808115
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK36SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK36SCB"
    VALUE
    0x80808116
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK36SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK36SCG"
    VALUE
    0x80808117
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37AicSCB"
    VALUE
    0x80808118
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37AicSCG"
    VALUE
    0x80808119
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37OR"
    VALUE
    0x8080811A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37SCB"
    VALUE
    0x8080811B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37SCG"
    VALUE
    0x8080811C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK37ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x8080811D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38AicSCB"
    VALUE
    0x8080811E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38AicSCG"
    VALUE
    0x8080811F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38OR"
    VALUE
    0x80808120
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38SCB"
    VALUE
    0x80808121
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38SCG"
    VALUE
    0x80808122
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK38ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80808123
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39AicSCB"
    VALUE
    0x80808124
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39AicSCG"
    VALUE
    0x80808125
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39OR"
    VALUE
    0x80808126
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39SCB"
    VALUE
    0x80808127
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39SCG"
    VALUE
    0x80808128
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK39ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80808129
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40AicSCB"
    VALUE
    0x8080812A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40AicSCG"
    VALUE
    0x8080812B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40OR"
    VALUE
    0x8080812C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40SCB"
    VALUE
    0x8080812D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40SCG"
    VALUE
    0x8080812E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK40ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x8080812F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41AicSCB"
    VALUE
    0x80808130
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41AicSCG"
    VALUE
    0x80808131
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41OR"
    VALUE
    0x80808132
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41SCB"
    VALUE
    0x80808133
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41SCG"
    VALUE
    0x80808134
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK41ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80808135
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42AicSCB"
    VALUE
    0x80808136
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42AicSCG"
    VALUE
    0x80808137
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42OR"
    VALUE
    0x80808138
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42SCB"
    VALUE
    0x80808139
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42SCG"
    VALUE
    0x8080813A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK42ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x8080813B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK43OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK43OR"
    VALUE
    0x8080813C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK43SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK43SCB"
    VALUE
    0x8080813D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK43SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK43SCG"
    VALUE
    0x8080813E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44AicSCB"
    VALUE
    0x8080813F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44AicSCG"
    VALUE
    0x80808140
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44OR"
    VALUE
    0x80808141
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44SCB"
    VALUE
    0x80808142
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44SCG"
    VALUE
    0x80808143
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK44ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80808144
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45AicSCB"
    VALUE
    0x80808145
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45AicSCG"
    VALUE
    0x80808146
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45OR"
    VALUE
    0x80808147
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45SCB"
    VALUE
    0x80808148
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45SCG"
    VALUE
    0x80808149
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK45ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x8080814A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK52OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK52OR"
    VALUE
    0x8080814B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK52SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK52SCB"
    VALUE
    0x8080814C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK52SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK52SCG"
    VALUE
    0x8080814D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK53OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK53OR"
    VALUE
    0x8080814E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK53SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK53SCB"
    VALUE
    0x8080814F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK53SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK53SCG"
    VALUE
    0x80808150
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54AicSCB"
    VALUE
    0x80808151
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54AicSCG"
    VALUE
    0x80808152
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54OR"
    VALUE
    0x80808153
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54SCB"
    VALUE
    0x80808154
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54SCG"
    VALUE
    0x80808155
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK54ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80808156
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55AicSCB"
    VALUE
    0x80808157
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55AicSCG"
    VALUE
    0x80808158
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55OR"
    VALUE
    0x80808159
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55SCB"
    VALUE
    0x8080815A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55SCG"
    VALUE
    0x8080815B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK55ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x8080815C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK56OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK56OR"
    VALUE
    0x8080815D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK56SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK56SCB"
    VALUE
    0x8080815E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK56SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK56SCG"
    VALUE
    0x8080815F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK57OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK57OR"
    VALUE
    0x80808160
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK57SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK57SCB"
    VALUE
    0x80808161
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK57SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK57SCG"
    VALUE
    0x80808162
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK58OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK58OR"
    VALUE
    0x80808163
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK58SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK58SCB"
    VALUE
    0x80808164
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK58SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK58SCG"
    VALUE
    0x80808165
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK59OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK59OR"
    VALUE
    0x80808166
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK59SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK59SCB"
    VALUE
    0x80808167
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK59SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK59SCG"
    VALUE
    0x80808168
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK60OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK60OR"
    VALUE
    0x80808169
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK60SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK60SCB"
    VALUE
    0x8080816A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK60SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK60SCG"
    VALUE
    0x8080816B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61AicSCB"
    VALUE
    0x8080816C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61AicSCG"
    VALUE
    0x8080816D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61OR"
    VALUE
    0x8080816E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61SCB"
    VALUE
    0x8080816F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61SCG"
    VALUE
    0x80808170
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK61ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80808171
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK62OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK62OR"
    VALUE
    0x80808172
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK62SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK62SCB"
    VALUE
    0x80808173
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK62SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK62SCG"
    VALUE
    0x80808174
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63AicSCB"
    VALUE
    0x80808175
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63AicSCG"
    VALUE
    0x80808176
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63OR"
    VALUE
    0x80808177
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63SCB"
    VALUE
    0x80808178
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63SCG"
    VALUE
    0x80808179
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK63ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x8080817A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64AicSCB"
    VALUE
    0x8080817B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64AicSCG"
    VALUE
    0x8080817C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64OR"
    VALUE
    0x8080817D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64SCB"
    VALUE
    0x8080817E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64SCG"
    VALUE
    0x8080817F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK64ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80808180
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65AicSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65AicSCB"
    VALUE
    0x80808181
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65AicSCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65AicSCG"
    VALUE
    0x80808182
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65OR"
    VALUE
    0x80808183
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65SCB"
    VALUE
    0x80808184
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65SCG"
    VALUE
    0x80808185
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK65ShuntSCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80808186
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK74OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK74OR"
    VALUE
    0x80808187
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK74SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK74SCB"
    VALUE
    0x80808188
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK74SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK74SCG"
    VALUE
    0x80808189
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK75OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK75OR"
    VALUE
    0x8080818A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK75SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK75SCB"
    VALUE
    0x8080818B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK75SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK75SCG"
    VALUE
    0x8080818C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK76OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK76OR"
    VALUE
    0x8080818D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK76SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK76SCB"
    VALUE
    0x8080818E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK76SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK76SCG"
    VALUE
    0x8080818F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK77OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK77OR"
    VALUE
    0x80808190
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK77SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK77SCB"
    VALUE
    0x80808191
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK77SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK77SCG"
    VALUE
    0x80808192
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK78OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK78OR"
    VALUE
    0x80808193
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK78SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK78SCB"
    VALUE
    0x80808194
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inK78SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inK78SCG"
    VALUE
    0x80808195
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_DvUBAT_FWs_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80808196
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OVErr_VPR6_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80808197
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OVWarn_VPR6_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80808198
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80808199
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x8080819A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_UBAT_MON_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x8080819B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x8080819C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x8080819D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_UBRM24_MON_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x8080819E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VDD5_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x8080819F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VDD5_IN_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x808081A0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VPR6_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x808081A1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VSS3_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x808081A2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VSS4_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x808081A3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_Temp1_HTErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x808081A4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_Temp1_HTWarn_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x808081A5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_Temp2_HTErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x808081A6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_Temp2_HTWarn_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x808081A7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808081A8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x808081A9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VDD5_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x808081AA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VDD5_IN_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x808081AB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VPR6_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x808081AC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VSS3_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x808081AD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VSS4_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x808081AE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA01OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA01OL"
    VALUE
    0x808081AF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA01OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA01OT"
    VALUE
    0x808081B0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA01SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA01SCB"
    VALUE
    0x808081B1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA01SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA01SCG"
    VALUE
    0x808081B2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02OL"
    VALUE
    0x808081B3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02OR"
    VALUE
    0x808081B4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02OT"
    VALUE
    0x808081B5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02SCB"
    VALUE
    0x808081B6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02SCG"
    VALUE
    0x808081B7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03OL"
    VALUE
    0x808081B8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03OT"
    VALUE
    0x808081B9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03SCB"
    VALUE
    0x808081BA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03SCG"
    VALUE
    0x808081BB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04OL"
    VALUE
    0x808081BC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04OT"
    VALUE
    0x808081BD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04SCB"
    VALUE
    0x808081BE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04SCG"
    VALUE
    0x808081BF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05OL"
    VALUE
    0x808081C0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05OR"
    VALUE
    0x808081C1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05OT"
    VALUE
    0x808081C2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05SCB"
    VALUE
    0x808081C3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05SCG"
    VALUE
    0x808081C4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA06OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA06OL"
    VALUE
    0x808081C5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA06OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA06OR"
    VALUE
    0x808081C6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA06OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA06OT"
    VALUE
    0x808081C7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA06SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA06SCB"
    VALUE
    0x808081C8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA06SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA06SCG"
    VALUE
    0x808081C9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07OL"
    VALUE
    0x808081CA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07OT"
    VALUE
    0x808081CB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07SCB"
    VALUE
    0x808081CC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07SCG"
    VALUE
    0x808081CD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08OL"
    VALUE
    0x808081CE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08OT"
    VALUE
    0x808081CF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08SCB"
    VALUE
    0x808081D0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08SCG"
    VALUE
    0x808081D1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09OL"
    VALUE
    0x808081D2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09OR"
    VALUE
    0x808081D3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09OT"
    VALUE
    0x808081D4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09SCB"
    VALUE
    0x808081D5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09SCG"
    VALUE
    0x808081D6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10OL"
    VALUE
    0x808081D7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10OT"
    VALUE
    0x808081D8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10SCB"
    VALUE
    0x808081D9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10SCG"
    VALUE
    0x808081DA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA11OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA11OL"
    VALUE
    0x808081DB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA11OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA11OT"
    VALUE
    0x808081DC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA11SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA11SCB"
    VALUE
    0x808081DD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA11SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA11SCG"
    VALUE
    0x808081DE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA12OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA12OR"
    VALUE
    0x808081DF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA12SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA12SCB"
    VALUE
    0x808081E0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA12SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA12SCG"
    VALUE
    0x808081E1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA16OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA16OL"
    VALUE
    0x808081E2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA16OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA16OT"
    VALUE
    0x808081E3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA16SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA16SCB"
    VALUE
    0x808081E4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA16SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA16SCG"
    VALUE
    0x808081E5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17OL"
    VALUE
    0x808081E6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17OR"
    VALUE
    0x808081E7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17OT"
    VALUE
    0x808081E8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17SCB"
    VALUE
    0x808081E9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17SCG"
    VALUE
    0x808081EA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18OL"
    VALUE
    0x808081EB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18OT"
    VALUE
    0x808081EC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18SCB"
    VALUE
    0x808081ED
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18SCG"
    VALUE
    0x808081EE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19OL"
    VALUE
    0x808081EF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19OR"
    VALUE
    0x808081F0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19OT"
    VALUE
    0x808081F1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19SCB"
    VALUE
    0x808081F2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19SCG"
    VALUE
    0x808081F3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20OL"
    VALUE
    0x808081F4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20OR"
    VALUE
    0x808081F5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20OT"
    VALUE
    0x808081F6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20SCB"
    VALUE
    0x808081F7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20SCG"
    VALUE
    0x808081F8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31OL"
    VALUE
    0x808081F9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31OR"
    VALUE
    0x808081FA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31OT"
    VALUE
    0x808081FB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31SCB"
    VALUE
    0x808081FC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31SCG"
    VALUE
    0x808081FD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32OL"
    VALUE
    0x808081FE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32OR"
    VALUE
    0x808081FF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32OT"
    VALUE
    0x80808200
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32SCB"
    VALUE
    0x80808201
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32SCG"
    VALUE
    0x80808202
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33OL"
    VALUE
    0x80808203
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33OR"
    VALUE
    0x80808204
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33OT"
    VALUE
    0x80808205
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33SCB"
    VALUE
    0x80808206
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33SCG"
    VALUE
    0x80808207
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34OL"
    VALUE
    0x80808208
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34OR"
    VALUE
    0x80808209
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34OT"
    VALUE
    0x8080820A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34SCB"
    VALUE
    0x8080820B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34SCG"
    VALUE
    0x8080820C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35OL"
    VALUE
    0x8080820D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35OR"
    VALUE
    0x8080820E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35OT"
    VALUE
    0x8080820F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35SCB"
    VALUE
    0x80808210
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35SCG"
    VALUE
    0x80808211
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46OL"
    VALUE
    0x80808212
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46OR"
    VALUE
    0x80808213
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46OT"
    VALUE
    0x80808214
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46SCB"
    VALUE
    0x80808215
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46SCG"
    VALUE
    0x80808216
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47OL"
    VALUE
    0x80808217
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47OR"
    VALUE
    0x80808218
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47OT"
    VALUE
    0x80808219
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47SCB"
    VALUE
    0x8080821A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47SCG"
    VALUE
    0x8080821B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48OL"
    VALUE
    0x8080821C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48OR"
    VALUE
    0x8080821D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48OT"
    VALUE
    0x8080821E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48SCB"
    VALUE
    0x8080821F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48SCG"
    VALUE
    0x80808220
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA49OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA49OL"
    VALUE
    0x80808221
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA49OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA49OT"
    VALUE
    0x80808222
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA49SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA49SCB"
    VALUE
    0x80808223
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA49SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA49SCG"
    VALUE
    0x80808224
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA50OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA50OL"
    VALUE
    0x80808225
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA50OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA50OT"
    VALUE
    0x80808226
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA50SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA50SCB"
    VALUE
    0x80808227
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA50SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA50SCG"
    VALUE
    0x80808228
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51OL"
    VALUE
    0x80808229
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51OR"
    VALUE
    0x8080822A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51OT"
    VALUE
    0x8080822B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51SCB"
    VALUE
    0x8080822C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51SCG"
    VALUE
    0x8080822D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52OL"
    VALUE
    0x8080822E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52OR"
    VALUE
    0x8080822F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52OT"
    VALUE
    0x80808230
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52SCB"
    VALUE
    0x80808231
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52SCG"
    VALUE
    0x80808232
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53OL"
    VALUE
    0x80808233
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53OR"
    VALUE
    0x80808234
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53OT"
    VALUE
    0x80808235
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53SCB"
    VALUE
    0x80808236
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53SCG"
    VALUE
    0x80808237
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54OL"
    VALUE
    0x80808238
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54OR"
    VALUE
    0x80808239
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54OT"
    VALUE
    0x8080823A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54SCB"
    VALUE
    0x8080823B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54SCG"
    VALUE
    0x8080823C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA55OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA55OL"
    VALUE
    0x8080823D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA55OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA55OT"
    VALUE
    0x8080823E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA55SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA55SCB"
    VALUE
    0x8080823F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA55SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA55SCG"
    VALUE
    0x80808240
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA56OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA56OL"
    VALUE
    0x80808241
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA56OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA56OT"
    VALUE
    0x80808242
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA56SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA56SCB"
    VALUE
    0x80808243
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA56SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA56SCG"
    VALUE
    0x80808244
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA58OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA58OL"
    VALUE
    0x80808245
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA58OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA58OT"
    VALUE
    0x80808246
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA58SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA58SCB"
    VALUE
    0x80808247
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA58SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA58SCG"
    VALUE
    0x80808248
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07OL"
    VALUE
    0x80808249
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07OR"
    VALUE
    0x8080824A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07OT"
    VALUE
    0x8080824B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07SCB"
    VALUE
    0x8080824C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07SCG"
    VALUE
    0x8080824D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08OL"
    VALUE
    0x8080824E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08OR"
    VALUE
    0x8080824F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08OT"
    VALUE
    0x80808250
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08SCB"
    VALUE
    0x80808251
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08SCG"
    VALUE
    0x80808252
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09OL"
    VALUE
    0x80808253
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09OR"
    VALUE
    0x80808254
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09OT"
    VALUE
    0x80808255
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09SCB"
    VALUE
    0x80808256
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09SCG"
    VALUE
    0x80808257
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12OL"
    VALUE
    0x80808258
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12OT"
    VALUE
    0x80808259
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12SCB"
    VALUE
    0x8080825A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12SCG"
    VALUE
    0x8080825B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13OL"
    VALUE
    0x8080825C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13OT"
    VALUE
    0x8080825D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13SCB"
    VALUE
    0x8080825E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13SCG"
    VALUE
    0x8080825F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14OL"
    VALUE
    0x80808260
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14OR"
    VALUE
    0x80808261
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14OT"
    VALUE
    0x80808262
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14SCB"
    VALUE
    0x80808263
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14SCG"
    VALUE
    0x80808264
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15OL"
    VALUE
    0x80808265
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15OR"
    VALUE
    0x80808266
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15OT"
    VALUE
    0x80808267
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15SCB"
    VALUE
    0x80808268
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15SCG"
    VALUE
    0x80808269
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16OL"
    VALUE
    0x8080826A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16OR"
    VALUE
    0x8080826B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16OT"
    VALUE
    0x8080826C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16SCB"
    VALUE
    0x8080826D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16SCG"
    VALUE
    0x8080826E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17OL"
    VALUE
    0x8080826F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17OR"
    VALUE
    0x80808270
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17OT"
    VALUE
    0x80808271
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17SCB"
    VALUE
    0x80808272
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17SCG"
    VALUE
    0x80808273
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK25OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK25OR"
    VALUE
    0x80808274
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK25SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK25SCB"
    VALUE
    0x80808275
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK25SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK25SCG"
    VALUE
    0x80808276
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29OL"
    VALUE
    0x80808277
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29OR"
    VALUE
    0x80808278
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29OT"
    VALUE
    0x80808279
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29SCB"
    VALUE
    0x8080827A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29SCG"
    VALUE
    0x8080827B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51OL"
    VALUE
    0x8080827C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51OT"
    VALUE
    0x8080827D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51SCB"
    VALUE
    0x8080827E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51SCG"
    VALUE
    0x8080827F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK62OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK62OR"
    VALUE
    0x80808280
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK62SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK62SCB"
    VALUE
    0x80808281
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK62SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK62SCG"
    VALUE
    0x80808282
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73OL"
    VALUE
    0x80808283
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73OR"
    VALUE
    0x80808284
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73OT"
    VALUE
    0x80808285
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73SCB"
    VALUE
    0x80808286
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73SCG"
    VALUE
    0x80808287
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK80OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK80OL"
    VALUE
    0x80808288
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK80OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK80OT"
    VALUE
    0x80808289
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK80SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK80SCB"
    VALUE
    0x8080828A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK80SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK80SCG"
    VALUE
    0x8080828B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK81OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK81OL"
    VALUE
    0x8080828C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK81OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK81OT"
    VALUE
    0x8080828D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK81SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK81SCB"
    VALUE
    0x8080828E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK81SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK81SCG"
    VALUE
    0x8080828F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK82OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK82OL"
    VALUE
    0x80808290
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK82OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK82OT"
    VALUE
    0x80808291
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK82SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK82SCB"
    VALUE
    0x80808292
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK82SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK82SCG"
    VALUE
    0x80808293
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK83OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK83OL"
    VALUE
    0x80808294
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK83OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK83OT"
    VALUE
    0x80808295
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK83SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK83SCB"
    VALUE
    0x80808296
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK83SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK83SCG"
    VALUE
    0x80808297
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK84OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK84OL"
    VALUE
    0x80808298
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK84OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK84OT"
    VALUE
    0x80808299
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK84SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK84SCB"
    VALUE
    0x8080829A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK84SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK84SCG"
    VALUE
    0x8080829B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK85OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK85OL"
    VALUE
    0x8080829C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK85OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK85OT"
    VALUE
    0x8080829D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK85SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK85SCB"
    VALUE
    0x8080829E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK85SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK85SCG"
    VALUE
    0x8080829F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK86OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK86OL"
    VALUE
    0x808082A0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK86OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK86OT"
    VALUE
    0x808082A1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK86SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK86SCB"
    VALUE
    0x808082A2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK86SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK86SCG"
    VALUE
    0x808082A3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK87OL_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK87OL"
    VALUE
    0x808082A4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK87OT_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK87OT"
    VALUE
    0x808082A5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK87SCB_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK87SCB"
    VALUE
    0x808082A6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK87SCG_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK87SCG"
    VALUE
    0x808082A7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_DSMDummy_C
    "AUTOSAR: Matching DTC group / Check DFC_DSMDummy"
    VALUE
    0x808082A8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8000_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8000"
    VALUE
    0x808082A9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8001_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8001"
    VALUE
    0x808082AA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8002_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8002"
    VALUE
    0x808082AB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8003_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8003"
    VALUE
    0x808082AC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8004_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8004"
    VALUE
    0x808082AD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8005_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8005"
    VALUE
    0x808082AE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8006_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8006"
    VALUE
    0x808082AF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8007_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8007"
    VALUE
    0x808082B0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8008_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8008"
    VALUE
    0x808082B1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8009_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8009"
    VALUE
    0x808082B2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x800a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x800a"
    VALUE
    0x808082B3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x800b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x800b"
    VALUE
    0x808082B4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x800c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x800c"
    VALUE
    0x808082B5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x800d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x800d"
    VALUE
    0x808082B6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x800e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x800e"
    VALUE
    0x808082B7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x800f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x800f"
    VALUE
    0x808082B8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8010_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8010"
    VALUE
    0x808082B9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8011_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8011"
    VALUE
    0x808082BA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8012_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8012"
    VALUE
    0x808082BB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8013_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8013"
    VALUE
    0x808082BC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8014_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8014"
    VALUE
    0x808082BD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8015_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8015"
    VALUE
    0x808082BE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8016_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8016"
    VALUE
    0x808082BF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8017_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8017"
    VALUE
    0x808082C0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8018_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8018"
    VALUE
    0x808082C1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8019_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8019"
    VALUE
    0x808082C2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x801a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x801a"
    VALUE
    0x808082C3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x801b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x801b"
    VALUE
    0x808082C4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x801c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x801c"
    VALUE
    0x808082C5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x801d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x801d"
    VALUE
    0x808082C6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x801e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x801e"
    VALUE
    0x808082C7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x801f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x801f"
    VALUE
    0x808082C8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8020_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8020"
    VALUE
    0x808082C9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8021_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8021"
    VALUE
    0x808082CA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8022_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8022"
    VALUE
    0x808082CB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8023_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8023"
    VALUE
    0x808082CC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8024_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8024"
    VALUE
    0x808082CD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8025_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8025"
    VALUE
    0x808082CE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8026_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8026"
    VALUE
    0x808082CF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8027_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8027"
    VALUE
    0x808082D0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8028_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8028"
    VALUE
    0x808082D1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8029_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8029"
    VALUE
    0x808082D2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x802a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x802a"
    VALUE
    0x808082D3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x802b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x802b"
    VALUE
    0x808082D4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x802c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x802c"
    VALUE
    0x808082D5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x802d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x802d"
    VALUE
    0x808082D6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x802e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x802e"
    VALUE
    0x808082D7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x802f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x802f"
    VALUE
    0x808082D8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8030_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8030"
    VALUE
    0x808082D9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8031_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8031"
    VALUE
    0x808082DA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8032_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8032"
    VALUE
    0x808082DB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8033_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8033"
    VALUE
    0x808082DC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8034_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8034"
    VALUE
    0x808082DD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8035_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8035"
    VALUE
    0x808082DE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8036_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8036"
    VALUE
    0x808082DF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8037_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8037"
    VALUE
    0x808082E0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8038_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8038"
    VALUE
    0x808082E1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8039_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8039"
    VALUE
    0x808082E2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x803a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x803a"
    VALUE
    0x808082E3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x803b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x803b"
    VALUE
    0x808082E4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x803c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x803c"
    VALUE
    0x808082E5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x803d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x803d"
    VALUE
    0x808082E6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x803e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x803e"
    VALUE
    0x808082E7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x803f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x803f"
    VALUE
    0x808082E8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8040_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8040"
    VALUE
    0x808082E9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8041_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8041"
    VALUE
    0x808082EA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8042_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8042"
    VALUE
    0x808082EB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8043_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8043"
    VALUE
    0x808082EC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8044_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8044"
    VALUE
    0x808082ED
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8045_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8045"
    VALUE
    0x808082EE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8046_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8046"
    VALUE
    0x808082EF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8047_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8047"
    VALUE
    0x808082F0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8048_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8048"
    VALUE
    0x808082F1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8049_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8049"
    VALUE
    0x808082F2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x804a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x804a"
    VALUE
    0x808082F3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x804b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x804b"
    VALUE
    0x808082F4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x804c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x804c"
    VALUE
    0x808082F5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x804d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x804d"
    VALUE
    0x808082F6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x804e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x804e"
    VALUE
    0x808082F7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x804f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x804f"
    VALUE
    0x808082F8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8050_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8050"
    VALUE
    0x808082F9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8051_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8051"
    VALUE
    0x808082FA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8052_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8052"
    VALUE
    0x808082FB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8053_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8053"
    VALUE
    0x808082FC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8054_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8054"
    VALUE
    0x808082FD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8055_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8055"
    VALUE
    0x808082FE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8056_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8056"
    VALUE
    0x808082FF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8057_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8057"
    VALUE
    0x80808300
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8058_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8058"
    VALUE
    0x80808301
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8059_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8059"
    VALUE
    0x80808302
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x805a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x805a"
    VALUE
    0x80808303
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x805b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x805b"
    VALUE
    0x80808304
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x805c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x805c"
    VALUE
    0x80808305
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x805d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x805d"
    VALUE
    0x80808306
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x805e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x805e"
    VALUE
    0x80808307
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x805f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x805f"
    VALUE
    0x80808308
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8060_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8060"
    VALUE
    0x80808309
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8061_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8061"
    VALUE
    0x8080830A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8062_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8062"
    VALUE
    0x8080830B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8C01_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8C01"
    VALUE
    0x8080830C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8C02_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8C02"
    VALUE
    0x8080830D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8C03_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8C03"
    VALUE
    0x8080830E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetDataNoBuf_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x8080830F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetDataParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetDataParam"
    VALUE
    0x80808310
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetDataboxNoInit_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80808311
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80808312
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetRxBufStatusParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80808313
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetStatusParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetStatusParam"
    VALUE
    0x80808314
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canGetTxBufStatusParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80808315
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canInitParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canInitParam"
    VALUE
    0x80808316
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canInitRxDataboxOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80808317
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canInitRxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80808318
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canInitTxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80808319
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canIpduGroupControl_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canIpduGroupControl"
    VALUE
    0x8080831A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canIsDataboxFreeNoInit_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x8080831B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canIsDataboxFreeParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x8080831C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canIsTxEmptyParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x8080831D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegBusOffCallbInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x8080831E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegBusOffCallbParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x8080831F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxBufInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80808320
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxBufOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80808321
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxBufParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80808322
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxCallbInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80808323
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxCallbParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80808324
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxDataboxInvNumb_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80808325
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxDataboxInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80808326
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxDataboxOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80808327
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegRxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80808328
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxBufInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80808329
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxBufOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x8080832A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxBufParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxBufParam"
    VALUE
    0x8080832B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxDataboxInvNumb_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x8080832C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxDataboxInvState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x8080832D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxDataboxOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x8080832E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canRegTxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x8080832F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canResetTxBufParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80808330
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canSendDataBufOvfl_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80808331
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canSendDataParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canSendDataParam"
    VALUE
    0x80808332
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canSendDataboxNoInit_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80808333
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canSendDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80808334
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canSetTxCycleParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80808335
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canStartParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canStartParam"
    VALUE
    0x80808336
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_canStopParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_canStopParam"
    VALUE
    0x80808337
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_can_ClearIpduGroup_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80808338
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_can_ReceiveSignal_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80808339
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_can_SendSignal_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_can_SendSignal"
    VALUE
    0x8080833A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_can_SetIpduGroup_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x8080833B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmDTCJ1939_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x8080833C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmDelDTCJ1939_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x8080833D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmDelErrors_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmDelErrors"
    VALUE
    0x8080833E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmGetDFES_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmGetDFES"
    VALUE
    0x8080833F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmGetDTCJ1939_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80808340
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmGetErrors_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmGetErrors"
    VALUE
    0x80808341
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmGetNumErrors_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80808342
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmInitQueueOverflow_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80808343
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmNumDTCJ1939_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80808344
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmTesterror_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmTesterror"
    VALUE
    0x80808345
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmUpdateDebError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80808346
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmUpdateError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmUpdateError"
    VALUE
    0x80808347
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmgetDFCStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80808348
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_dsmtestErrorDFC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80808349
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAi_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAi"
    VALUE
    0x8080834A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAic_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAic"
    VALUE
    0x8080834B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAicCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAicCfg"
    VALUE
    0x8080834C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAicGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAicGetStatus"
    VALUE
    0x8080834D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAid_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAid"
    VALUE
    0x8080834E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAidCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAidCfg"
    VALUE
    0x8080834F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAiv_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAiv"
    VALUE
    0x80808350
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAivCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAivCfg"
    VALUE
    0x80808351
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inAivGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inAivGetStatus"
    VALUE
    0x80808352
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inDi_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inDi"
    VALUE
    0x80808353
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inFi_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inFi"
    VALUE
    0x80808354
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inFiCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inFiCfg"
    VALUE
    0x80808355
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inFiGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inFiGetStatus"
    VALUE
    0x80808356
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inFi_Buffered_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inFi_Buffered"
    VALUE
    0x80808357
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inPhase_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inPhase"
    VALUE
    0x80808358
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inPhaseGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80808359
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inPhaseResetCounter_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x8080835A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inRi_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inRi"
    VALUE
    0x8080835B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inRiCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inRiCfg"
    VALUE
    0x8080835C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inRiCfgTemp_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inRiCfgTemp"
    VALUE
    0x8080835D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inRiGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inRiGetStatus"
    VALUE
    0x8080835E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inRiGetTemp_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inRiGetTemp"
    VALUE
    0x8080835F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentCopyFDFifo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80808360
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentDisable_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentDisable"
    VALUE
    0x80808361
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentEnable_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentEnable"
    VALUE
    0x80808362
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentGetErrorStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80808363
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentGetFD_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentGetFD"
    VALUE
    0x80808364
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentGetSD_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentGetSD"
    VALUE
    0x80808365
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentGetSDDatabox_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80808366
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentGetStatus"
    VALUE
    0x80808367
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentInitSDDatabox_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80808368
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentRegisterCopyFDFifo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80808369
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentRegisterFDFifo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x8080836A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_inSentRegisterSDDataboxes_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x8080836B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusCanRxBufferOverflow_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x8080836C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusGetCaAddrParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x8080836D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusGetDiagnosticParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x8080836E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x8080836F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusGetStatusParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80808370
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitCommCaMissing_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80808371
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitCommParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80808372
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitCommState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitCommState"
    VALUE
    0x80808373
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitDiagnosticParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80808374
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitFailureListParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80808375
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitRxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80808376
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusInitTxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80808377
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegRxDataboxOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80808378
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegRxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80808379
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegRxDataboxState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x8080837A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegTxDataboxOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x8080837B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegTxDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x8080837C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegTxDataboxState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x8080837D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x8080837E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegisterInstancesOverlap_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x8080837F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegisterInstancesParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80808380
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusRegisterInstancesState_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80808381
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSendDataboxParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80808382
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSendRequestPGNParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80808383
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaAddrCaUsed_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80808384
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaAddrComm_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80808385
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaAddrInvCan_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80808386
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaAddrParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80808387
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaInfoParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80808388
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSetCaNameParam_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80808389
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_isobusSftyCanTxErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x8080838A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_ReceiveSignal_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x8080838B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_SendSignal_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_SendSignal"
    VALUE
    0x8080838C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_getStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_getStatus"
    VALUE
    0x8080838D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_gotoSleep_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_gotoSleep"
    VALUE
    0x8080838E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_scheduleRequest_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x8080838F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_lin_wakeUp_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_lin_wakeUp"
    VALUE
    0x80808390
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memFlsCfgShr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80808391
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memGetStatus"
    VALUE
    0x80808392
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memMarkBlock_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memMarkBlock"
    VALUE
    0x80808393
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadApi1Error_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadApi1Error"
    VALUE
    0x80808394
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadApi2Error_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadApi2Error"
    VALUE
    0x80808395
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadBlock_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadBlock"
    VALUE
    0x80808396
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadCalibInputError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80808397
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadCalibOuputError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80808398
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memReadSystemError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memReadSystemError"
    VALUE
    0x80808399
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_memWriteBlock_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_memWriteBlock"
    VALUE
    0x8080839A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_moOV_FirstConstADC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x8080839B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_moOV_SecondConstADC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x8080839C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_moUV_FirstConstADC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x8080839D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_moUV_SecondConstADC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x8080839E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_INH_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_INH"
    VALUE
    0x8080839F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_INHLatch_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_INHLatch"
    VALUE
    0x808083A0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_adcPDD_fail_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x808083A1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_memoryProtection_err_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x808083A2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02OC"
    VALUE
    0x808083A3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA02Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA02Unintended"
    VALUE
    0x808083A4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03OC"
    VALUE
    0x808083A5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA03Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA03Unintended"
    VALUE
    0x808083A6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04OC"
    VALUE
    0x808083A7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA04Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA04Unintended"
    VALUE
    0x808083A8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05OC"
    VALUE
    0x808083A9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA05Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA05Unintended"
    VALUE
    0x808083AA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07OC"
    VALUE
    0x808083AB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA07Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA07Unintended"
    VALUE
    0x808083AC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08OC"
    VALUE
    0x808083AD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA08Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA08Unintended"
    VALUE
    0x808083AE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09OC"
    VALUE
    0x808083AF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA09Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA09Unintended"
    VALUE
    0x808083B0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10OC"
    VALUE
    0x808083B1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA10Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA10Unintended"
    VALUE
    0x808083B2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17OC"
    VALUE
    0x808083B3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA17Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA17Unintended"
    VALUE
    0x808083B4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18OC"
    VALUE
    0x808083B5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA18Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA18Unintended"
    VALUE
    0x808083B6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19OC"
    VALUE
    0x808083B7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA19Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA19Unintended"
    VALUE
    0x808083B8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20OC"
    VALUE
    0x808083B9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA20Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA20Unintended"
    VALUE
    0x808083BA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31OC"
    VALUE
    0x808083BB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA31Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA31Unintended"
    VALUE
    0x808083BC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32OC"
    VALUE
    0x808083BD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA32Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA32Unintended"
    VALUE
    0x808083BE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33OC"
    VALUE
    0x808083BF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA33Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA33Unintended"
    VALUE
    0x808083C0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34OC"
    VALUE
    0x808083C1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA34Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA34Unintended"
    VALUE
    0x808083C2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35OC"
    VALUE
    0x808083C3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA35Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA35Unintended"
    VALUE
    0x808083C4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46OC"
    VALUE
    0x808083C5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA46Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA46Unintended"
    VALUE
    0x808083C6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47OC"
    VALUE
    0x808083C7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA47Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA47Unintended"
    VALUE
    0x808083C8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48OC"
    VALUE
    0x808083C9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA48Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA48Unintended"
    VALUE
    0x808083CA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51OC"
    VALUE
    0x808083CB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA51Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA51Unintended"
    VALUE
    0x808083CC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52OC"
    VALUE
    0x808083CD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA52Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA52Unintended"
    VALUE
    0x808083CE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53OC"
    VALUE
    0x808083CF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA53Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA53Unintended"
    VALUE
    0x808083D0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54OC"
    VALUE
    0x808083D1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outA54Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outA54Unintended"
    VALUE
    0x808083D2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAov_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAov"
    VALUE
    0x808083D3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAovCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAovCfg"
    VALUE
    0x808083D4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAovCfgPI_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAovCfgPI"
    VALUE
    0x808083D5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAovGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAovGetStatus"
    VALUE
    0x808083D6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAovGetVoltage_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAovGetVoltage"
    VALUE
    0x808083D7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outAovResetError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outAovResetError"
    VALUE
    0x808083D8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDo"
    VALUE
    0x808083D9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDoCfgPwrLs_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x808083DA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDoDisable_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDoDisable"
    VALUE
    0x808083DB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDoGetCurrent_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDoGetCurrent"
    VALUE
    0x808083DC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDoGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDoGetStatus"
    VALUE
    0x808083DD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outDoResetError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outDoResetError"
    VALUE
    0x808083DE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07OC"
    VALUE
    0x808083DF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK07Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK07Unintended"
    VALUE
    0x808083E0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08OC"
    VALUE
    0x808083E1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK08Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK08Unintended"
    VALUE
    0x808083E2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09OC"
    VALUE
    0x808083E3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK09Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK09Unintended"
    VALUE
    0x808083E4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12OC"
    VALUE
    0x808083E5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK12Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK12Unintended"
    VALUE
    0x808083E6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13OC"
    VALUE
    0x808083E7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK13Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK13Unintended"
    VALUE
    0x808083E8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14OC"
    VALUE
    0x808083E9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK14Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK14Unintended"
    VALUE
    0x808083EA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15OC"
    VALUE
    0x808083EB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK15Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK15Unintended"
    VALUE
    0x808083EC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16OC"
    VALUE
    0x808083ED
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK16Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK16Unintended"
    VALUE
    0x808083EE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17OC"
    VALUE
    0x808083EF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK17Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK17Unintended"
    VALUE
    0x808083F0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29OC"
    VALUE
    0x808083F1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK29Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK29Unintended"
    VALUE
    0x808083F2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51OC"
    VALUE
    0x808083F3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK51Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK51Unintended"
    VALUE
    0x808083F4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73OC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73OC"
    VALUE
    0x808083F5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outK73Unintended_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outK73Unintended"
    VALUE
    0x808083F6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPo"
    VALUE
    0x808083F7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoCfg"
    VALUE
    0x808083F8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoCfgPeriod_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x808083F9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoCfgPwrLs_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x808083FA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoDisable_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoDisable"
    VALUE
    0x808083FB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoGetCurrent_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoGetCurrent"
    VALUE
    0x808083FC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoGetStatus"
    VALUE
    0x808083FD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoResetError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoResetError"
    VALUE
    0x808083FE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPoc_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPoc"
    VALUE
    0x808083FF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPocCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPocCfg"
    VALUE
    0x80808400
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPocCfgDither_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPocCfgDither"
    VALUE
    0x80808401
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPocCfgPI_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPocCfgPI"
    VALUE
    0x80808402
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPod_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPod"
    VALUE
    0x80808403
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPodCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPodCfg"
    VALUE
    0x80808404
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_outPodCfgPeriod_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80808405
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_rsmFfiApiCallErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80808406
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safout_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safout"
    VALUE
    0x80808407
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutCfg"
    VALUE
    0x80808408
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl1_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl1"
    VALUE
    0x80808409
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl10_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl10"
    VALUE
    0x8080840A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl10Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x8080840B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl10OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl10OR"
    VALUE
    0x8080840C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl11_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl11"
    VALUE
    0x8080840D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl11Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x8080840E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl11OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl11OR"
    VALUE
    0x8080840F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl12_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl12"
    VALUE
    0x80808410
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl12Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80808411
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl12OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80808412
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl13_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl13"
    VALUE
    0x80808413
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl13Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80808414
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl13OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80808415
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl14_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl14"
    VALUE
    0x80808416
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl14Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80808417
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl14OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80808418
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl15_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl15"
    VALUE
    0x80808419
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl15Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x8080841A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl15OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl15OR"
    VALUE
    0x8080841B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl16_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl16"
    VALUE
    0x8080841C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl16Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x8080841D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl16OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl16OR"
    VALUE
    0x8080841E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl17_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl17"
    VALUE
    0x8080841F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl17Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80808420
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl17OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80808421
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl18_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl18"
    VALUE
    0x80808422
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl18Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80808423
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl18OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80808424
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl1Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80808425
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl1OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80808426
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl2_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl2"
    VALUE
    0x80808427
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl2Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80808428
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl2OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80808429
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl3_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl3"
    VALUE
    0x8080842A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl3Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x8080842B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl3OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl3OR"
    VALUE
    0x8080842C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl4_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl4"
    VALUE
    0x8080842D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl4Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x8080842E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl4OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl4OR"
    VALUE
    0x8080842F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl5_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl5"
    VALUE
    0x80808430
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl5Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80808431
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl5OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80808432
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl6_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl6"
    VALUE
    0x80808433
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl6Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80808434
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl6OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80808435
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl7_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl7"
    VALUE
    0x80808436
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl7Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80808437
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl7OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80808438
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl8_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl8"
    VALUE
    0x80808439
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl8Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x8080843A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl8OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl8OR"
    VALUE
    0x8080843B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl9_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl9"
    VALUE
    0x8080843C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl9Dev_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x8080843D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutChnl9OR_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutChnl9OR"
    VALUE
    0x8080843E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutDevError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutDevError"
    VALUE
    0x8080843F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutGetStatus_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutGetStatus"
    VALUE
    0x80808440
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutIgnoreError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80808441
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutResetError_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutResetError"
    VALUE
    0x80808442
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safoutUnlock_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safoutUnlock"
    VALUE
    0x80808443
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_safout_cfgDiag_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80808444
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secAccessDenied_RC_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80808445
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secAccessDenied_WDBI_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80808446
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secEvalRespKey_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secEvalRespKey"
    VALUE
    0x80808447
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secFlashingFailure_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secFlashingFailure"
    VALUE
    0x80808448
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secGetLevel_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secGetLevel"
    VALUE
    0x80808449
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secGetRnd_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secGetRnd"
    VALUE
    0x8080844A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secGetSeed_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secGetSeed"
    VALUE
    0x8080844B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secInvalidPassword_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secInvalidPassword"
    VALUE
    0x8080844C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secIsRequestAllowed_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x8080844D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secResetLevel_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secResetLevel"
    VALUE
    0x8080844E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secSaveSecret_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secSaveSecret"
    VALUE
    0x8080844F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_secSetLevel_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_secSetLevel"
    VALUE
    0x80808450
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysAit_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysAit"
    VALUE
    0x80808451
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysAiv_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysAiv"
    VALUE
    0x80808452
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysDi_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysDi"
    VALUE
    0x80808453
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysDo_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysDo"
    VALUE
    0x80808454
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysGetVss_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysGetVss"
    VALUE
    0x80808455
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysInit_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysInit"
    VALUE
    0x80808456
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysOperHrIntegrityErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80808457
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysOperHrsSaturated_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80808458
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sysSetVss_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sysSetVss"
    VALUE
    0x80808459
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sys_coreload_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sys_coreload"
    VALUE
    0x8080845A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_sys_taskload_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_sys_taskload"
    VALUE
    0x8080845B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VSS1_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x8080845C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_OV_VSS2_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x8080845D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VSS1_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x8080845E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rbr_mo_UV_VSS2_C
    "AUTOSAR: Matching DTC group / Check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x8080845F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "AUTOSAR: Matching DTC group / Check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80808460
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "AUTOSAR: Matching DTC group / Check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80808461
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "AUTOSAR: Matching DTC group / Check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80808462
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "AUTOSAR: Matching DTC group / Check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80808463
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "AUTOSAR: Matching DTC group / Check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80808464
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_CAN_E_TIMEOUT_C
    "AUTOSAR: Matching DTC group / Check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80808465
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80808466
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80808467
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80808468
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80808469
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x8080846A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "AUTOSAR: Matching DTC group / Check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x8080846B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_LIN_E_TIMEOUT_C
    "AUTOSAR: Matching DTC group / Check DFC_LIN_E_TIMEOUT"
    VALUE
    0x8080846C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_MultiStackTrace_Threshold_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x8080846D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_ETH_E_ACCESS_0_C
    "AUTOSAR: Matching DTC group / Check DFC_ETH_E_ACCESS_0"
    VALUE
    0x8080846E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "AUTOSAR: Matching DTC group / Check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x8080846F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "AUTOSAR: Matching DTC group / Check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80808470
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_MRly_Diag_Stk_Event_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80808471
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80808472
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_MemDiag_MemReadErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80808473
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_MemDiag_MemWrErr_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80808474
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80808475
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_T15_Diag_ComInVld_Event_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80808476
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80808477
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "AUTOSAR: Matching DTC group / Check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80808478
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80808479
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x8080847A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_10_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x8080847B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x8080847C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x8080847D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x8080847E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x8080847F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_22_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80808480
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_23_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80808481
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80808482
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80808483
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_7_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80808484
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM0_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80808485
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM10_16_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80808486
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM10_17_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80808487
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM10_21_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80808488
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80808489
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x8080848A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x8080848B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_3_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x8080848C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x8080848D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x8080848E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x8080848F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM11_9_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80808490
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80808491
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80808492
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_10_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80808493
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80808494
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80808495
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80808496
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80808497
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_22_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80808498
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_23_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80808499
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x8080849A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x8080849B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_7_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x8080849C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM1_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x8080849D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM21_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x8080849E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM21_16_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x8080849F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM21_3_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x808084A0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x808084A1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_10_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x808084A2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x808084A3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x808084A4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x808084A5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x808084A6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_22_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x808084A7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_23_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x808084A8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x808084A9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x808084AA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_7_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x808084AB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM2_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x808084AC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x808084AD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_10_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x808084AE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x808084AF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x808084B0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x808084B1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x808084B2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_22_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x808084B3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_23_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x808084B4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x808084B5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x808084B6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_7_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x808084B7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM3_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x808084B8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x808084B9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x808084BA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_12_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x808084BB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x808084BC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_15_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x808084BD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_17_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x808084BE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_18_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x808084BF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x808084C0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_20_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x808084C1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_21_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x808084C2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_25_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x808084C3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x808084C4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_5_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x808084C5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_7_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x808084C6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM6_8_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x808084C7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x808084C8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_12_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x808084C9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x808084CA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_14_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x808084CB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_15_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x808084CC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_16_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x808084CD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_17_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x808084CE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x808084CF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_20_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x808084D0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_25_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x808084D1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_26_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x808084D2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_28_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x808084D3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_29_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x808084D4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_30_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x808084D5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM7_31_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x808084D6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x808084D7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x808084D8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_10_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x808084D9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_11_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x808084DA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_12_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x808084DB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_13_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x808084DC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_16_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x808084DD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_18_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x808084DE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_2_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x808084DF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_3_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x808084E0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_30_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x808084E1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_31_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x808084E2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM8_4_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x808084E3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM9_0_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x808084E4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM9_1_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x808084E5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM9_15_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x808084E6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MOXEMM_SMU_ALM9_3_C
    "AUTOSAR: Matching DTC group / Check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x808084E7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoCSOPICO_C
    "AUTOSAR: Matching DTC group / Check DFC_MoCSOPICO"
    VALUE
    0x808084E8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoFVarPostBldSel_C
    "AUTOSAR: Matching DTC group / Check DFC_MoFVarPostBldSel"
    VALUE
    0x808084E9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoSysCtrlReIni_C
    "AUTOSAR: Matching DTC group / Check DFC_MoSysCtrlReIni"
    VALUE
    0x808084EA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTMCUFW_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x808084EB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTMonBIST_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x808084EC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTRegMonTest_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x808084ED
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x808084EE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTTempSens_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x808084EF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_MoXEMMHwLTUCBCfg_C
    "AUTOSAR: Matching DTC group / Check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x808084F0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_OCWDAABEActv_C
    "AUTOSAR: Matching DTC group / Check DFC_OCWDAABEActv"
    VALUE
    0x808084F1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_OCWDACom_C
    "AUTOSAR: Matching DTC group / Check DFC_OCWDACom"
    VALUE
    0x808084F2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_OCWDAErrPin_C
    "AUTOSAR: Matching DTC group / Check DFC_OCWDAErrPin"
    VALUE
    0x808084F3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_SWReset_0_C
    "AUTOSAR: Matching DTC group / Check DFC_SWReset_0"
    VALUE
    0x808084F4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_SWReset_1_C
    "AUTOSAR: Matching DTC group / Check DFC_SWReset_1"
    VALUE
    0x808084F5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_SWReset_2_C
    "AUTOSAR: Matching DTC group / Check DFC_SWReset_2"
    VALUE
    0x808084F6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_Unused_C
    "AUTOSAR: DTC severity class / Check DFC_Unused"
    VALUE
    0x80808A54
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80c7_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80808A55
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80c8_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80c8"
    VALUE
    0x80808A56
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80c9_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80c9"
    VALUE
    0x80808A57
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ca_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ca"
    VALUE
    0x80808A58
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80cb_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80cb"
    VALUE
    0x80808A59
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80cc_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80cc"
    VALUE
    0x80808A5A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80cd_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80cd"
    VALUE
    0x80808A5B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ce_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ce"
    VALUE
    0x80808A5C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80cf_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80cf"
    VALUE
    0x80808A5D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80d0_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80d0"
    VALUE
    0x80808A5E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80d1_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80d1"
    VALUE
    0x80808A5F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80d2_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80808A60
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80d3_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80808A61
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80d4_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80808A62
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80d5_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80808A63
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80d6_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80808A64
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80d7_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80d7"
    VALUE
    0x80808A65
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80d8_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80d8"
    VALUE
    0x80808A66
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80d9_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80d9"
    VALUE
    0x80808A67
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80da_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80da"
    VALUE
    0x80808A68
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80db_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80db"
    VALUE
    0x80808A69
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80dc_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80dc"
    VALUE
    0x80808A6A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80dd_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80dd"
    VALUE
    0x80808A6B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80de_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80de"
    VALUE
    0x80808A6C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80df_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80df"
    VALUE
    0x80808A6D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80e0_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80e0"
    VALUE
    0x80808A6E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80e1_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80e1"
    VALUE
    0x80808A6F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80e2_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80808A70
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80e3_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80808A71
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80e4_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80808A72
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80e5_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80808A73
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80e6_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80808A74
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80e7_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80e7"
    VALUE
    0x80808A75
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80e8_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80e8"
    VALUE
    0x80808A76
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80e9_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80e9"
    VALUE
    0x80808A77
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ea_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ea"
    VALUE
    0x80808A78
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80eb_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80eb"
    VALUE
    0x80808A79
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ec_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ec"
    VALUE
    0x80808A7A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ed_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ed"
    VALUE
    0x80808A7B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ee_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ee"
    VALUE
    0x80808A7C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ef_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ef"
    VALUE
    0x80808A7D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80f0_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80f0"
    VALUE
    0x80808A7E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80f1_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80f1"
    VALUE
    0x80808A7F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80f2_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80808A80
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80f3_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80808A81
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80f4_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80808A82
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80f5_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80808A83
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80f6_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80f6"
    VALUE
    0x80808A84
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80f7_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80f7"
    VALUE
    0x80808A85
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80f8_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80f8"
    VALUE
    0x80808A86
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80f9_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80f9"
    VALUE
    0x80808A87
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80fa_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80fa"
    VALUE
    0x80808A88
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80fb_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80fb"
    VALUE
    0x80808A89
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80fc_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80fc"
    VALUE
    0x80808A8A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80fd_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80fd"
    VALUE
    0x80808A8B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80fe_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80fe"
    VALUE
    0x80808A8C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ff_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ff"
    VALUE
    0x80808A8D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8100_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8100"
    VALUE
    0x80808A8E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8101_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8101"
    VALUE
    0x80808A8F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8102_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8102"
    VALUE
    0x80808A90
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8103_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8103"
    VALUE
    0x80808A91
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8104_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8104"
    VALUE
    0x80808A92
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8105_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8105"
    VALUE
    0x80808A93
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8106_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8106"
    VALUE
    0x80808A94
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8107_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8107"
    VALUE
    0x80808A95
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8108_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8108"
    VALUE
    0x80808A96
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8109_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8109"
    VALUE
    0x80808A97
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x810a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x810a"
    VALUE
    0x80808A98
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x810b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x810b"
    VALUE
    0x80808A99
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x810c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x810c"
    VALUE
    0x80808A9A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x810d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x810d"
    VALUE
    0x80808A9B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x810e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x810e"
    VALUE
    0x80808A9C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x810f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x810f"
    VALUE
    0x80808A9D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8110_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8110"
    VALUE
    0x80808A9E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8111_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8111"
    VALUE
    0x80808A9F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8112_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8112"
    VALUE
    0x80808AA0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8113_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8113"
    VALUE
    0x80808AA1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8114_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8114"
    VALUE
    0x80808AA2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8115_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8115"
    VALUE
    0x80808AA3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8116_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8116"
    VALUE
    0x80808AA4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8117_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8117"
    VALUE
    0x80808AA5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8118_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8118"
    VALUE
    0x80808AA6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8119_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8119"
    VALUE
    0x80808AA7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x811a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x811a"
    VALUE
    0x80808AA8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x811b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x811b"
    VALUE
    0x80808AA9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x811c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x811c"
    VALUE
    0x80808AAA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x811d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x811d"
    VALUE
    0x80808AAB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x811e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x811e"
    VALUE
    0x80808AAC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x811f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x811f"
    VALUE
    0x80808AAD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8120_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8120"
    VALUE
    0x80808AAE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8121_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8121"
    VALUE
    0x80808AAF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8122_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8122"
    VALUE
    0x80808AB0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8123_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8123"
    VALUE
    0x80808AB1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8124_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8124"
    VALUE
    0x80808AB2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8125_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8125"
    VALUE
    0x80808AB3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8126_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8126"
    VALUE
    0x80808AB4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8127_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8127"
    VALUE
    0x80808AB5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8128_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8128"
    VALUE
    0x80808AB6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8129_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8129"
    VALUE
    0x80808AB7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x812a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x812a"
    VALUE
    0x80808AB8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_TiInRow0x8B01_C
    "AUTOSAR: DTC severity class / Check DFC_bds_TiInRow0x8B01"
    VALUE
    0x80808AB9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_TiInRow0x8B02_C
    "AUTOSAR: DTC severity class / Check DFC_bds_TiInRow0x8B02"
    VALUE
    0x80808ABA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_TiInRow0x8B03_C
    "AUTOSAR: DTC severity class / Check DFC_bds_TiInRow0x8B03"
    VALUE
    0x80808ABB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_DevLibBattUHi_C
    "AUTOSAR: DTC severity class / Check DFC_DevLibBattUHi"
    VALUE
    0x80808ABC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_DevLibBattULo_C
    "AUTOSAR: DTC severity class / Check DFC_DevLibBattULo"
    VALUE
    0x80808ABD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8063_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8063"
    VALUE
    0x80808ABE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8064_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8064"
    VALUE
    0x80808ABF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8065_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8065"
    VALUE
    0x80808AC0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8066_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8066"
    VALUE
    0x80808AC1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8067_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8067"
    VALUE
    0x80808AC2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8068_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8068"
    VALUE
    0x80808AC3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8069_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8069"
    VALUE
    0x80808AC4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x806a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x806a"
    VALUE
    0x80808AC5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x806b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x806b"
    VALUE
    0x80808AC6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x806c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x806c"
    VALUE
    0x80808AC7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x806d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x806d"
    VALUE
    0x80808AC8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x806e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x806e"
    VALUE
    0x80808AC9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x806f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x806f"
    VALUE
    0x80808ACA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8070_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8070"
    VALUE
    0x80808ACB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8071_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8071"
    VALUE
    0x80808ACC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8072_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8072"
    VALUE
    0x80808ACD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8073_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8073"
    VALUE
    0x80808ACE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8074_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8074"
    VALUE
    0x80808ACF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8075_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8075"
    VALUE
    0x80808AD0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8076_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8076"
    VALUE
    0x80808AD1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8077_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8077"
    VALUE
    0x80808AD2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8078_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8078"
    VALUE
    0x80808AD3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8079_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8079"
    VALUE
    0x80808AD4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x807a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x807a"
    VALUE
    0x80808AD5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x807b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x807b"
    VALUE
    0x80808AD6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x807c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x807c"
    VALUE
    0x80808AD7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x807d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x807d"
    VALUE
    0x80808AD8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x807e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x807e"
    VALUE
    0x80808AD9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x807f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x807f"
    VALUE
    0x80808ADA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8080_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8080"
    VALUE
    0x80808ADB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8081_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8081"
    VALUE
    0x80808ADC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8082_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8082"
    VALUE
    0x80808ADD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8083_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8083"
    VALUE
    0x80808ADE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8084_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8084"
    VALUE
    0x80808ADF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8085_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8085"
    VALUE
    0x80808AE0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8086_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8086"
    VALUE
    0x80808AE1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8087_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8087"
    VALUE
    0x80808AE2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8088_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8088"
    VALUE
    0x80808AE3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8089_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8089"
    VALUE
    0x80808AE4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x808a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x808a"
    VALUE
    0x80808AE5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x808b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x808b"
    VALUE
    0x80808AE6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x808c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x808c"
    VALUE
    0x80808AE7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x808d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x808d"
    VALUE
    0x80808AE8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x808e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x808e"
    VALUE
    0x80808AE9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x808f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x808f"
    VALUE
    0x80808AEA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8090_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8090"
    VALUE
    0x80808AEB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8091_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8091"
    VALUE
    0x80808AEC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8092_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8092"
    VALUE
    0x80808AED
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8093_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8093"
    VALUE
    0x80808AEE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8094_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8094"
    VALUE
    0x80808AEF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8095_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8095"
    VALUE
    0x80808AF0
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8096_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8096"
    VALUE
    0x80808AF1
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8097_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8097"
    VALUE
    0x80808AF2
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8098_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8098"
    VALUE
    0x80808AF3
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x8099_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x8099"
    VALUE
    0x80808AF4
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x809a_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x809a"
    VALUE
    0x80808AF5
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x809b_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x809b"
    VALUE
    0x80808AF6
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x809c_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x809c"
    VALUE
    0x80808AF7
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x809d_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x809d"
    VALUE
    0x80808AF8
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x809e_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x809e"
    VALUE
    0x80808AF9
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x809f_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x809f"
    VALUE
    0x80808AFA
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80a0_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80a0"
    VALUE
    0x80808AFB
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80a1_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80a1"
    VALUE
    0x80808AFC
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80a2_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80a2"
    VALUE
    0x80808AFD
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80a3_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80a3"
    VALUE
    0x80808AFE
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80a4_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80a4"
    VALUE
    0x80808AFF
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80a5_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80808B00
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80a6_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80a6"
    VALUE
    0x80808B01
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80a7_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80a7"
    VALUE
    0x80808B02
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80a8_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80a8"
    VALUE
    0x80808B03
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80a9_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80a9"
    VALUE
    0x80808B04
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80aa_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80aa"
    VALUE
    0x80808B05
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ab_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ab"
    VALUE
    0x80808B06
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ac_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ac"
    VALUE
    0x80808B07
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ad_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ad"
    VALUE
    0x80808B08
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ae_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ae"
    VALUE
    0x80808B09
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80af_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80af"
    VALUE
    0x80808B0A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80b0_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80b0"
    VALUE
    0x80808B0B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80b1_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80b1"
    VALUE
    0x80808B0C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80b2_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80b2"
    VALUE
    0x80808B0D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80b3_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80b3"
    VALUE
    0x80808B0E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80b4_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80b4"
    VALUE
    0x80808B0F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80b5_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80b5"
    VALUE
    0x80808B10
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80b6_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80b6"
    VALUE
    0x80808B11
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80b7_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80b7"
    VALUE
    0x80808B12
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80b8_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80b8"
    VALUE
    0x80808B13
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80b9_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80b9"
    VALUE
    0x80808B14
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80ba_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80ba"
    VALUE
    0x80808B15
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80bb_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80bb"
    VALUE
    0x80808B16
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80bc_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80bc"
    VALUE
    0x80808B17
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80bd_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80bd"
    VALUE
    0x80808B18
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80be_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80be"
    VALUE
    0x80808B19
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80bf_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80bf"
    VALUE
    0x80808B1A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80c0_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80c0"
    VALUE
    0x80808B1B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80c1_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80c1"
    VALUE
    0x80808B1C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80c2_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80c2"
    VALUE
    0x80808B1D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80c3_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80c3"
    VALUE
    0x80808B1E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80c4_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80c4"
    VALUE
    0x80808B1F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80c5_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80c5"
    VALUE
    0x80808B20
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_NoDeb0x80c6_C
    "AUTOSAR: DTC severity class / Check DFC_bds_NoDeb0x80c6"
    VALUE
    0x80808B21
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_TiUpDwn0x8A01_C
    "AUTOSAR: DTC severity class / Check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x80808B22
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_TiUpDwn0x8A02_C
    "AUTOSAR: DTC severity class / Check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x80808B23
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_bds_TiUpDwn0x8A03_C
    "AUTOSAR: DTC severity class / Check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x80808B24
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA13OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA13OR"
    VALUE
    0x80808B25
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA13SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA13SCB"
    VALUE
    0x80808B26
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA13SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA13SCG"
    VALUE
    0x80808B27
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA14OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA14OR"
    VALUE
    0x80808B28
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA14SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA14SCB"
    VALUE
    0x80808B29
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA14SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA14SCG"
    VALUE
    0x80808B2A
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA21OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA21OR"
    VALUE
    0x80808B2B
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA21SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA21SCB"
    VALUE
    0x80808B2C
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA21SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA21SCG"
    VALUE
    0x80808B2D
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA22OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA22OR"
    VALUE
    0x80808B2E
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA22SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA22SCB"
    VALUE
    0x80808B2F
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA22SCG_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA22SCG"
    VALUE
    0x80808B30
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA23OR_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA23OR"
    VALUE
    0x80808B31
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA23SCB_C
    "AUTOSAR: DTC severity class / Check DFC_rbr_inA23SCB"
    VALUE
    0x80808B32
    Val_Wu8
    128.000000000
    Dem_DTCSeverity_Verb
    0.00
    128.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcSeverity.DFC_rbr_inA23SCG_C
