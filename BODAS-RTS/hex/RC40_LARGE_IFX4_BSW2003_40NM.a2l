    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012205


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].Wakeup_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012208


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].TransmitSRF_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001220B


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].SlpGetStatus_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001220C


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].NewScheduleTable_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012200


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].GotoSleepCtr
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012207


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_Status_u8
    "Lin Interface status variable"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121F4


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_ModeRepeatReq_Max_u8
    "Maximum Tries for Same Mode Request Possible in LinSM"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CE98


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].ChnlState
    "LinSM type variable[0]/"
    UBYTE
    AUTOSAR_LinSM_CompuMethods_LinSM_CompuMethod_OperationalMode
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001224C


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].TimeOutCounter
    "LinSM type variable[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012250


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].TimeoutFlag
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012254


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].StoredSchdTab
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012255


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].LinSm_SchdReq_E_NOT_OK
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012256


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].LinSm_Conf_Status
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012257


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].LinSm_Request_Status
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012258


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].LinSm_Sleep_Status
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012259


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_RamVar_ast[0].LinSmModReqRepMax
    "LinSM type variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001225A


/end MEASUREMENT




/begin MEASUREMENT

    LinSM_State_en
    "State variable of LINSM"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001225C


/end MEASUREMENT




/begin MEASUREMENT

    PduR_State
    "State information of Pdur module"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012270


/end MEASUREMENT




/begin MEASUREMENT

    TcpIp_EthIfCtrlSt_aen
    "Gives Information about TCP/IP stack state for a specific EthIf controller (TCPIP_STATE_ONLINE i.e. communication via at least one IP address is possible, TCPIP_STATE_ONHOLD i.e. no communication is currently possible (e.g. link down), TCPIP_STATE_OFFLINE i.e. no communication is possible, TCPIP_STATE_STARTUP i.e. IP address assignment in progress or ready for manual start communication is currently not possible, TCPIP_STATE_SHUTDOWN i.e. release of resources using the EthIf controller, release of IP address assignment.)"
    UBYTE
    AUTOSAR_TcpIp_CompuMethods_TcpIp_Enum_StateType
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700077A2
    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_CanMcan_DriverState_MP
    "Flag to check if CAN driver is Initialized(CAN_READY(TRUE)) or Not Initialized (CAN_UNINIT(FALSE))"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    1.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70007658


/end MEASUREMENT




/begin MEASUREMENT

    rba_CanMcan_MsgStatus_MP
    "This variable value describes the CAN message buffer status. The value is 1 if the message transmission is initiated and is reset(value 0) after the confirmation is given for the same."
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D116
    MATRIX_DIM 13 


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_dataDiagInfo_MP
    "Array of 32-bit diagnosis information"
    ULONG
    DefaultIdenticalCompu
    1
    100
    0.0
    4.294967295E9
    ECU_ADDRESS 0x6000AFE8


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_idDbgSignal
    "Signal Id of half-bridge signal that needs to be debugged"
    UWORD
    DefaultIdenticalCompu
    1
    100
    0.0
    65535.0
    ECU_ADDRESS 0x700063C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_stDiagCtrl_MP
    "The status of diagnosis control"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x6000D183


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_stDiagDi_MP
    "The status of diagnosis disabled"
    UBYTE
    AUTOSAR_Platform_CompuMethods_boolean
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x6000D184


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_stSwtOffDiag_MP
    "The status of switch-off mode diagnosis"
    UBYTE
    RB_RBA_rba_IoDiagHlfBr_CompuMethods_rba_IoDiagHlfBr_SwtOffDiagSts_tu8_CompuMethod
    1
    100
    0.0
    5.
    FORMAT "%9.0"
    ECU_ADDRESS 0x6000D182


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_stTstPlsReq_MP
    "The status of test pulse request"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x6000D181


/end MEASUREMENT




/begin MEASUREMENT

    rba_IoDiagHlfBr_xReasSwtOffDiagAbort_MP
    "The reason for switch-off mode diagnosis aborted"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x6000D180


/end MEASUREMENT




/begin MEASUREMENT

    rba_MRly_Ctrl_State_MP
    "Current control state of Main Relay"
    UBYTE
    RB_RBA_rba_MRly_BswModuleDescriptions_rba_MRly_Ctrl_States_CompuMethod
    1
    100
    0.0
    1.
    FORMAT "%8.3"
    ECU_ADDRESS 0x70030440

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Current control state of Main Relay\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_ThresholdTable
    "Threshold table for Configured Limits"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700063CA
    MATRIX_DIM 6 


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[0].current
    "Core load Os measurement for each core[0]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[1].current
    "Core load Os measurement for each core[1]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016B2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[2].current
    "Core load Os measurement for each core[2]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[3].current
    "Core load Os measurement for each core[3]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016BE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[0].curCycleMax
    "Core load Os measurement for each core[0]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016AE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[1].curCycleMax
    "Core load Os measurement for each core[1]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[2].curCycleMax
    "Core load Os measurement for each core[2]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016BA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[3].curCycleMax
    "Core load Os measurement for each core[3]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[0].lifeTimeMax
    "Core load Os measurement for each core[0]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[1].lifeTimeMax
    "Core load Os measurement for each core[1]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016B6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[2].lifeTimeMax
    "Core load Os measurement for each core[2]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_CoreLoad[3].lifeTimeMax
    "Core load Os measurement for each core[3]/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x700016C2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_1000ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013238


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_1000ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001323C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_1000ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013240


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.CETCurrent
    "Task response time monitoring for OS_1000ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013244


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.CETCycleMax
    "Task response time monitoring for OS_1000ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013248


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_1000ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001324C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1000ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_1000ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001324E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_100ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013220


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_100ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013224


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_100ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013228


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.CETCurrent
    "Task response time monitoring for OS_100ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001322C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.CETCycleMax
    "Task response time monitoring for OS_100ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013230


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_100ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013234


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_100ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_100ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013236


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_10ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013208


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_10ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001320C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_10ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013210


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.CETCurrent
    "Task response time monitoring for OS_10ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013214


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.CETCycleMax
    "Task response time monitoring for OS_10ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013218


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_10ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001321C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_10ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_10ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001321E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_1ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_1ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_1ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.CETCurrent
    "Task response time monitoring for OS_1ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.CETCycleMax
    "Task response time monitoring for OS_1ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013200


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_1ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013204


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_1ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_1ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013206


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_200ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_200ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_200ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.CETCurrent
    "Task response time monitoring for OS_200ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.CETCycleMax
    "Task response time monitoring for OS_200ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_200ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600131EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_200ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_200ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600131EE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_20ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_20ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_20ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.CETCurrent
    "Task response time monitoring for OS_20ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.CETCycleMax
    "Task response time monitoring for OS_20ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_20ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600131D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_20ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_20ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600131D6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_2ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_2ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_2ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.CETCurrent
    "Task response time monitoring for OS_2ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.CETCycleMax
    "Task response time monitoring for OS_2ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_2ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600131BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_2ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_2ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600131BE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_40ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013190


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_40ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013194


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_40ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013198


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.CETCurrent
    "Task response time monitoring for OS_40ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001319C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.CETCycleMax
    "Task response time monitoring for OS_40ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x600131A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_40ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600131A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_40ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_40ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x600131A6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_50ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013178


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_50ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001317C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_50ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013180


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.CETCurrent
    "Task response time monitoring for OS_50ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013184


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.CETCycleMax
    "Task response time monitoring for OS_50ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013188


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_50ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001318C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_50ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_50ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001318E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_5ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013160


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_5ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013164


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_5ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013168


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.CETCurrent
    "Task response time monitoring for OS_5ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001316C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.CETCycleMax
    "Task response time monitoring for OS_5ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013170


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_5ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013174


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_5ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_5ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x60013176


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.RespTimeCurrent
    "Task response time monitoring for OS_80ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013148


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.RespTimeCycleMax
    "Task response time monitoring for OS_80ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x6001314C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.RespTimeLifetimeMax
    "Task response time monitoring for OS_80ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_TaskRespTime_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013150


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.CETCurrent
    "Task response time monitoring for OS_80ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013154


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.CETCycleMax
    "Task response time monitoring for OS_80ms_Task/"
    ULONG
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_CET_T1_CompuMethod
    1
    100
    0.0
    4.2949672E7
    FORMAT "%13.9"
    ECU_ADDRESS 0x60013158


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.CETCurrentLoad
    "Task response time monitoring for OS_80ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001315C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsMeasmt_OS_80ms_Task.CETCurrentLoadMax
    "Task response time monitoring for OS_80ms_Task/"
    UWORD
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_T1_PercConversion
    1
    100
    0.0
    655.
    FORMAT "%5.2"
    ECU_ADDRESS 0x6001315E


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_CSA0
    "Current Cycle Max Usage stack Csa0"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C426


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_CSA1
    "Current Cycle Max Usage stack Csa1"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C424


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_CSA2
    "Current Cycle Max Usage stack Csa2"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C422


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_User0
    "Current Cycle Max Usage stack User0"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C42E


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_User1
    "Current Cycle Max Usage stack User1"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C42C


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_CurrentCycleMaxUsage_User2
    "Current Cycle Max Usage stack User2"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C42A


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_CSA0
    "Life Time Max Usage stack CSA0"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60036830


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_CSA1
    "Life Time Max Usage stack CSA1"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6003682E


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_CSA2
    "Life Time Max Usage stack CSA2"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6003682C


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_User0
    "Life Time Max Usage stack User0"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60036838


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_User1
    "Life Time Max Usage stack User1"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60036836


/end MEASUREMENT




/begin MEASUREMENT

    rba_MultiStackTrace_LifeTimeMaxUsage_User2
    "Life Time Max Usage stack User2"
    UWORD
    RB_RBA_rba_OsShell_CompuMethods_rba_OsShell_ResourceConversion
    1
    100
    0.0
    655.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60036834


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr1000msTask
    "OS task counter for the OS_1000ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr100msTask
    "OS task counter for the OS_100ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr100msTaskUntrusted
    "OS task counter for the OS_100ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9AA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr10msTask
    "OS task counter for the OS_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C998


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr10msTaskUntrusted
    "OS task counter for the OS_10ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C996


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr1msTask
    "OS task counter for the OS_1ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C988


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr1msTaskUntrusted
    "OS task counter for the OS_1ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C986


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr200msTask
    "OS task counter for the OS_200ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9AE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr20msTask
    "OS task counter for the OS_20ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C99C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr20msTaskUntrusted
    "OS task counter for the OS_20ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C99A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr2msTask
    "OS task counter for the OS_2ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C98C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr2msTaskUntrusted
    "OS task counter for the OS_2ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C98A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr40msTask
    "OS task counter for the OS_40ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr40msTaskUntrusted
    "OS task counter for the OS_40ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C99E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr50msTask
    "OS task counter for the OS_50ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr50msTaskUntrusted
    "OS task counter for the OS_50ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9A2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr5msTask
    "OS task counter for the OS_5ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C992


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr5msTaskUntrusted
    "OS task counter for the OS_5ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C990


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr80msTask
    "OS task counter for the OS_80ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntr80msTaskUntrusted
    "OS task counter for the OS_80ms_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9A6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrAsw1BgTask
    "OS task counter for the OS_Asw1Bg_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrAswBgTaskUntrusted
    "OS task counter for the OS_AswBg_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9C2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrAswShutdownTaskUntrusted
    "OS task counter for the OS_AswShutdown_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrBswBgTask
    "OS task counter for the OS_BswBg_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A808


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWup100msTask
    "OS task counter for the OS_CalWup_100ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A800


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWup10msTask
    "OS task counter for the OS_CalWup_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A7FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWup20msTask
    "OS task counter for the OS_CalWup_20ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A7FE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWup2msTask
    "OS task counter for the OS_CalWup_2ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A7F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupAsw110msTask
    "OS task counter for the OS_CalWupAsw1_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C98E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupAsw210msTask
    "OS task counter for the OS_CalWupAsw2_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupAsw310msTask
    "OS task counter for the OS_CalWupAsw3_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000536


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupBgTask
    "OS task counter for the OS_CalWup_Bg_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A806


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupIniEndTask
    "OS task counter for the OS_CalWup_IniEnd_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A804


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrCalWupIniTask
    "OS task counter for the OS_CalWup_Ini_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A802


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrDSMClearTask
    "OS task counter for the OS_DSM_Clear_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000548


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrDSMReiniTask
    "OS task counter for the OS_DSM_Reini_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000550


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrEngReStrtModeMTask
    "OS task counter for the OS_EngReStrtModeM_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000EA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrEngReStrtTask
    "OS task counter for the OS_EngReStrt_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrEpmNoSyncTask
    "OS task counter for the OS_EpmNoSync_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000CE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit1000msTask
    "Limit error counter for OS_1000ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D217


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit100msTask
    "Limit error counter for OS_100ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D215


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit100msTaskUntrusted
    "Limit error counter for OS_100ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D214


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit10msTask
    "Limit error counter for OS_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FF


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit10msTaskUntrusted
    "Limit error counter for OS_10ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit1msTask
    "Limit error counter for OS_1ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit1msTaskUntrusted
    "Limit error counter for OS_1ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E7


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit200msTask
    "Limit error counter for OS_200ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D216


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit20msTask
    "Limit error counter for OS_20ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D204


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit20msTaskUntrusted
    "Limit error counter for OS_20ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D203


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit2msTask
    "Limit error counter for OS_2ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1EF


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit2msTaskUntrusted
    "Limit error counter for OS_2ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1EE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit40msTask
    "Limit error counter for OS_40ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D208


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit40msTaskUntrusted
    "Limit error counter for OS_40ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D207


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit50msTask
    "Limit error counter for OS_50ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit50msTaskUntrusted
    "Limit error counter for OS_50ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20B


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit5msTask
    "Limit error counter for OS_5ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit5msTaskUntrusted
    "Limit error counter for OS_5ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F5


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit80msTask
    "Limit error counter for OS_80ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D210


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimit80msTaskUntrusted
    "Limit error counter for OS_80ms_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20F


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitAsw1BgTask
    "Limit error counter for OS_Asw1Bg_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D22E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitAswBgTaskUntrusted
    "Limit error counter for OS_AswBg_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D22D


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitAswShutdownTaskUntrusted
    "Limit error counter for OS_AswShutdown_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D22C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitBswBgTask
    "Limit error counter for OS_BswBg_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D22B


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWup100msTask
    "Limit error counter for OS_CalWup_100ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D213


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWup10msTask
    "Limit error counter for OS_CalWup_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWup20msTask
    "Limit error counter for OS_CalWup_20ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D200


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWup2msTask
    "Limit error counter for OS_CalWup_2ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1EA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupAsw110msTask
    "Limit error counter for OS_CalWupAsw1_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupAsw210msTask
    "Limit error counter for OS_CalWupAsw2_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F3


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupAsw310msTask
    "Limit error counter for OS_CalWupAsw3_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1ED


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupBgTask
    "Limit error counter for OS_CalWup_Bg_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D22A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupIniEndTask
    "Limit error counter for OS_CalWup_IniEnd_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D229


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitCalWupIniTask
    "Limit error counter for OS_CalWup_Ini_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D228


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitDSMClearTask
    "Limit error counter for OS_DSM_Clear_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D219


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitDSMReiniTask
    "Limit error counter for OS_DSM_Reini_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D227


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitEngReStrtModeMTask
    "Limit error counter for OS_EngReStrtModeM_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D226


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitEngReStrtTask
    "Limit error counter for OS_EngReStrt_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E9


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitEpmNoSyncTask
    "Limit error counter for OS_EpmNoSync_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1EB


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitInfraAsw1App10msTask
    "Limit error counter for OS_InfraAsw1App_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FB


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitInfraAsw2App10msTask
    "Limit error counter for OS_InfraAsw2App_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitInfraAsw3App10msTask
    "Limit error counter for OS_InfraAsw3App_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F9


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitInfraBswApp10msTask
    "Limit error counter for OS_InfraBswApp_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitIniDrvTask
    "Limit error counter for OS_IniDrv_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D218


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitIniDrvTaskUntrusted
    "Limit error counter for OS_IniDrv_Task_Untrusted"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D225


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitIniEndTask
    "Limit error counter for OS_IniEnd_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D224


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitIniTask
    "Limit error counter for OS_Ini_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D223


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitMoTask
    "Limit error counter for OS_Mo_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitRbrAfterRunTask
    "Limit error counter for OS_RbrAfterRun_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D222


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitReIniModeMTask
    "Limit error counter for OS_ReIniModeM_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D221


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitReIniTask
    "Limit error counter for OS_ReIni_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdown10msTask
    "Limit error counter for OS_Shutdown_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1DD


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdownAsw1Task
    "Limit error counter for OS_Shutdown_Asw1_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdownAsw2Task
    "Limit error counter for OS_Shutdown_Asw2_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E1


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdownAsw3Task
    "Limit error counter for OS_Shutdown_Asw3_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdownBswTask
    "Limit error counter for OS_Shutdown_Bsw_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1DF


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitShutdownSeqTask
    "Limit error counter for OS_Shutdown_Seq_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1DE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitWdgMTask
    "Limit error counter for OS_WdgM_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E3


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore2100msTask
    "Limit error counter for OS_core2_100ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D212


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore210msTask
    "Limit error counter for OS_core2_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1FD


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore21msTask
    "Limit error counter for OS_core2_1ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore220msTask
    "Limit error counter for OS_core2_20ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D202


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore22msTask
    "Limit error counter for OS_core2_2ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore240msTask
    "Limit error counter for OS_core2_40ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D206


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore250msTask
    "Limit error counter for OS_core2_50ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore25msTask
    "Limit error counter for OS_core2_5ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F1


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore280msTask
    "Limit error counter for OS_core2_80ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore2AswBgTask
    "Limit error counter for OS_core2_AswBg_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D220


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore2AswShutdownTask
    "Limit error counter for OS_core2_AswShutdown_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21F


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore2IniDrvTask
    "Limit error counter for OS_core2_IniDrv_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore3100msTask
    "Limit error counter for OS_core3_100ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D211


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore310msTask
    "Limit error counter for OS_core3_10ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F7


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore31msTask
    "Limit error counter for OS_core3_1ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1E5


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore320msTask
    "Limit error counter for OS_core3_20ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D201


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore32msTask
    "Limit error counter for OS_core3_2ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore340msTask
    "Limit error counter for OS_core3_40ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D205


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore350msTask
    "Limit error counter for OS_core3_50ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D209


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore35msTask
    "Limit error counter for OS_core3_5ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore380msTask
    "Limit error counter for OS_core3_80ms_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D20D


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore3AswBgTask
    "Limit error counter for OS_core3_AswBg_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21D


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore3AswShutdownTask
    "Limit error counter for OS_core3_AswShutdown_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrErrLimitcore3IniDrvTask
    "Limit error counter for OS_core3_IniDrv_Task"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D21B


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrInfraAsw1App10msTask
    "OS task counter for the OS_InfraAsw1App_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C994


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrInfraAsw2App10msTask
    "OS task counter for the OS_InfraAsw2App_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000D6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrInfraAsw3App10msTask
    "OS task counter for the OS_InfraAsw3App_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000053C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrInfraBswApp10msTask
    "OS task counter for the OS_InfraBswApp_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A7FA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrIniDrvTask
    "OS task counter for the OS_IniDrv_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9B2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrIniDrvTaskUntrusted
    "OS task counter for the OS_IniDrv_Task_Untrusted"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9BE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrIniEndTask
    "OS task counter for the OS_IniEnd_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrIniTask
    "OS task counter for the OS_Ini_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9BA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrMoTask
    "OS task counter for the OS_Mo_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C984


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrRbrAfterRunTask
    "OS task counter for the OS_RbrAfterRun_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrReIniModeMTask
    "OS task counter for the OS_ReIniModeM_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9B6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrReIniTask
    "OS task counter for the OS_ReIni_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C9B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdown10msTask
    "OS task counter for the OS_Shutdown_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A7F2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdownAsw1Task
    "OS task counter for the OS_Shutdown_Asw1_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C980


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdownAsw2Task
    "OS task counter for the OS_Shutdown_Asw2_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdownAsw3Task
    "OS task counter for the OS_Shutdown_Asw3_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000530


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdownBswTask
    "OS task counter for the OS_Shutdown_Bsw_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A7F6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrShutdownSeqTask
    "OS task counter for the OS_Shutdown_Seq_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000A7F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_CntrWdgMTask
    "OS task counter for the OS_WdgM_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001C982


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore2100msTask
    "OS task counter for the OS_core2_100ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000E2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore210msTask
    "OS task counter for the OS_core2_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore21msTask
    "OS task counter for the OS_core2_1ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000CA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore220msTask
    "OS task counter for the OS_core2_20ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000DA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore22msTask
    "OS task counter for the OS_core2_2ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000D2


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore240msTask
    "OS task counter for the OS_core2_40ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore250msTask
    "OS task counter for the OS_core2_50ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000DE


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore25msTask
    "OS task counter for the OS_core2_5ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore280msTask
    "OS task counter for the OS_core2_80ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore2AswBgTask
    "OS task counter for the OS_core2_AswBg_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore2AswShutdownTask
    "OS task counter for the OS_core2_AswShutdown_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000E6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore2IniDrvTask
    "OS task counter for the OS_core2_IniDrv_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x500000E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore3100msTask
    "OS task counter for the OS_core3_100ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000546


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore310msTask
    "OS task counter for the OS_core3_10ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000053A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore31msTask
    "OS task counter for the OS_core3_1ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000532


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore320msTask
    "OS task counter for the OS_core3_20ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000053E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore32msTask
    "OS task counter for the OS_core3_2ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000534


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore340msTask
    "OS task counter for the OS_core3_40ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000540


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore350msTask
    "OS task counter for the OS_core3_50ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000542


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore35msTask
    "OS task counter for the OS_core3_5ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000538


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore380msTask
    "OS task counter for the OS_core3_80ms_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x40000544


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore3AswBgTask
    "OS task counter for the OS_core3_AswBg_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000054E


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore3AswShutdownTask
    "OS task counter for the OS_core3_AswShutdown_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000054C


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_Cntrcore3IniDrvTask
    "OS task counter for the OS_core3_IniDrv_Task"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x4000054A


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrAccess
    "OS E_OS_ACCESS error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1DB


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrCallevel
    "OS E_OS_CALLEVEL error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1DA


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrId
    "OS E_OS_ID error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D9


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrLimitSum
    "OS E_OS_LIMIT error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrNoFunc
    "OS E_OS_NOFUNC error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D7


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrResource
    "OS E_OS_RESOURCE error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D6


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrState
    "OS E_OS_STATE error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D5


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrSum
    "OS overall error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_cntrErrValue
    "OS E_OS_VALUE error counter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D1D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_tiPowerOnFrst10ms
    "Time from last Power on Reset to first 10ms-Raster"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C436


/end MEASUREMENT




/begin MEASUREMENT

    rba_OsShell_tiResetFrst10ms
    "Time from last Reset to first 10ms-Raster"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000C438


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ApplEnv_st.Loc_u32
    "reset application environment/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ApplEnv_st.UserValue_u32
    "reset application environment/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ApplEnv_st.Id_en
    "reset application environment/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ApplEnv_st.Grp_en
    "reset application environment/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031FE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ApplEnv_st.CntrRst_u8
    "reset application environment/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031FF


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[0].ResetId_en
    "extended Reset history buffer[0]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AE0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[1].ResetId_en
    "extended Reset history buffer[1]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AF0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[2].ResetId_en
    "extended Reset history buffer[2]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B00


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[3].ResetId_en
    "extended Reset history buffer[3]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B10


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[4].ResetId_en
    "extended Reset history buffer[4]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B20


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[5].ResetId_en
    "extended Reset history buffer[5]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B30


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[6].ResetId_en
    "extended Reset history buffer[6]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B40


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[7].ResetId_en
    "extended Reset history buffer[7]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B50


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[8].ResetId_en
    "extended Reset history buffer[8]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B60


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[9].ResetId_en
    "extended Reset history buffer[9]/"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B70


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[0].Cntr_u16
    "extended Reset history buffer[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AE2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[1].Cntr_u16
    "extended Reset history buffer[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AF2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[2].Cntr_u16
    "extended Reset history buffer[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B02


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[3].Cntr_u16
    "extended Reset history buffer[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B12


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[4].Cntr_u16
    "extended Reset history buffer[4]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B22


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[5].Cntr_u16
    "extended Reset history buffer[5]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B32


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[6].Cntr_u16
    "extended Reset history buffer[6]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B42


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[7].Cntr_u16
    "extended Reset history buffer[7]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B52


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[8].Cntr_u16
    "extended Reset history buffer[8]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B62


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[9].Cntr_u16
    "extended Reset history buffer[9]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B72


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[0].Addr_u32
    "extended Reset history buffer[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AE4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[1].Addr_u32
    "extended Reset history buffer[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AF4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[2].Addr_u32
    "extended Reset history buffer[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B04


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[3].Addr_u32
    "extended Reset history buffer[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B14


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[4].Addr_u32
    "extended Reset history buffer[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B24


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[5].Addr_u32
    "extended Reset history buffer[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B34


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[6].Addr_u32
    "extended Reset history buffer[6]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B44


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[7].Addr_u32
    "extended Reset history buffer[7]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B54


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[8].Addr_u32
    "extended Reset history buffer[8]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B64


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[9].Addr_u32
    "extended Reset history buffer[9]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B74


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[0].SwId_u32_1
    "extended Reset history buffer[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AE8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[1].SwId_u32_1
    "extended Reset history buffer[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AF8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[2].SwId_u32_1
    "extended Reset history buffer[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B08


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[3].SwId_u32_1
    "extended Reset history buffer[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B18


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[4].SwId_u32_1
    "extended Reset history buffer[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B28


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[5].SwId_u32_1
    "extended Reset history buffer[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B38


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[6].SwId_u32_1
    "extended Reset history buffer[6]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B48


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[7].SwId_u32_1
    "extended Reset history buffer[7]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B58


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[8].SwId_u32_1
    "extended Reset history buffer[8]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B68


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[9].SwId_u32_1
    "extended Reset history buffer[9]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B78


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[0].SwId_u32_2
    "extended Reset history buffer[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AEC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[1].SwId_u32_2
    "extended Reset history buffer[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039AFC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[2].SwId_u32_2
    "extended Reset history buffer[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B0C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[3].SwId_u32_2
    "extended Reset history buffer[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B1C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[4].SwId_u32_2
    "extended Reset history buffer[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B2C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[5].SwId_u32_2
    "extended Reset history buffer[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B3C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[6].SwId_u32_2
    "extended Reset history buffer[6]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B4C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[7].SwId_u32_2
    "extended Reset history buffer[7]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B5C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[8].SwId_u32_2
    "extended Reset history buffer[8]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B6C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_ExtHistBuf_ast[9].SwId_u32_2
    "extended Reset history buffer[9]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B7C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Reset_HistBuf_a
    "reset history buffer"
    UWORD
    RB_RBA_rba_Reset_CompuMethods_rba_Reset_Id_ten
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70039B80
    MATRIX_DIM 8 


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Input_st.configs_ast[0].idElement_u32
    "rba_Runtime Measurement Variable/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001860


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Input_st.configs_ast[0].idTask_u16
    "rba_Runtime Measurement Variable/[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001864


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Input_st.tiSampleTime_u8
    "rba_Runtime Measurement Variable/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001868


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Input_st.ctTrigger_u8
    "rba_Runtime Measurement Variable/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001869


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].tiCurRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C30


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].tiCurRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C58


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].tiCurRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C80


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C34


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].tiMinRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C5C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].tiMinRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C84


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C38


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].tiMaxRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C60


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].tiMaxRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C88


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C3C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C64


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C8C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C40


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C68


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C90


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C44


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].ctCalls_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C6C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].ctCalls_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C94


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C48


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C70


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C98


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C4C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C74


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C9C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C50


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C78


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CA0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].loadPer64k_u16
    "rba_Runtime Measurement Variable[0]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C54


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].loadPer64k_u16
    "rba_Runtime Measurement Variable[1]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C7C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].loadPer64k_u16
    "rba_Runtime Measurement Variable[2]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CA4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[0].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C56


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[1].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001C7E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonIsr_ast[2].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CA6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonSystemLoadPer64k_au16
    "Core Load"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029DC
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiCurRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CA8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiCurRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CDC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiCurRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D10


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiCurRT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D44


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiCurRT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D78


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiCurRT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DAC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiCurRT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DE0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiCurRT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E14


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiCurRT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E48


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiCurRT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E7C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiCurRT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EB0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiCurRT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EE4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiCurRT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F18


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiCurRT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F4C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiCurRT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F80


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiCurRT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FB4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiCurRT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FE8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiCurRT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000201C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiCurRT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002050


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiCurRT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002084


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiCurRT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiCurRT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiCurRT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002120


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiCurRT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002154


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiCurRT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002188


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiCurRT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiCurRT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiCurRT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002224


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiCurRT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002258


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiCurRT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000228C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiCurRT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiCurRT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiCurRT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002328


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiCurRT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000235C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiCurRT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002390


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiCurRT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiCurRT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiCurRT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000242C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiCurRT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002460


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiCurRT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002494


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiCurRT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiCurRT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiCurRT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002530


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiCurRT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002564


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiCurRT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002598


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiCurRT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiCurRT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002600


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiCurRT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002634


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiCurRT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002668


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiCurRT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000269C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiCurRT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiCurRT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002704


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiCurRT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002738


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiCurRT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000276C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiCurRT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiCurRT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiCurRT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002808


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiCurRT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000283C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiCurRT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002870


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiCurRT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiCurRT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiCurRT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000290C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiCurRT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002940


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiCurRT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002974


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiCurRT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CAC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiMinRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CE0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiMinRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D14


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiMinRT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D48


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiMinRT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D7C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiMinRT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DB0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiMinRT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DE4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiMinRT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E18


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiMinRT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E4C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiMinRT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E80


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiMinRT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EB4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiMinRT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EE8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiMinRT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F1C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiMinRT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F50


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiMinRT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F84


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiMinRT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FB8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiMinRT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FEC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiMinRT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002020


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiMinRT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002054


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiMinRT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002088


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiMinRT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiMinRT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiMinRT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002124


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiMinRT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002158


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiMinRT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000218C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiMinRT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiMinRT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiMinRT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002228


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiMinRT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000225C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiMinRT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002290


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiMinRT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiMinRT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiMinRT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000232C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiMinRT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002360


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiMinRT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002394


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiMinRT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiMinRT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiMinRT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002430


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiMinRT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002464


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiMinRT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002498


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiMinRT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiMinRT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002500


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiMinRT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002534


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiMinRT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002568


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiMinRT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000259C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiMinRT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiMinRT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002604


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiMinRT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002638


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiMinRT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000266C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiMinRT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiMinRT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiMinRT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002708


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiMinRT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000273C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiMinRT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002770


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiMinRT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiMinRT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiMinRT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000280C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiMinRT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002840


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiMinRT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002874


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiMinRT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiMinRT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiMinRT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002910


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiMinRT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002944


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiMinRT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002978


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiMinRT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CB0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiMaxRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CE4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiMaxRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D18


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiMaxRT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D4C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiMaxRT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D80


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiMaxRT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DB4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiMaxRT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DE8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiMaxRT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E1C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiMaxRT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E50


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiMaxRT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E84


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiMaxRT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EB8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiMaxRT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EEC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiMaxRT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F20


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiMaxRT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F54


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiMaxRT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F88


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiMaxRT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FBC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiMaxRT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FF0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiMaxRT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002024


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiMaxRT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002058


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiMaxRT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000208C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiMaxRT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiMaxRT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiMaxRT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002128


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiMaxRT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000215C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiMaxRT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002190


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiMaxRT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiMaxRT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiMaxRT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000222C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiMaxRT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002260


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiMaxRT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002294


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiMaxRT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiMaxRT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiMaxRT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002330


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiMaxRT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002364


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiMaxRT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002398


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiMaxRT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiMaxRT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002400


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiMaxRT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002434


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiMaxRT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002468


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiMaxRT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000249C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiMaxRT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiMaxRT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002504


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiMaxRT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002538


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiMaxRT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000256C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiMaxRT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiMaxRT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiMaxRT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002608


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiMaxRT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000263C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiMaxRT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002670


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiMaxRT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiMaxRT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiMaxRT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000270C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiMaxRT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002740


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiMaxRT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002774


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiMaxRT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiMaxRT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiMaxRT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002810


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiMaxRT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002844


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiMaxRT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002878


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiMaxRT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiMaxRT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiMaxRT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002914


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiMaxRT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002948


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiMaxRT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000297C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiMaxRT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CB4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CE8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D1C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D50


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D84


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DB8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DEC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E20


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E54


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E88


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EBC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EF0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F24


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F58


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F8C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FC0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FF4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002028


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000205C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002090


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000212C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002160


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002194


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002230


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002264


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002298


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002300


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002334


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002368


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000239C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002404


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002438


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000246C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002508


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000253C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002570


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000260C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002640


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002674


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002710


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002744


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002778


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002814


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002848


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000287C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002918


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000294C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002980


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiCurResponseT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CB8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CEC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D20


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D54


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D88


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DBC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DF0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E24


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E58


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E8C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EC0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EF4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F28


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F5C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F90


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FC4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FF8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000202C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002060


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002094


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002130


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002164


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002198


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002200


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002234


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002268


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000229C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002304


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002338


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000236C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002408


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000243C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002470


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000250C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002540


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002574


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002610


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002644


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002678


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002714


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002748


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000277C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002818


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000284C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002880


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000291C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002950


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002984


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiMinResponseT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CBC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CF0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D24


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D58


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D8C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DC0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DF4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E28


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E5C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E90


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EC4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EF8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F2C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F60


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F94


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FC8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FFC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002030


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002064


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002098


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002100


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002134


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002168


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000219C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002204


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002238


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000226C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002308


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000233C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002370


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000240C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002440


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002474


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002510


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002544


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002578


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002614


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002648


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000267C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002718


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000274C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002780


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000281C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002850


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002884


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002920


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002954


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002988


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiMaxResponseT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CC0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CF4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D28


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D5C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D90


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DC4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DF8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E2C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E60


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E94


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EC8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EFC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F30


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F64


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F98


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FCC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002000


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002034


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002068


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000209C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002104


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002138


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000216C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002208


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000223C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002270


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000230C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002340


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002374


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002410


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002444


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002478


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002514


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002548


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000257C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002618


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000264C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002680


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000271C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002750


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002784


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002820


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002854


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002888


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002924


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002958


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000298C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].ctCallsTotal_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CC4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CF8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D2C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D60


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D94


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DC8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DFC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E30


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E64


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E98


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001ECC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F00


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F34


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F68


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F9C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FD0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002004


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002038


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000206C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002108


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000213C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002170


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000220C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002240


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002274


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002310


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002344


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002378


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002414


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002448


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000247C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002518


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000254C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002580


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000261C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002650


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002684


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002720


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002754


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002788


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002824


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002858


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000288C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002928


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000295C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002990


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].tiAvrgRT_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CC8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].ctCalls_u32
    "rba_Runtime Measurement Variable[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CFC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].ctCalls_u32
    "rba_Runtime Measurement Variable[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D30


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].ctCalls_u32
    "rba_Runtime Measurement Variable[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D64


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].ctCalls_u32
    "rba_Runtime Measurement Variable[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D98


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].ctCalls_u32
    "rba_Runtime Measurement Variable[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DCC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].ctCalls_u32
    "rba_Runtime Measurement Variable[6]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E00


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].ctCalls_u32
    "rba_Runtime Measurement Variable[7]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E34


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].ctCalls_u32
    "rba_Runtime Measurement Variable[8]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E68


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].ctCalls_u32
    "rba_Runtime Measurement Variable[9]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E9C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].ctCalls_u32
    "rba_Runtime Measurement Variable[10]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001ED0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].ctCalls_u32
    "rba_Runtime Measurement Variable[11]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F04


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].ctCalls_u32
    "rba_Runtime Measurement Variable[12]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F38


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].ctCalls_u32
    "rba_Runtime Measurement Variable[13]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F6C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].ctCalls_u32
    "rba_Runtime Measurement Variable[14]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FA0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].ctCalls_u32
    "rba_Runtime Measurement Variable[15]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FD4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].ctCalls_u32
    "rba_Runtime Measurement Variable[16]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002008


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].ctCalls_u32
    "rba_Runtime Measurement Variable[17]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000203C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].ctCalls_u32
    "rba_Runtime Measurement Variable[18]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002070


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].ctCalls_u32
    "rba_Runtime Measurement Variable[19]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].ctCalls_u32
    "rba_Runtime Measurement Variable[20]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].ctCalls_u32
    "rba_Runtime Measurement Variable[21]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000210C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].ctCalls_u32
    "rba_Runtime Measurement Variable[22]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002140


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].ctCalls_u32
    "rba_Runtime Measurement Variable[23]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002174


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].ctCalls_u32
    "rba_Runtime Measurement Variable[24]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].ctCalls_u32
    "rba_Runtime Measurement Variable[25]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].ctCalls_u32
    "rba_Runtime Measurement Variable[26]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002210


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].ctCalls_u32
    "rba_Runtime Measurement Variable[27]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002244


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].ctCalls_u32
    "rba_Runtime Measurement Variable[28]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002278


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].ctCalls_u32
    "rba_Runtime Measurement Variable[29]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].ctCalls_u32
    "rba_Runtime Measurement Variable[30]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].ctCalls_u32
    "rba_Runtime Measurement Variable[31]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002314


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].ctCalls_u32
    "rba_Runtime Measurement Variable[32]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002348


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].ctCalls_u32
    "rba_Runtime Measurement Variable[33]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000237C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].ctCalls_u32
    "rba_Runtime Measurement Variable[34]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].ctCalls_u32
    "rba_Runtime Measurement Variable[35]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].ctCalls_u32
    "rba_Runtime Measurement Variable[36]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002418


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].ctCalls_u32
    "rba_Runtime Measurement Variable[37]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000244C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].ctCalls_u32
    "rba_Runtime Measurement Variable[38]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002480


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].ctCalls_u32
    "rba_Runtime Measurement Variable[39]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].ctCalls_u32
    "rba_Runtime Measurement Variable[40]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].ctCalls_u32
    "rba_Runtime Measurement Variable[41]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000251C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].ctCalls_u32
    "rba_Runtime Measurement Variable[42]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002550


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].ctCalls_u32
    "rba_Runtime Measurement Variable[43]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002584


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].ctCalls_u32
    "rba_Runtime Measurement Variable[44]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].ctCalls_u32
    "rba_Runtime Measurement Variable[45]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].ctCalls_u32
    "rba_Runtime Measurement Variable[46]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002620


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].ctCalls_u32
    "rba_Runtime Measurement Variable[47]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002654


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].ctCalls_u32
    "rba_Runtime Measurement Variable[48]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002688


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].ctCalls_u32
    "rba_Runtime Measurement Variable[49]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].ctCalls_u32
    "rba_Runtime Measurement Variable[50]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].ctCalls_u32
    "rba_Runtime Measurement Variable[51]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002724


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].ctCalls_u32
    "rba_Runtime Measurement Variable[52]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002758


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].ctCalls_u32
    "rba_Runtime Measurement Variable[53]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000278C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].ctCalls_u32
    "rba_Runtime Measurement Variable[54]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].ctCalls_u32
    "rba_Runtime Measurement Variable[55]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].ctCalls_u32
    "rba_Runtime Measurement Variable[56]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002828


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].ctCalls_u32
    "rba_Runtime Measurement Variable[57]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000285C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].ctCalls_u32
    "rba_Runtime Measurement Variable[58]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002890


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].ctCalls_u32
    "rba_Runtime Measurement Variable[59]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].ctCalls_u32
    "rba_Runtime Measurement Variable[60]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].ctCalls_u32
    "rba_Runtime Measurement Variable[61]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000292C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].ctCalls_u32
    "rba_Runtime Measurement Variable[62]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002960


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].ctCalls_u32
    "rba_Runtime Measurement Variable[63]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002994


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].ctCalls_u32
    "rba_Runtime Measurement Variable[64]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CCC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D00


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D34


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[3]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D68


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[4]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D9C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[5]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DD0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[6]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E04


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[7]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E38


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[8]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E6C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[9]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EA0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[10]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001ED4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[11]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F08


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[12]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F3C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[13]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F70


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[14]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FA4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[15]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FD8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[16]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000200C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[17]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002040


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[18]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002074


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[19]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[20]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[21]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002110


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[22]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002144


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[23]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002178


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[24]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[25]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[26]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002214


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[27]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002248


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[28]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000227C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[29]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[30]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[31]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002318


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[32]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000234C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[33]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002380


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[34]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[35]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[36]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000241C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[37]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002450


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[38]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002484


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[39]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[40]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[41]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002520


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[42]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002554


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[43]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002588


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[44]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[45]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[46]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002624


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[47]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002658


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[48]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000268C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[49]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[50]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[51]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002728


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[52]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000275C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[53]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002790


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[54]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[55]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[56]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000282C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[57]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002860


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[58]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002894


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[59]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[60]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[61]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002930


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[62]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002964


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[63]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002998


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].internal_st.tiAccuRT_u32
    "rba_Runtime Measurement Variable[64]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CD0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D04


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D38


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[3]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D6C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[4]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DA0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[5]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DD4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[6]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E08


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[7]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E3C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[8]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E70


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[9]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EA4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[10]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001ED8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[11]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F0C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[12]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F40


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[13]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F74


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[14]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FA8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[15]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FDC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[16]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002010


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[17]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002044


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[18]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002078


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[19]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[20]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[21]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002114


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[22]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002148


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[23]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000217C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[24]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[25]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[26]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002218


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[27]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000224C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[28]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002280


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[29]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[30]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[31]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000231C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[32]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002350


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[33]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002384


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[34]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[35]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[36]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002420


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[37]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002454


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[38]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002488


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[39]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[40]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[41]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002524


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[42]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002558


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[43]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000258C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[44]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[45]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[46]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002628


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[47]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000265C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[48]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002690


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[49]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[50]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[51]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000272C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[52]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002760


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[53]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002794


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[54]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[55]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[56]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002830


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[57]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002864


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[58]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002898


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[59]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[60]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002900


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[61]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002934


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[62]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002968


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[63]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000299C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].internal_st.ctBeginCalls_u32
    "rba_Runtime Measurement Variable[64]//"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[0]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CD4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[1]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D08


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[2]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D3C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[3]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D70


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[4]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DA4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[5]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DD8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[6]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E0C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[7]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E40


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[8]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E74


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[9]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EA8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[10]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EDC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[11]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F10


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[12]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F44


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[13]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F78


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[14]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FAC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[15]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FE0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[16]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002014


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[17]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002048


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[18]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000207C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[19]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020B0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[20]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[21]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002118


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[22]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000214C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[23]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002180


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[24]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[25]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[26]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000221C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[27]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002250


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[28]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002284


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[29]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[30]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[31]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002320


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[32]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002354


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[33]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002388


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[34]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[35]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[36]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002424


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[37]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002458


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[38]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000248C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[39]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[40]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[41]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002528


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[42]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000255C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[43]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002590


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[44]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[45]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[46]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000262C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[47]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002660


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[48]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002694


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[49]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[50]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[51]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002730


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[52]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002764


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[53]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002798


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[54]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[55]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002800


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[56]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002834


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[57]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002868


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[58]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000289C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[59]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[60]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002904


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[61]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002938


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[62]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000296C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[63]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].internal_st.tiBeginFree_u32
    "rba_Runtime Measurement Variable[64]//"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].loadPer64k_u16
    "rba_Runtime Measurement Variable[0]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CD8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].loadPer64k_u16
    "rba_Runtime Measurement Variable[1]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D0C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].loadPer64k_u16
    "rba_Runtime Measurement Variable[2]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D40


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].loadPer64k_u16
    "rba_Runtime Measurement Variable[3]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D74


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].loadPer64k_u16
    "rba_Runtime Measurement Variable[4]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DA8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].loadPer64k_u16
    "rba_Runtime Measurement Variable[5]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DDC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].loadPer64k_u16
    "rba_Runtime Measurement Variable[6]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E10


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].loadPer64k_u16
    "rba_Runtime Measurement Variable[7]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E44


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].loadPer64k_u16
    "rba_Runtime Measurement Variable[8]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E78


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].loadPer64k_u16
    "rba_Runtime Measurement Variable[9]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EAC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].loadPer64k_u16
    "rba_Runtime Measurement Variable[10]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EE0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].loadPer64k_u16
    "rba_Runtime Measurement Variable[11]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F14


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].loadPer64k_u16
    "rba_Runtime Measurement Variable[12]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F48


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].loadPer64k_u16
    "rba_Runtime Measurement Variable[13]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F7C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].loadPer64k_u16
    "rba_Runtime Measurement Variable[14]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FB0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].loadPer64k_u16
    "rba_Runtime Measurement Variable[15]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FE4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].loadPer64k_u16
    "rba_Runtime Measurement Variable[16]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002018


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].loadPer64k_u16
    "rba_Runtime Measurement Variable[17]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000204C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].loadPer64k_u16
    "rba_Runtime Measurement Variable[18]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002080


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].loadPer64k_u16
    "rba_Runtime Measurement Variable[19]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020B4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].loadPer64k_u16
    "rba_Runtime Measurement Variable[20]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].loadPer64k_u16
    "rba_Runtime Measurement Variable[21]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000211C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].loadPer64k_u16
    "rba_Runtime Measurement Variable[22]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002150


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].loadPer64k_u16
    "rba_Runtime Measurement Variable[23]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002184


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].loadPer64k_u16
    "rba_Runtime Measurement Variable[24]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021B8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].loadPer64k_u16
    "rba_Runtime Measurement Variable[25]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].loadPer64k_u16
    "rba_Runtime Measurement Variable[26]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002220


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].loadPer64k_u16
    "rba_Runtime Measurement Variable[27]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002254


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].loadPer64k_u16
    "rba_Runtime Measurement Variable[28]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002288


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].loadPer64k_u16
    "rba_Runtime Measurement Variable[29]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022BC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].loadPer64k_u16
    "rba_Runtime Measurement Variable[30]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].loadPer64k_u16
    "rba_Runtime Measurement Variable[31]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002324


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].loadPer64k_u16
    "rba_Runtime Measurement Variable[32]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002358


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].loadPer64k_u16
    "rba_Runtime Measurement Variable[33]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000238C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].loadPer64k_u16
    "rba_Runtime Measurement Variable[34]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023C0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].loadPer64k_u16
    "rba_Runtime Measurement Variable[35]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].loadPer64k_u16
    "rba_Runtime Measurement Variable[36]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002428


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].loadPer64k_u16
    "rba_Runtime Measurement Variable[37]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000245C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].loadPer64k_u16
    "rba_Runtime Measurement Variable[38]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002490


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].loadPer64k_u16
    "rba_Runtime Measurement Variable[39]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024C4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].loadPer64k_u16
    "rba_Runtime Measurement Variable[40]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].loadPer64k_u16
    "rba_Runtime Measurement Variable[41]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000252C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].loadPer64k_u16
    "rba_Runtime Measurement Variable[42]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002560


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].loadPer64k_u16
    "rba_Runtime Measurement Variable[43]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002594


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].loadPer64k_u16
    "rba_Runtime Measurement Variable[44]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].loadPer64k_u16
    "rba_Runtime Measurement Variable[45]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].loadPer64k_u16
    "rba_Runtime Measurement Variable[46]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002630


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].loadPer64k_u16
    "rba_Runtime Measurement Variable[47]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002664


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].loadPer64k_u16
    "rba_Runtime Measurement Variable[48]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002698


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].loadPer64k_u16
    "rba_Runtime Measurement Variable[49]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].loadPer64k_u16
    "rba_Runtime Measurement Variable[50]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002700


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].loadPer64k_u16
    "rba_Runtime Measurement Variable[51]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002734


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].loadPer64k_u16
    "rba_Runtime Measurement Variable[52]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002768


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].loadPer64k_u16
    "rba_Runtime Measurement Variable[53]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000279C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].loadPer64k_u16
    "rba_Runtime Measurement Variable[54]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].loadPer64k_u16
    "rba_Runtime Measurement Variable[55]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002804


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].loadPer64k_u16
    "rba_Runtime Measurement Variable[56]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002838


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].loadPer64k_u16
    "rba_Runtime Measurement Variable[57]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000286C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].loadPer64k_u16
    "rba_Runtime Measurement Variable[58]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].loadPer64k_u16
    "rba_Runtime Measurement Variable[59]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].loadPer64k_u16
    "rba_Runtime Measurement Variable[60]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002908


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].loadPer64k_u16
    "rba_Runtime Measurement Variable[61]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000293C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].loadPer64k_u16
    "rba_Runtime Measurement Variable[62]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002970


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].loadPer64k_u16
    "rba_Runtime Measurement Variable[63]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].loadPer64k_u16
    "rba_Runtime Measurement Variable[64]/"
    UWORD
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Percentage
    1
    100
    0.0
    99.99847412109375
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[0].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001CDA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[1].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D0E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[2].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D42


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[3].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001D76


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[4].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DAA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[5].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001DDE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[6].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E12


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[7].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[7]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E46


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[8].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[8]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001E7A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[9].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[9]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EAE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[10].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[10]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001EE2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[11].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[11]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F16


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[12].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[12]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F4A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[13].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[13]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001F7E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[14].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[14]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FB2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[15].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[15]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001FE6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[16].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[16]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000201A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[17].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[17]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000204E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[18].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[18]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002082


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[19].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[19]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020B6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[20].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[20]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700020EA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[21].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[21]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000211E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[22].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[22]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002152


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[23].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[23]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002186


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[24].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[24]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021BA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[25].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[25]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700021EE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[26].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[26]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002222


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[27].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[27]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002256


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[28].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[28]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000228A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[29].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[29]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022BE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[30].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[30]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700022F2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[31].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[31]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002326


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[32].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[32]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000235A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[33].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[33]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000238E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[34].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[34]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023C2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[35].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[35]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700023F6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[36].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[36]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000242A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[37].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[37]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000245E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[38].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[38]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002492


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[39].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[39]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024C6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[40].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[40]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700024FA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[41].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[41]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000252E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[42].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[42]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002562


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[43].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[43]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002596


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[44].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[44]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025CA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[45].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[45]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700025FE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[46].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[46]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002632


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[47].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[47]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002666


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[48].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[48]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000269A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[49].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[49]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700026CE


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[50].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[50]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002702


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[51].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[51]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002736


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[52].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[52]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000276A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[53].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[53]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000279E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[54].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[54]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700027D2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[55].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[55]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002806


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[56].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[56]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000283A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[57].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[57]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000286E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[58].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[58]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028A2


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[59].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[59]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700028D6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[60].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[60]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000290A


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[61].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[61]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000293E


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[62].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[62]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70002972


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[63].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[63]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029A6


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_MonTask_ast[64].ctSampleProcessed_u8
    "rba_Runtime Measurement Variable[64]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x700029DA


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017CC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017F0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001814


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiAvrgRT_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001838


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017D0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017F4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001818


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMinRT_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000183C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017D4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017F8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000181C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMaxRT_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001840


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiAvrgCD_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017D8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiAvrgCD_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017FC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiAvrgCD_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001820


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiAvrgCD_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001844


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMinCD_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017DC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMinCD_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001800


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMinCD_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001824


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMinCD_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001848


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].tiMaxCD_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017E0


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].tiMaxCD_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001804


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].tiMaxCD_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001828


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].tiMaxCD_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000184C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017E4


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001808


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000182C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].ctCalls_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001850


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].results_ast[0].ctReentCalls_u32
    "rba_Runtime Measurement Variable/[0]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017E8


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].results_ast[0].ctReentCalls_u32
    "rba_Runtime Measurement Variable/[1]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000180C


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].results_ast[0].ctReentCalls_u32
    "rba_Runtime Measurement Variable/[2]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001830


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].results_ast[0].ctReentCalls_u32
    "rba_Runtime Measurement Variable/[3]/[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001854


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[0].tiSampleDuration_u32
    "rba_Runtime Measurement Variable/[0]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x700017EC


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[1].tiSampleDuration_u32
    "rba_Runtime Measurement Variable/[1]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001810


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[2].tiSampleDuration_u32
    "rba_Runtime Measurement Variable/[2]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001834


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.cores_ast[3].tiSampleDuration_u32
    "rba_Runtime Measurement Variable/[3]/"
    ULONG
    RB_RBA_rba_Runtime_CompuMethods_rba_Runtime_Time
    1
    100
    0.0
    4.294967295E7
    FORMAT "%5.0"
    ECU_ADDRESS 0x70001858


/end MEASUREMENT




/begin MEASUREMENT

    rba_Runtime_Output_st.ctSample_u8
    "rba_Runtime Measurement Variable/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x7000185C


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[0].Control_u8
    "State of configured ServicePoints[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A0


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[1].Control_u8
    "State of configured ServicePoints[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A4


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[2].Control_u8
    "State of configured ServicePoints[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A8


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[3].Control_u8
    "State of configured ServicePoints[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AC


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[0].ErrCntPre_u8
    "State of configured ServicePoints[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A1


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[1].ErrCntPre_u8
    "State of configured ServicePoints[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A5


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[2].ErrCntPre_u8
    "State of configured ServicePoints[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A9


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[3].ErrCntPre_u8
    "State of configured ServicePoints[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AD


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[0].ErrCntPost_u8
    "State of configured ServicePoints[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A2


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[1].ErrCntPost_u8
    "State of configured ServicePoints[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A6


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[2].ErrCntPost_u8
    "State of configured ServicePoints[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AA


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[3].ErrCntPost_u8
    "State of configured ServicePoints[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AE


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[0].FailedTriggerCounter_u8
    "State of configured ServicePoints[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A3


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[1].FailedTriggerCounter_u8
    "State of configured ServicePoints[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031A7


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[2].FailedTriggerCounter_u8
    "State of configured ServicePoints[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AB


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_ControlVar[3].FailedTriggerCounter_u8
    "State of configured ServicePoints[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600031AF


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_DelayedEcuInitialisation
    "time in ms the ECU initialization was delayed, because it was waiting for download of Bypass configuration"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.1"
    ECU_ADDRESS 0x6000C4C8


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_DummyVar
    "Dummy variable which can be stimulated at ServicePoint \"rba_Svbb_DummyActivate\" for activation of ServiceBasedBypass"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.1"
    ECU_ADDRESS 0x6000C4C7


/end MEASUREMENT




/begin MEASUREMENT

    rba_SvbbEtk_stEnable
    "Internal state of Service Based Bypass"
    UBYTE
    RB_RBA_rba_SvbbEtk_CompuMethods_rba_SvbbEtk_StateEnable_CM
    1
    100
    0.0
    255.
    FORMAT "%5.1"
    ECU_ADDRESS 0x6000C4C6


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_ObservationCounters_IrrSwOffTrigEngRun_Value_MP
    "ObservationCounter: Irregular Switch Off Counter Triggered by Engine Running"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x70030420

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "ObservationCounter: Irregular Switch Off Counter Triggered by Engine Running\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_ObservationCounters_IrrSwOff_Value_MP
    "ObservationCounter: Irregular SwitchOff Counter"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x70030421

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "ObservationCounter: Irregular SwitchOff Counter\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_CurrentState_MP
    "Current state of System Control"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_CompuMethod
    1
    100
    0.0
    7.
    FORMAT "%8.3"
    ECU_ADDRESS 0x70030424

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Current state of System Control\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_Prolongers_MP
    "Prolongers in PostDrive State"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x7003042B

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in PostDrive State\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutCounterBegin_MP
    "Timeout Counter for PostDrive Begin"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x70030427

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for PostDrive Begin\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutCounterEnd_MP
    "Timeout Counter for PostDrive End"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x70030425

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for PostDrive End\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutCounterNetwork_MP
    "Timeout Counter for PostDrive Network"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x70030426

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for PostDrive Network\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutHistoryBegin_MP
    "Timeout history for PostDrive Begin"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x7003042A

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for PostDrive Begin\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutHistoryEnd_MP
    "Timeout history for PostDrive End"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x70030428

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for PostDrive End\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_TimeoutHistoryNetwork_MP
    "Timeout history for PostDrive Network"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x70030429

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for PostDrive Network\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PostDrive_substate_MP
    "Sub-state of System Control state PostDrive"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PostDrive_CompuMethod
    1
    100
    0.0
    9.
    FORMAT "%8.3"
    ECU_ADDRESS 0x7003042C

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Sub-state of System Control state PostDrive\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PrepareDrive_substate_MP
    "Sub-state of System Control state PrepareDrive"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PrepareDrive_CompuMethod
    1
    100
    0.0
    3.
    FORMAT "%8.3"
    ECU_ADDRESS 0x7003042D

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Sub-state of System Control state PrepareDrive\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PrepareShutdown_Prolongers_MP
    "Prolongers in PrepareShutdown State"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x70030430

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in PrepareShutdown State\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PrepareShutdown_TimeoutCounterComplete_MP
    "Timeout Counter for PrepareShutdown Complete"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x7003042E

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for PrepareShutdown Complete\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PrepareShutdown_TimeoutHistoryComplete_MP
    "Timeout history for PrepareShutdown Complete"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x7003042F

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout history for PrepareShutdown Complete\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PrepareShutdown_substate_MP
    "Sub-state of System Control state PrepareShutdown"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_PrepareShutdown_CompuMethod
    1
    100
    0.0
    6.
    FORMAT "%8.3"
    ECU_ADDRESS 0x70030431

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Sub-state of System Control state PrepareShutdown\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_PreviousState_MP
    "Previous state of System Control"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_CompuMethod
    1
    100
    0.0
    7.
    FORMAT "%8.3"
    ECU_ADDRESS 0x70030423

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Previous state of System Control\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_Prolongers_MP
    "Prolongers in Wait State"
    UBYTE
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_Prolongers_CompuMethod
    1
    100
    0.0
    255.
    FORMAT "%8.3"
    ECU_ADDRESS 0x7003043E

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Prolongers in Wait Stat\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION

    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_TimeoutCounterDelay_MP
    "Timeout Counter for Wait Delay"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x70030438

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for Wait Delay\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_TimeoutCounterNetwork_MP
    "Timeout Counter for Wait Network"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x70030439

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for Wait Network\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

    rba_SyC_States_Wait_TimeoutCounterProlong_MP
    "Timeout Counter for Wait Prolong"
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.0
    ECU_ADDRESS 0x7003043A

    /begin ANNOTATION

    ANNOTATION_LABEL "Description (coming from AUTOSAR DESC field)"

    /begin ANNOTATION_TEXT
     "Timeout Counter for Wait Prolong\r\n"
    /end ANNOTATION_TEXT

  /end ANNOTATION



/end MEASUREMENT




/begin MEASUREMENT

