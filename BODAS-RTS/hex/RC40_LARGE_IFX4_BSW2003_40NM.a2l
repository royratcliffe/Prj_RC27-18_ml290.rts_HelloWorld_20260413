/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_UBRM24_MON_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80806314
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VDD5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80806318
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VDD5_IN_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x8080631C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VPR6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80806320
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VSS3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80806324
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VSS4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80806328
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_Temp1_HTErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x8080632C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_Temp1_HTWarn_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80806330
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_Temp2_HTErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80806334
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_Temp2_HTWarn_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80806338
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x8080633C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80806340
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VDD5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80806344
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VDD5_IN_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80806348
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VPR6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x8080634C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VSS3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80806350
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VSS4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80806354
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA01OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA01OL"
    VALUE
    0x80806358
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA01OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA01OT"
    VALUE
    0x8080635C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA01SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA01SCB"
    VALUE
    0x80806360
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA01SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA01SCG"
    VALUE
    0x80806364
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02OL"
    VALUE
    0x80806368
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02OR"
    VALUE
    0x8080636C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02OT"
    VALUE
    0x80806370
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02SCB"
    VALUE
    0x80806374
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02SCG"
    VALUE
    0x80806378
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03OL"
    VALUE
    0x8080637C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03OT"
    VALUE
    0x80806380
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03SCB"
    VALUE
    0x80806384
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03SCG"
    VALUE
    0x80806388
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04OL"
    VALUE
    0x8080638C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04OT"
    VALUE
    0x80806390
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04SCB"
    VALUE
    0x80806394
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04SCG"
    VALUE
    0x80806398
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05OL"
    VALUE
    0x8080639C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05OR"
    VALUE
    0x808063A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05OT"
    VALUE
    0x808063A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05SCB"
    VALUE
    0x808063A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05SCG"
    VALUE
    0x808063AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA06OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA06OL"
    VALUE
    0x808063B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA06OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA06OR"
    VALUE
    0x808063B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA06OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA06OT"
    VALUE
    0x808063B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA06SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA06SCB"
    VALUE
    0x808063BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA06SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA06SCG"
    VALUE
    0x808063C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07OL"
    VALUE
    0x808063C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07OT"
    VALUE
    0x808063C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07SCB"
    VALUE
    0x808063CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07SCG"
    VALUE
    0x808063D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08OL"
    VALUE
    0x808063D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08OT"
    VALUE
    0x808063D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08SCB"
    VALUE
    0x808063DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08SCG"
    VALUE
    0x808063E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09OL"
    VALUE
    0x808063E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09OR"
    VALUE
    0x808063E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09OT"
    VALUE
    0x808063EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09SCB"
    VALUE
    0x808063F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09SCG"
    VALUE
    0x808063F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10OL"
    VALUE
    0x808063F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10OT"
    VALUE
    0x808063FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10SCB"
    VALUE
    0x80806400
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10SCG"
    VALUE
    0x80806404
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA11OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA11OL"
    VALUE
    0x80806408
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA11OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA11OT"
    VALUE
    0x8080640C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA11SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA11SCB"
    VALUE
    0x80806410
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA11SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA11SCG"
    VALUE
    0x80806414
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA12OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA12OR"
    VALUE
    0x80806418
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA12SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA12SCB"
    VALUE
    0x8080641C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA12SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA12SCG"
    VALUE
    0x80806420
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA16OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA16OL"
    VALUE
    0x80806424
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA16OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA16OT"
    VALUE
    0x80806428
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA16SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA16SCB"
    VALUE
    0x8080642C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA16SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA16SCG"
    VALUE
    0x80806430
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17OL"
    VALUE
    0x80806434
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17OR"
    VALUE
    0x80806438
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17OT"
    VALUE
    0x8080643C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17SCB"
    VALUE
    0x80806440
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17SCG"
    VALUE
    0x80806444
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18OL"
    VALUE
    0x80806448
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18OT"
    VALUE
    0x8080644C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18SCB"
    VALUE
    0x80806450
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18SCG"
    VALUE
    0x80806454
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19OL"
    VALUE
    0x80806458
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19OR"
    VALUE
    0x8080645C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19OT"
    VALUE
    0x80806460
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19SCB"
    VALUE
    0x80806464
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19SCG"
    VALUE
    0x80806468
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20OL"
    VALUE
    0x8080646C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20OR"
    VALUE
    0x80806470
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20OT"
    VALUE
    0x80806474
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20SCB"
    VALUE
    0x80806478
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20SCG"
    VALUE
    0x8080647C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31OL"
    VALUE
    0x80806480
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31OR"
    VALUE
    0x80806484
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31OT"
    VALUE
    0x80806488
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31SCB"
    VALUE
    0x8080648C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31SCG"
    VALUE
    0x80806490
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32OL"
    VALUE
    0x80806494
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32OR"
    VALUE
    0x80806498
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32OT"
    VALUE
    0x8080649C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32SCB"
    VALUE
    0x808064A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32SCG"
    VALUE
    0x808064A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33OL"
    VALUE
    0x808064A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33OR"
    VALUE
    0x808064AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33OT"
    VALUE
    0x808064B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33SCB"
    VALUE
    0x808064B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33SCG"
    VALUE
    0x808064B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34OL"
    VALUE
    0x808064BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34OR"
    VALUE
    0x808064C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34OT"
    VALUE
    0x808064C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34SCB"
    VALUE
    0x808064C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34SCG"
    VALUE
    0x808064CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35OL"
    VALUE
    0x808064D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35OR"
    VALUE
    0x808064D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35OT"
    VALUE
    0x808064D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35SCB"
    VALUE
    0x808064DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35SCG"
    VALUE
    0x808064E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46OL"
    VALUE
    0x808064E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46OR"
    VALUE
    0x808064E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46OT"
    VALUE
    0x808064EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46SCB"
    VALUE
    0x808064F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46SCG"
    VALUE
    0x808064F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47OL"
    VALUE
    0x808064F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47OR"
    VALUE
    0x808064FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47OT"
    VALUE
    0x80806500
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47SCB"
    VALUE
    0x80806504
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47SCG"
    VALUE
    0x80806508
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48OL"
    VALUE
    0x8080650C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48OR"
    VALUE
    0x80806510
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48OT"
    VALUE
    0x80806514
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48SCB"
    VALUE
    0x80806518
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48SCG"
    VALUE
    0x8080651C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA49OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA49OL"
    VALUE
    0x80806520
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA49OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA49OT"
    VALUE
    0x80806524
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA49SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA49SCB"
    VALUE
    0x80806528
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA49SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA49SCG"
    VALUE
    0x8080652C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA50OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA50OL"
    VALUE
    0x80806530
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA50OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA50OT"
    VALUE
    0x80806534
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA50SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA50SCB"
    VALUE
    0x80806538
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA50SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA50SCG"
    VALUE
    0x8080653C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51OL"
    VALUE
    0x80806540
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51OR"
    VALUE
    0x80806544
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51OT"
    VALUE
    0x80806548
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51SCB"
    VALUE
    0x8080654C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51SCG"
    VALUE
    0x80806550
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52OL"
    VALUE
    0x80806554
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52OR"
    VALUE
    0x80806558
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52OT"
    VALUE
    0x8080655C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52SCB"
    VALUE
    0x80806560
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52SCG"
    VALUE
    0x80806564
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53OL"
    VALUE
    0x80806568
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53OR"
    VALUE
    0x8080656C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53OT"
    VALUE
    0x80806570
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53SCB"
    VALUE
    0x80806574
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53SCG"
    VALUE
    0x80806578
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54OL"
    VALUE
    0x8080657C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54OR"
    VALUE
    0x80806580
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54OT"
    VALUE
    0x80806584
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54SCB"
    VALUE
    0x80806588
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54SCG"
    VALUE
    0x8080658C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA55OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA55OL"
    VALUE
    0x80806590
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA55OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA55OT"
    VALUE
    0x80806594
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA55SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA55SCB"
    VALUE
    0x80806598
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA55SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA55SCG"
    VALUE
    0x8080659C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA56OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA56OL"
    VALUE
    0x808065A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA56OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA56OT"
    VALUE
    0x808065A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA56SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA56SCB"
    VALUE
    0x808065A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA56SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA56SCG"
    VALUE
    0x808065AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA58OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA58OL"
    VALUE
    0x808065B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA58OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA58OT"
    VALUE
    0x808065B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA58SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA58SCB"
    VALUE
    0x808065B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA58SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA58SCG"
    VALUE
    0x808065BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07OL"
    VALUE
    0x808065C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07OR"
    VALUE
    0x808065C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07OT"
    VALUE
    0x808065C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07SCB"
    VALUE
    0x808065CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07SCG"
    VALUE
    0x808065D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08OL"
    VALUE
    0x808065D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08OR"
    VALUE
    0x808065D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08OT"
    VALUE
    0x808065DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08SCB"
    VALUE
    0x808065E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08SCG"
    VALUE
    0x808065E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09OL"
    VALUE
    0x808065E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09OR"
    VALUE
    0x808065EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09OT"
    VALUE
    0x808065F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09SCB"
    VALUE
    0x808065F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09SCG"
    VALUE
    0x808065F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12OL"
    VALUE
    0x808065FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12OT"
    VALUE
    0x80806600
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12SCB"
    VALUE
    0x80806604
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12SCG"
    VALUE
    0x80806608
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13OL"
    VALUE
    0x8080660C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13OT"
    VALUE
    0x80806610
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13SCB"
    VALUE
    0x80806614
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13SCG"
    VALUE
    0x80806618
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14OL"
    VALUE
    0x8080661C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14OR"
    VALUE
    0x80806620
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14OT"
    VALUE
    0x80806624
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14SCB"
    VALUE
    0x80806628
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14SCG"
    VALUE
    0x8080662C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15OL"
    VALUE
    0x80806630
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15OR"
    VALUE
    0x80806634
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15OT"
    VALUE
    0x80806638
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15SCB"
    VALUE
    0x8080663C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15SCG"
    VALUE
    0x80806640
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16OL"
    VALUE
    0x80806644
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16OR"
    VALUE
    0x80806648
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16OT"
    VALUE
    0x8080664C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16SCB"
    VALUE
    0x80806650
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16SCG"
    VALUE
    0x80806654
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17OL"
    VALUE
    0x80806658
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17OR"
    VALUE
    0x8080665C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17OT"
    VALUE
    0x80806660
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17SCB"
    VALUE
    0x80806664
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17SCG"
    VALUE
    0x80806668
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK25OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK25OR"
    VALUE
    0x8080666C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK25SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK25SCB"
    VALUE
    0x80806670
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK25SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK25SCG"
    VALUE
    0x80806674
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29OL"
    VALUE
    0x80806678
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29OR"
    VALUE
    0x8080667C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29OT"
    VALUE
    0x80806680
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29SCB"
    VALUE
    0x80806684
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29SCG"
    VALUE
    0x80806688
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51OL"
    VALUE
    0x8080668C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51OT"
    VALUE
    0x80806690
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51SCB"
    VALUE
    0x80806694
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51SCG"
    VALUE
    0x80806698
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK62OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK62OR"
    VALUE
    0x8080669C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK62SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK62SCB"
    VALUE
    0x808066A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK62SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK62SCG"
    VALUE
    0x808066A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73OL"
    VALUE
    0x808066A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73OR"
    VALUE
    0x808066AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73OT"
    VALUE
    0x808066B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73SCB"
    VALUE
    0x808066B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73SCG"
    VALUE
    0x808066B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK80OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK80OL"
    VALUE
    0x808066BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK80OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK80OT"
    VALUE
    0x808066C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK80SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK80SCB"
    VALUE
    0x808066C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK80SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK80SCG"
    VALUE
    0x808066C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK81OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK81OL"
    VALUE
    0x808066CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK81OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK81OT"
    VALUE
    0x808066D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK81SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK81SCB"
    VALUE
    0x808066D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK81SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK81SCG"
    VALUE
    0x808066D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK82OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK82OL"
    VALUE
    0x808066DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK82OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK82OT"
    VALUE
    0x808066E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK82SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK82SCB"
    VALUE
    0x808066E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK82SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK82SCG"
    VALUE
    0x808066E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK83OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK83OL"
    VALUE
    0x808066EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK83OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK83OT"
    VALUE
    0x808066F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK83SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK83SCB"
    VALUE
    0x808066F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK83SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK83SCG"
    VALUE
    0x808066F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK84OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK84OL"
    VALUE
    0x808066FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK84OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK84OT"
    VALUE
    0x80806700
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK84SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK84SCB"
    VALUE
    0x80806704
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK84SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK84SCG"
    VALUE
    0x80806708
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK85OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK85OL"
    VALUE
    0x8080670C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK85OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK85OT"
    VALUE
    0x80806710
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK85SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK85SCB"
    VALUE
    0x80806714
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK85SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK85SCG"
    VALUE
    0x80806718
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK86OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK86OL"
    VALUE
    0x8080671C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK86OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK86OT"
    VALUE
    0x80806720
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK86SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK86SCB"
    VALUE
    0x80806724
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK86SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK86SCG"
    VALUE
    0x80806728
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK87OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK87OL"
    VALUE
    0x8080672C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK87OT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK87OT"
    VALUE
    0x80806730
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK87SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK87SCB"
    VALUE
    0x80806734
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK87SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK87SCG"
    VALUE
    0x80806738
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_DSMDummy_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_DSMDummy"
    VALUE
    0x8080673C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8000_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8000"
    VALUE
    0x80806740
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8001_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8001"
    VALUE
    0x80806744
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8002_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8002"
    VALUE
    0x80806748
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8003_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8003"
    VALUE
    0x8080674C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8004_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8004"
    VALUE
    0x80806750
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8005_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8005"
    VALUE
    0x80806754
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8006_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8006"
    VALUE
    0x80806758
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8007_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8007"
    VALUE
    0x8080675C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8008_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8008"
    VALUE
    0x80806760
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8009_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8009"
    VALUE
    0x80806764
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x800a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800a"
    VALUE
    0x80806768
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x800b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800b"
    VALUE
    0x8080676C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x800c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800c"
    VALUE
    0x80806770
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x800d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800d"
    VALUE
    0x80806774
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x800e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800e"
    VALUE
    0x80806778
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x800f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800f"
    VALUE
    0x8080677C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8010_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8010"
    VALUE
    0x80806780
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8011_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8011"
    VALUE
    0x80806784
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8012_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8012"
    VALUE
    0x80806788
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8013_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8013"
    VALUE
    0x8080678C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8014_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8014"
    VALUE
    0x80806790
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8015_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8015"
    VALUE
    0x80806794
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8016_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8016"
    VALUE
    0x80806798
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8017_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8017"
    VALUE
    0x8080679C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8018_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8018"
    VALUE
    0x808067A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8019_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8019"
    VALUE
    0x808067A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x801a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801a"
    VALUE
    0x808067A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x801b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801b"
    VALUE
    0x808067AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x801c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801c"
    VALUE
    0x808067B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x801d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801d"
    VALUE
    0x808067B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x801e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801e"
    VALUE
    0x808067B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x801f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801f"
    VALUE
    0x808067BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8020_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8020"
    VALUE
    0x808067C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8021_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8021"
    VALUE
    0x808067C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8022_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8022"
    VALUE
    0x808067C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8023_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8023"
    VALUE
    0x808067CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8024_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8024"
    VALUE
    0x808067D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8025_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8025"
    VALUE
    0x808067D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8026_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8026"
    VALUE
    0x808067D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8027_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8027"
    VALUE
    0x808067DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8028_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8028"
    VALUE
    0x808067E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8029_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8029"
    VALUE
    0x808067E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x802a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802a"
    VALUE
    0x808067E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x802b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802b"
    VALUE
    0x808067EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x802c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802c"
    VALUE
    0x808067F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x802d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802d"
    VALUE
    0x808067F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x802e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802e"
    VALUE
    0x808067F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x802f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802f"
    VALUE
    0x808067FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8030_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8030"
    VALUE
    0x80806800
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8031_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8031"
    VALUE
    0x80806804
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8032_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8032"
    VALUE
    0x80806808
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8033_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8033"
    VALUE
    0x8080680C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8034_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8034"
    VALUE
    0x80806810
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8035_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8035"
    VALUE
    0x80806814
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8036_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8036"
    VALUE
    0x80806818
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8037_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8037"
    VALUE
    0x8080681C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8038_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8038"
    VALUE
    0x80806820
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8039_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8039"
    VALUE
    0x80806824
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x803a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803a"
    VALUE
    0x80806828
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x803b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803b"
    VALUE
    0x8080682C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x803c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803c"
    VALUE
    0x80806830
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x803d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803d"
    VALUE
    0x80806834
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x803e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803e"
    VALUE
    0x80806838
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x803f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803f"
    VALUE
    0x8080683C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8040_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8040"
    VALUE
    0x80806840
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8041_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8041"
    VALUE
    0x80806844
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8042_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8042"
    VALUE
    0x80806848
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8043_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8043"
    VALUE
    0x8080684C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8044_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8044"
    VALUE
    0x80806850
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8045_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8045"
    VALUE
    0x80806854
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8046_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8046"
    VALUE
    0x80806858
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8047_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8047"
    VALUE
    0x8080685C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8048_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8048"
    VALUE
    0x80806860
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8049_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8049"
    VALUE
    0x80806864
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x804a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804a"
    VALUE
    0x80806868
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x804b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804b"
    VALUE
    0x8080686C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x804c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804c"
    VALUE
    0x80806870
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x804d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804d"
    VALUE
    0x80806874
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x804e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804e"
    VALUE
    0x80806878
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x804f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804f"
    VALUE
    0x8080687C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8050_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8050"
    VALUE
    0x80806880
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8051_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8051"
    VALUE
    0x80806884
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8052_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8052"
    VALUE
    0x80806888
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8053_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8053"
    VALUE
    0x8080688C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8054_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8054"
    VALUE
    0x80806890
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8055_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8055"
    VALUE
    0x80806894
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8056_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8056"
    VALUE
    0x80806898
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8057_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8057"
    VALUE
    0x8080689C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8058_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8058"
    VALUE
    0x808068A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8059_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8059"
    VALUE
    0x808068A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x805a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805a"
    VALUE
    0x808068A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x805b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805b"
    VALUE
    0x808068AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x805c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805c"
    VALUE
    0x808068B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x805d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805d"
    VALUE
    0x808068B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x805e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805e"
    VALUE
    0x808068B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x805f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805f"
    VALUE
    0x808068BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8060_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8060"
    VALUE
    0x808068C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8061_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8061"
    VALUE
    0x808068C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8062_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8062"
    VALUE
    0x808068C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8C01_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8C01"
    VALUE
    0x808068CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8C02_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8C02"
    VALUE
    0x808068D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8C03_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8C03"
    VALUE
    0x808068D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetDataNoBuf_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x808068D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetDataParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetDataParam"
    VALUE
    0x808068DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetDataboxNoInit_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x808068E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x808068E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetRxBufStatusParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x808068E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetStatusParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetStatusParam"
    VALUE
    0x808068EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canGetTxBufStatusParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x808068F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canInitParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canInitParam"
    VALUE
    0x808068F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canInitRxDataboxOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x808068F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canInitRxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x808068FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canInitTxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80806900
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canIpduGroupControl_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80806904
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canIsDataboxFreeNoInit_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80806908
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canIsDataboxFreeParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x8080690C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canIsTxEmptyParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80806910
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegBusOffCallbInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80806914
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegBusOffCallbParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80806918
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxBufInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x8080691C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxBufOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80806920
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxBufParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80806924
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxCallbInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80806928
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxCallbParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x8080692C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxDataboxInvNumb_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80806930
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxDataboxInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80806934
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxDataboxOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80806938
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegRxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x8080693C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxBufInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80806940
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxBufOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80806944
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxBufParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80806948
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxDataboxInvNumb_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x8080694C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxDataboxInvState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80806950
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxDataboxOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x80806954
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canRegTxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80806958
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canResetTxBufParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x8080695C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canSendDataBufOvfl_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80806960
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canSendDataParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canSendDataParam"
    VALUE
    0x80806964
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canSendDataboxNoInit_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80806968
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canSendDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x8080696C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canSetTxCycleParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80806970
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canStartParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canStartParam"
    VALUE
    0x80806974
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_canStopParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_canStopParam"
    VALUE
    0x80806978
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_can_ClearIpduGroup_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x8080697C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_can_ReceiveSignal_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80806980
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_can_SendSignal_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_can_SendSignal"
    VALUE
    0x80806984
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_can_SetIpduGroup_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80806988
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmDTCJ1939_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x8080698C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmDelDTCJ1939_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80806990
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmDelErrors_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmDelErrors"
    VALUE
    0x80806994
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmGetDFES_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmGetDFES"
    VALUE
    0x80806998
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmGetDTCJ1939_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x8080699C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmGetErrors_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmGetErrors"
    VALUE
    0x808069A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmGetNumErrors_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x808069A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmInitQueueOverflow_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x808069A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmNumDTCJ1939_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x808069AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmTesterror_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmTesterror"
    VALUE
    0x808069B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmUpdateDebError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x808069B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmUpdateError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmUpdateError"
    VALUE
    0x808069B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmgetDFCStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x808069BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_dsmtestErrorDFC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x808069C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAi"
    VALUE
    0x808069C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAic_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAic"
    VALUE
    0x808069C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAicCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAicCfg"
    VALUE
    0x808069CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAicGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAicGetStatus"
    VALUE
    0x808069D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAid_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAid"
    VALUE
    0x808069D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAidCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAidCfg"
    VALUE
    0x808069D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAiv_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAiv"
    VALUE
    0x808069DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAivCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAivCfg"
    VALUE
    0x808069E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inAivGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inAivGetStatus"
    VALUE
    0x808069E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inDi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inDi"
    VALUE
    0x808069E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inFi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inFi"
    VALUE
    0x808069EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inFiCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inFiCfg"
    VALUE
    0x808069F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inFiGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inFiGetStatus"
    VALUE
    0x808069F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inFi_Buffered_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inFi_Buffered"
    VALUE
    0x808069F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inPhase_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inPhase"
    VALUE
    0x808069FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inPhaseGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80806A00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inPhaseResetCounter_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80806A04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inRi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inRi"
    VALUE
    0x80806A08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inRiCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inRiCfg"
    VALUE
    0x80806A0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inRiCfgTemp_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x80806A10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inRiGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inRiGetStatus"
    VALUE
    0x80806A14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inRiGetTemp_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inRiGetTemp"
    VALUE
    0x80806A18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentCopyFDFifo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80806A1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentDisable_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentDisable"
    VALUE
    0x80806A20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentEnable_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentEnable"
    VALUE
    0x80806A24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentGetErrorStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80806A28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentGetFD_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentGetFD"
    VALUE
    0x80806A2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentGetSD_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentGetSD"
    VALUE
    0x80806A30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentGetSDDatabox_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80806A34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentGetStatus"
    VALUE
    0x80806A38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentInitSDDatabox_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80806A3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentRegisterCopyFDFifo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80806A40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentRegisterFDFifo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x80806A44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inSentRegisterSDDataboxes_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x80806A48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusCanRxBufferOverflow_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x80806A4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusGetCaAddrParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x80806A50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusGetDiagnosticParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x80806A54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x80806A58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusGetStatusParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80806A5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitCommCaMissing_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80806A60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitCommParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80806A64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitCommState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommState"
    VALUE
    0x80806A68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitDiagnosticParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80806A6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitFailureListParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80806A70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitRxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80806A74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusInitTxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80806A78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegRxDataboxOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80806A7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegRxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80806A80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegRxDataboxState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80806A84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegTxDataboxOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80806A88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegTxDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80806A8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegTxDataboxState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80806A90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x80806A94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegisterInstancesOverlap_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x80806A98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegisterInstancesParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80806A9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusRegisterInstancesState_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80806AA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSendDataboxParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80806AA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSendRequestPGNParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80806AA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaAddrCaUsed_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80806AAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaAddrComm_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80806AB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaAddrInvCan_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80806AB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaAddrParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80806AB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaInfoParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80806ABC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSetCaNameParam_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80806AC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_isobusSftyCanTxErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80806AC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_ReceiveSignal_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80806AC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_SendSignal_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_SendSignal"
    VALUE
    0x80806ACC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_getStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_getStatus"
    VALUE
    0x80806AD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_gotoSleep_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80806AD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_scheduleRequest_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80806AD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_lin_wakeUp_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_lin_wakeUp"
    VALUE
    0x80806ADC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memFlsCfgShr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80806AE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memGetStatus"
    VALUE
    0x80806AE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memMarkBlock_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memMarkBlock"
    VALUE
    0x80806AE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadApi1Error_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80806AEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadApi2Error_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80806AF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadBlock_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadBlock"
    VALUE
    0x80806AF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadCalibInputError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80806AF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadCalibOuputError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80806AFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memReadSystemError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memReadSystemError"
    VALUE
    0x80806B00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_memWriteBlock_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_memWriteBlock"
    VALUE
    0x80806B04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_moOV_FirstConstADC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80806B08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_moOV_SecondConstADC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80806B0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_moUV_FirstConstADC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80806B10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_moUV_SecondConstADC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80806B14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_INH_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_INH"
    VALUE
    0x80806B18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_INHLatch_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_INHLatch"
    VALUE
    0x80806B1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_adcPDD_fail_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80806B20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_memoryProtection_err_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80806B24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02OC"
    VALUE
    0x80806B28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA02Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA02Unintended"
    VALUE
    0x80806B2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03OC"
    VALUE
    0x80806B30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA03Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA03Unintended"
    VALUE
    0x80806B34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04OC"
    VALUE
    0x80806B38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA04Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA04Unintended"
    VALUE
    0x80806B3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05OC"
    VALUE
    0x80806B40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA05Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA05Unintended"
    VALUE
    0x80806B44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07OC"
    VALUE
    0x80806B48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA07Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA07Unintended"
    VALUE
    0x80806B4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08OC"
    VALUE
    0x80806B50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA08Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA08Unintended"
    VALUE
    0x80806B54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09OC"
    VALUE
    0x80806B58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA09Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA09Unintended"
    VALUE
    0x80806B5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10OC"
    VALUE
    0x80806B60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA10Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA10Unintended"
    VALUE
    0x80806B64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17OC"
    VALUE
    0x80806B68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA17Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA17Unintended"
    VALUE
    0x80806B6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18OC"
    VALUE
    0x80806B70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA18Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA18Unintended"
    VALUE
    0x80806B74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19OC"
    VALUE
    0x80806B78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA19Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA19Unintended"
    VALUE
    0x80806B7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20OC"
    VALUE
    0x80806B80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA20Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA20Unintended"
    VALUE
    0x80806B84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31OC"
    VALUE
    0x80806B88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA31Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA31Unintended"
    VALUE
    0x80806B8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32OC"
    VALUE
    0x80806B90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA32Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA32Unintended"
    VALUE
    0x80806B94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33OC"
    VALUE
    0x80806B98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA33Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA33Unintended"
    VALUE
    0x80806B9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34OC"
    VALUE
    0x80806BA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA34Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA34Unintended"
    VALUE
    0x80806BA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35OC"
    VALUE
    0x80806BA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA35Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA35Unintended"
    VALUE
    0x80806BAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46OC"
    VALUE
    0x80806BB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA46Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA46Unintended"
    VALUE
    0x80806BB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47OC"
    VALUE
    0x80806BB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA47Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA47Unintended"
    VALUE
    0x80806BBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48OC"
    VALUE
    0x80806BC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA48Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA48Unintended"
    VALUE
    0x80806BC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51OC"
    VALUE
    0x80806BC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA51Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA51Unintended"
    VALUE
    0x80806BCC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52OC"
    VALUE
    0x80806BD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA52Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA52Unintended"
    VALUE
    0x80806BD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53OC"
    VALUE
    0x80806BD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA53Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA53Unintended"
    VALUE
    0x80806BDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54OC"
    VALUE
    0x80806BE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outA54Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outA54Unintended"
    VALUE
    0x80806BE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAov_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAov"
    VALUE
    0x80806BE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAovCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAovCfg"
    VALUE
    0x80806BEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAovCfgPI_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAovCfgPI"
    VALUE
    0x80806BF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAovGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAovGetStatus"
    VALUE
    0x80806BF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAovGetVoltage_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80806BF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outAovResetError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outAovResetError"
    VALUE
    0x80806BFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDo"
    VALUE
    0x80806C00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDoCfgPwrLs_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80806C04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDoDisable_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDoDisable"
    VALUE
    0x80806C08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDoGetCurrent_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80806C0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDoGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDoGetStatus"
    VALUE
    0x80806C10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outDoResetError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outDoResetError"
    VALUE
    0x80806C14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07OC"
    VALUE
    0x80806C18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK07Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK07Unintended"
    VALUE
    0x80806C1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08OC"
    VALUE
    0x80806C20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK08Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK08Unintended"
    VALUE
    0x80806C24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09OC"
    VALUE
    0x80806C28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK09Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK09Unintended"
    VALUE
    0x80806C2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12OC"
    VALUE
    0x80806C30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK12Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK12Unintended"
    VALUE
    0x80806C34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13OC"
    VALUE
    0x80806C38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK13Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK13Unintended"
    VALUE
    0x80806C3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14OC"
    VALUE
    0x80806C40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK14Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK14Unintended"
    VALUE
    0x80806C44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15OC"
    VALUE
    0x80806C48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK15Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK15Unintended"
    VALUE
    0x80806C4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16OC"
    VALUE
    0x80806C50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK16Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK16Unintended"
    VALUE
    0x80806C54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17OC"
    VALUE
    0x80806C58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK17Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK17Unintended"
    VALUE
    0x80806C5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29OC"
    VALUE
    0x80806C60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK29Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK29Unintended"
    VALUE
    0x80806C64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51OC"
    VALUE
    0x80806C68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK51Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK51Unintended"
    VALUE
    0x80806C6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73OC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73OC"
    VALUE
    0x80806C70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outK73Unintended_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outK73Unintended"
    VALUE
    0x80806C74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPo"
    VALUE
    0x80806C78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoCfg"
    VALUE
    0x80806C7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoCfgPeriod_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80806C80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoCfgPwrLs_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80806C84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoDisable_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoDisable"
    VALUE
    0x80806C88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoGetCurrent_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80806C8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoGetStatus"
    VALUE
    0x80806C90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoResetError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoResetError"
    VALUE
    0x80806C94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPoc_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPoc"
    VALUE
    0x80806C98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPocCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPocCfg"
    VALUE
    0x80806C9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPocCfgDither_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPocCfgDither"
    VALUE
    0x80806CA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPocCfgPI_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPocCfgPI"
    VALUE
    0x80806CA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPod_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPod"
    VALUE
    0x80806CA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPodCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPodCfg"
    VALUE
    0x80806CAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_outPodCfgPeriod_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80806CB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_rsmFfiApiCallErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80806CB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safout_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safout"
    VALUE
    0x80806CB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutCfg"
    VALUE
    0x80806CBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1"
    VALUE
    0x80806CC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10"
    VALUE
    0x80806CC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl10Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80806CC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl10OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80806CCC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11"
    VALUE
    0x80806CD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl11Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80806CD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl11OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80806CD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl12_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12"
    VALUE
    0x80806CDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl12Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80806CE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl12OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80806CE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13"
    VALUE
    0x80806CE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl13Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80806CEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl13OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80806CF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14"
    VALUE
    0x80806CF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl14Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80806CF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl14OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80806CFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl15_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15"
    VALUE
    0x80806D00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl15Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80806D04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl15OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80806D08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl16_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16"
    VALUE
    0x80806D0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl16Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80806D10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl16OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80806D14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl17_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17"
    VALUE
    0x80806D18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl17Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80806D1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl17OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80806D20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl18_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18"
    VALUE
    0x80806D24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl18Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80806D28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl18OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80806D2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl1Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80806D30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl1OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80806D34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2"
    VALUE
    0x80806D38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl2Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80806D3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl2OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80806D40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3"
    VALUE
    0x80806D44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl3Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80806D48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl3OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80806D4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4"
    VALUE
    0x80806D50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl4Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x80806D54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl4OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80806D58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5"
    VALUE
    0x80806D5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl5Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80806D60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl5OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80806D64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6"
    VALUE
    0x80806D68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl6Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80806D6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl6OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80806D70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7"
    VALUE
    0x80806D74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl7Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80806D78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl7OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80806D7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8"
    VALUE
    0x80806D80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl8Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80806D84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl8OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80806D88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl9_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9"
    VALUE
    0x80806D8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl9Dev_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80806D90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutChnl9OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x80806D94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutDevError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutDevError"
    VALUE
    0x80806D98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutGetStatus_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutGetStatus"
    VALUE
    0x80806D9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutIgnoreError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80806DA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutResetError_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutResetError"
    VALUE
    0x80806DA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safoutUnlock_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safoutUnlock"
    VALUE
    0x80806DA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_safout_cfgDiag_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80806DAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secAccessDenied_RC_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80806DB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secAccessDenied_WDBI_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80806DB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secEvalRespKey_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secEvalRespKey"
    VALUE
    0x80806DB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secFlashingFailure_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secFlashingFailure"
    VALUE
    0x80806DBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secGetLevel_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secGetLevel"
    VALUE
    0x80806DC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secGetRnd_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secGetRnd"
    VALUE
    0x80806DC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secGetSeed_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secGetSeed"
    VALUE
    0x80806DC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secInvalidPassword_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secInvalidPassword"
    VALUE
    0x80806DCC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secIsRequestAllowed_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80806DD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secResetLevel_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secResetLevel"
    VALUE
    0x80806DD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secSaveSecret_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secSaveSecret"
    VALUE
    0x80806DD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_secSetLevel_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_secSetLevel"
    VALUE
    0x80806DDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysAit_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysAit"
    VALUE
    0x80806DE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysAiv_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysAiv"
    VALUE
    0x80806DE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysDi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysDi"
    VALUE
    0x80806DE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysDo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysDo"
    VALUE
    0x80806DEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysGetVss_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysGetVss"
    VALUE
    0x80806DF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysInit_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysInit"
    VALUE
    0x80806DF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysOperHrIntegrityErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80806DF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysOperHrsSaturated_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80806DFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sysSetVss_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sysSetVss"
    VALUE
    0x80806E00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sys_coreload_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sys_coreload"
    VALUE
    0x80806E04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_sys_taskload_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_sys_taskload"
    VALUE
    0x80806E08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VSS1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80806E0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_VSS2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80806E10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VSS1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80806E14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_UV_VSS2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x80806E18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80806E1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80806E20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80806E24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80806E28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80806E2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_CAN_E_TIMEOUT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80806E30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80806E34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80806E38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80806E3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80806E40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80806E44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80806E48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_LIN_E_TIMEOUT_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80806E4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_MultiStackTrace_Threshold_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80806E50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_ETH_E_ACCESS_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x80806E54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x80806E58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80806E5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_MRly_Diag_Stk_Event_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80806E60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80806E64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_MemDiag_MemReadErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80806E68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_MemDiag_MemWrErr_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80806E6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80806E70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_T15_Diag_ComInVld_Event_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80806E74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80806E78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80806E7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80806E80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80806E84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80806E88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80806E8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80806E90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x80806E94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x80806E98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_22_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80806E9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_23_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80806EA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80806EA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80806EA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80806EAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM0_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80806EB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM10_16_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80806EB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM10_17_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80806EB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM10_21_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80806EBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80806EC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80806EC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80806EC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80806ECC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80806ED0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x80806ED4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x80806ED8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM11_9_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80806EDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80806EE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80806EE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80806EE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80806EEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80806EF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80806EF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80806EF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_22_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80806EFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_23_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80806F00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80806F04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80806F08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80806F0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM1_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80806F10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM21_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x80806F14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM21_16_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x80806F18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM21_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80806F1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80806F20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80806F24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80806F28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80806F2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80806F30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80806F34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_22_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80806F38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_23_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80806F3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80806F40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80806F44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80806F48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM2_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80806F4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80806F50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x80806F54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x80806F58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80806F5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80806F60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80806F64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_22_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80806F68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_23_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80806F6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80806F70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80806F74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80806F78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM3_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80806F7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80806F80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80806F84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_12_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80806F88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80806F8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_15_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80806F90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_17_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x80806F94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_18_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x80806F98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80806F9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_20_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80806FA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_21_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80806FA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_25_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80806FA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80806FAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80806FB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80806FB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM6_8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80806FB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80806FBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_12_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80806FC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80806FC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_14_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80806FC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_15_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80806FCC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_16_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80806FD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_17_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80806FD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80806FD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_20_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80806FDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_25_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80806FE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_26_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80806FE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_28_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80806FE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_29_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80806FEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_30_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80806FF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM7_31_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80806FF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80806FF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80806FFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_10_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80807000
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_11_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80807004
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_12_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80807008
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_13_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x8080700C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_16_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80807010
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_18_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80807014
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80807018
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x8080701C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_30_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80807020
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_31_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80807024
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM8_4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80807028
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM9_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x8080702C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM9_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80807030
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM9_15_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80807034
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MOXEMM_SMU_ALM9_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80807038
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoCSOPICO_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoCSOPICO"
    VALUE
    0x8080703C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoFVarPostBldSel_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoFVarPostBldSel"
    VALUE
    0x80807040
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoSysCtrlReIni_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoSysCtrlReIni"
    VALUE
    0x80807044
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTMCUFW_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80807048
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTMonBIST_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x8080704C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTRegMonTest_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80807050
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80807054
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTTempSens_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80807058
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_MoXEMMHwLTUCBCfg_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x8080705C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_OCWDAABEActv_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_OCWDAABEActv"
    VALUE
    0x80807060
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_OCWDACom_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_OCWDACom"
    VALUE
    0x80807064
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_OCWDAErrPin_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_OCWDAErrPin"
    VALUE
    0x80807068
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_SWReset_0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_SWReset_0"
    VALUE
    0x8080706C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_SWReset_1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_SWReset_1"
    VALUE
    0x80807070
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_SWReset_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_SWReset_2"
    VALUE
    0x80807074
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_Unused_C
    "J1939FMI specific trouble code / "
    VALUE
    0x80807078
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80c7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80807079
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80c8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c8"
    VALUE
    0x8080707A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80c9_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c9"
    VALUE
    0x8080707B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ca_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ca"
    VALUE
    0x8080707C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80cb_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80cb"
    VALUE
    0x8080707D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80cc_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80cc"
    VALUE
    0x8080707E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80cd_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80cd"
    VALUE
    0x8080707F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ce_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ce"
    VALUE
    0x80807080
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80cf_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80cf"
    VALUE
    0x80807081
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80d0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d0"
    VALUE
    0x80807082
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80d1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d1"
    VALUE
    0x80807083
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80d2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80807084
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80d3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80807085
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80d4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80807086
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80d5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80807087
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80d6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80807088
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80d7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d7"
    VALUE
    0x80807089
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80d8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d8"
    VALUE
    0x8080708A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80d9_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d9"
    VALUE
    0x8080708B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80da_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80da"
    VALUE
    0x8080708C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80db_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80db"
    VALUE
    0x8080708D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80dc_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80dc"
    VALUE
    0x8080708E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80dd_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80dd"
    VALUE
    0x8080708F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80de_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80de"
    VALUE
    0x80807090
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80df_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80df"
    VALUE
    0x80807091
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80e0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e0"
    VALUE
    0x80807092
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80e1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e1"
    VALUE
    0x80807093
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80e2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80807094
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80e3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80807095
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80e4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80807096
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80e5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80807097
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80e6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80807098
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80e7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e7"
    VALUE
    0x80807099
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80e8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e8"
    VALUE
    0x8080709A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80e9_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e9"
    VALUE
    0x8080709B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ea_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ea"
    VALUE
    0x8080709C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80eb_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80eb"
    VALUE
    0x8080709D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ec_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ec"
    VALUE
    0x8080709E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ed_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ed"
    VALUE
    0x8080709F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ee_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ee"
    VALUE
    0x808070A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ef_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ef"
    VALUE
    0x808070A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80f0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f0"
    VALUE
    0x808070A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80f1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f1"
    VALUE
    0x808070A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80f2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f2"
    VALUE
    0x808070A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80f3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f3"
    VALUE
    0x808070A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80f4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f4"
    VALUE
    0x808070A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80f5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f5"
    VALUE
    0x808070A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80f6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f6"
    VALUE
    0x808070A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80f7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f7"
    VALUE
    0x808070A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80f8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f8"
    VALUE
    0x808070AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80f9_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f9"
    VALUE
    0x808070AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80fa_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80fa"
    VALUE
    0x808070AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80fb_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80fb"
    VALUE
    0x808070AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80fc_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80fc"
    VALUE
    0x808070AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80fd_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80fd"
    VALUE
    0x808070AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80fe_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80fe"
    VALUE
    0x808070B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ff_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ff"
    VALUE
    0x808070B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8100_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8100"
    VALUE
    0x808070B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8101_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8101"
    VALUE
    0x808070B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8102_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8102"
    VALUE
    0x808070B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8103_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8103"
    VALUE
    0x808070B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8104_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8104"
    VALUE
    0x808070B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8105_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8105"
    VALUE
    0x808070B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8106_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8106"
    VALUE
    0x808070B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8107_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8107"
    VALUE
    0x808070B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8108_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8108"
    VALUE
    0x808070BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8109_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8109"
    VALUE
    0x808070BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x810a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810a"
    VALUE
    0x808070BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x810b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810b"
    VALUE
    0x808070BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x810c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810c"
    VALUE
    0x808070BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x810d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810d"
    VALUE
    0x808070BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x810e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810e"
    VALUE
    0x808070C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x810f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810f"
    VALUE
    0x808070C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8110_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8110"
    VALUE
    0x808070C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8111_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8111"
    VALUE
    0x808070C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8112_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8112"
    VALUE
    0x808070C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8113_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8113"
    VALUE
    0x808070C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8114_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8114"
    VALUE
    0x808070C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8115_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8115"
    VALUE
    0x808070C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8116_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8116"
    VALUE
    0x808070C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8117_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8117"
    VALUE
    0x808070C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8118_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8118"
    VALUE
    0x808070CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8119_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8119"
    VALUE
    0x808070CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x811a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811a"
    VALUE
    0x808070CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x811b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811b"
    VALUE
    0x808070CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x811c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811c"
    VALUE
    0x808070CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x811d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811d"
    VALUE
    0x808070CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x811e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811e"
    VALUE
    0x808070D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x811f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811f"
    VALUE
    0x808070D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8120_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8120"
    VALUE
    0x808070D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8121_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8121"
    VALUE
    0x808070D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8122_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8122"
    VALUE
    0x808070D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8123_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8123"
    VALUE
    0x808070D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8124_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8124"
    VALUE
    0x808070D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8125_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8125"
    VALUE
    0x808070D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8126_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8126"
    VALUE
    0x808070D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8127_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8127"
    VALUE
    0x808070D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8128_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8128"
    VALUE
    0x808070DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8129_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8129"
    VALUE
    0x808070DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x812a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x812a"
    VALUE
    0x808070DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_TiInRow0x8B01_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_TiInRow0x8B01"
    VALUE
    0x808070DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_TiInRow0x8B02_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_TiInRow0x8B02"
    VALUE
    0x808070DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_TiInRow0x8B03_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_TiInRow0x8B03"
    VALUE
    0x808070DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_DevLibBattUHi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_DevLibBattUHi"
    VALUE
    0x808070E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_DevLibBattULo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_DevLibBattULo"
    VALUE
    0x808070E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8063_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8063"
    VALUE
    0x808070E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8064_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8064"
    VALUE
    0x808070E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8065_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8065"
    VALUE
    0x808070E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8066_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8066"
    VALUE
    0x808070E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8067_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8067"
    VALUE
    0x808070E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8068_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8068"
    VALUE
    0x808070E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8069_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8069"
    VALUE
    0x808070E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x806a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806a"
    VALUE
    0x808070E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x806b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806b"
    VALUE
    0x808070EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x806c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806c"
    VALUE
    0x808070EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x806d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806d"
    VALUE
    0x808070EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x806e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806e"
    VALUE
    0x808070ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x806f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806f"
    VALUE
    0x808070EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8070_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8070"
    VALUE
    0x808070EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8071_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8071"
    VALUE
    0x808070F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8072_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8072"
    VALUE
    0x808070F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8073_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8073"
    VALUE
    0x808070F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8074_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8074"
    VALUE
    0x808070F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8075_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8075"
    VALUE
    0x808070F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8076_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8076"
    VALUE
    0x808070F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8077_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8077"
    VALUE
    0x808070F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8078_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8078"
    VALUE
    0x808070F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8079_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8079"
    VALUE
    0x808070F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x807a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807a"
    VALUE
    0x808070F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x807b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807b"
    VALUE
    0x808070FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x807c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807c"
    VALUE
    0x808070FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x807d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807d"
    VALUE
    0x808070FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x807e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807e"
    VALUE
    0x808070FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x807f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807f"
    VALUE
    0x808070FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8080_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8080"
    VALUE
    0x808070FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8081_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8081"
    VALUE
    0x80807100
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8082_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8082"
    VALUE
    0x80807101
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8083_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8083"
    VALUE
    0x80807102
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8084_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8084"
    VALUE
    0x80807103
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8085_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8085"
    VALUE
    0x80807104
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8086_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8086"
    VALUE
    0x80807105
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8087_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8087"
    VALUE
    0x80807106
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8088_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8088"
    VALUE
    0x80807107
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8089_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8089"
    VALUE
    0x80807108
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x808a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808a"
    VALUE
    0x80807109
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x808b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808b"
    VALUE
    0x8080710A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x808c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808c"
    VALUE
    0x8080710B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x808d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808d"
    VALUE
    0x8080710C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x808e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808e"
    VALUE
    0x8080710D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x808f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808f"
    VALUE
    0x8080710E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8090_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8090"
    VALUE
    0x8080710F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8091_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8091"
    VALUE
    0x80807110
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8092_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8092"
    VALUE
    0x80807111
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8093_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8093"
    VALUE
    0x80807112
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8094_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8094"
    VALUE
    0x80807113
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8095_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8095"
    VALUE
    0x80807114
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8096_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8096"
    VALUE
    0x80807115
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8097_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8097"
    VALUE
    0x80807116
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8098_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8098"
    VALUE
    0x80807117
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8099_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8099"
    VALUE
    0x80807118
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x809a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809a"
    VALUE
    0x80807119
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x809b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809b"
    VALUE
    0x8080711A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x809c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809c"
    VALUE
    0x8080711B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x809d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809d"
    VALUE
    0x8080711C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x809e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809e"
    VALUE
    0x8080711D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x809f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809f"
    VALUE
    0x8080711E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80a0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a0"
    VALUE
    0x8080711F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80a1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a1"
    VALUE
    0x80807120
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80a2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a2"
    VALUE
    0x80807121
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80a3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a3"
    VALUE
    0x80807122
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80a4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a4"
    VALUE
    0x80807123
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80a5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80807124
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80a6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a6"
    VALUE
    0x80807125
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80a7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a7"
    VALUE
    0x80807126
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80a8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a8"
    VALUE
    0x80807127
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80a9_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a9"
    VALUE
    0x80807128
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80aa_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80aa"
    VALUE
    0x80807129
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ab_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ab"
    VALUE
    0x8080712A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ac_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ac"
    VALUE
    0x8080712B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ad_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ad"
    VALUE
    0x8080712C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ae_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ae"
    VALUE
    0x8080712D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80af_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80af"
    VALUE
    0x8080712E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80b0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b0"
    VALUE
    0x8080712F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80b1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b1"
    VALUE
    0x80807130
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80b2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b2"
    VALUE
    0x80807131
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80b3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b3"
    VALUE
    0x80807132
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80b4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b4"
    VALUE
    0x80807133
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80b5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b5"
    VALUE
    0x80807134
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80b6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b6"
    VALUE
    0x80807135
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80b7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b7"
    VALUE
    0x80807136
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80b8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b8"
    VALUE
    0x80807137
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80b9_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b9"
    VALUE
    0x80807138
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80ba_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ba"
    VALUE
    0x80807139
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80bb_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80bb"
    VALUE
    0x8080713A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80bc_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80bc"
    VALUE
    0x8080713B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80bd_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80bd"
    VALUE
    0x8080713C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80be_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80be"
    VALUE
    0x8080713D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80bf_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80bf"
    VALUE
    0x8080713E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80c0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c0"
    VALUE
    0x8080713F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80c1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c1"
    VALUE
    0x80807140
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80c2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c2"
    VALUE
    0x80807141
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80c3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c3"
    VALUE
    0x80807142
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80c4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c4"
    VALUE
    0x80807143
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80c5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c5"
    VALUE
    0x80807144
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x80c6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c6"
    VALUE
    0x80807145
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_TiUpDwn0x8A01_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x80807146
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_TiUpDwn0x8A02_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x80807147
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_TiUpDwn0x8A03_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x80807148
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA13OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA13OR"
    VALUE
    0x80807149
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA13SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA13SCB"
    VALUE
    0x8080714A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA13SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA13SCG"
    VALUE
    0x8080714B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA14OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA14OR"
    VALUE
    0x8080714C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA14SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA14SCB"
    VALUE
    0x8080714D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA14SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA14SCG"
    VALUE
    0x8080714E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA21OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA21OR"
    VALUE
    0x8080714F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA21SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA21SCB"
    VALUE
    0x80807150
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA21SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA21SCG"
    VALUE
    0x80807151
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA22OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA22OR"
    VALUE
    0x80807152
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA22SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA22SCB"
    VALUE
    0x80807153
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA22SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA22SCG"
    VALUE
    0x80807154
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA23OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA23OR"
    VALUE
    0x80807155
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA23SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA23SCB"
    VALUE
    0x80807156
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA23SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA23SCG"
    VALUE
    0x80807157
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA24OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA24OR"
    VALUE
    0x80807158
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA24SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA24SCB"
    VALUE
    0x80807159
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA24SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA24SCG"
    VALUE
    0x8080715A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA25OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA25OR"
    VALUE
    0x8080715B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA25SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA25SCB"
    VALUE
    0x8080715C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA25SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA25SCG"
    VALUE
    0x8080715D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA26OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA26OR"
    VALUE
    0x8080715E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA26SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA26SCB"
    VALUE
    0x8080715F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA26SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA26SCG"
    VALUE
    0x80807160
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA27OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA27OR"
    VALUE
    0x80807161
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA27SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA27SCB"
    VALUE
    0x80807162
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA27SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA27SCG"
    VALUE
    0x80807163
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA28OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA28OR"
    VALUE
    0x80807164
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA28SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA28SCB"
    VALUE
    0x80807165
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA28SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA28SCG"
    VALUE
    0x80807166
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA29OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA29OR"
    VALUE
    0x80807167
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA29SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA29SCB"
    VALUE
    0x80807168
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA29SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA29SCG"
    VALUE
    0x80807169
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36AicSCB"
    VALUE
    0x8080716A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36AicSCG"
    VALUE
    0x8080716B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36OR"
    VALUE
    0x8080716C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36SCB"
    VALUE
    0x8080716D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36SCG"
    VALUE
    0x8080716E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA36ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x8080716F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37AicSCB"
    VALUE
    0x80807170
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37AicSCG"
    VALUE
    0x80807171
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37OR"
    VALUE
    0x80807172
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37SCB"
    VALUE
    0x80807173
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37SCG"
    VALUE
    0x80807174
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA37ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80807175
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80807176
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38AicSCG"
    VALUE
    0x80807177
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38OR"
    VALUE
    0x80807178
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38SCB"
    VALUE
    0x80807179
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38SCG"
    VALUE
    0x8080717A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA38ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x8080717B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39AicSCB"
    VALUE
    0x8080717C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39AicSCG"
    VALUE
    0x8080717D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39OR"
    VALUE
    0x8080717E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39SCB"
    VALUE
    0x8080717F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39SCG"
    VALUE
    0x80807180
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA39ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80807181
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA40OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA40OR"
    VALUE
    0x80807182
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA40SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA40SCB"
    VALUE
    0x80807183
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA40SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA40SCG"
    VALUE
    0x80807184
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA41OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA41OR"
    VALUE
    0x80807185
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA41SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA41SCB"
    VALUE
    0x80807186
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA41SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA41SCG"
    VALUE
    0x80807187
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA42OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA42OR"
    VALUE
    0x80807188
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA42SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA42SCB"
    VALUE
    0x80807189
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA42SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA42SCG"
    VALUE
    0x8080718A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43AicSCB"
    VALUE
    0x8080718B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43AicSCG"
    VALUE
    0x8080718C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43OR"
    VALUE
    0x8080718D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43SCB"
    VALUE
    0x8080718E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43SCG"
    VALUE
    0x8080718F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA43ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80807190
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA44OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA44OL"
    VALUE
    0x80807191
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA44SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA44SCB"
    VALUE
    0x80807192
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA44SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA44SCG"
    VALUE
    0x80807193
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA57OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA57OR"
    VALUE
    0x80807194
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA57SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA57SCB"
    VALUE
    0x80807195
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA57SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA57SCG"
    VALUE
    0x80807196
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA59OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA59OL"
    VALUE
    0x80807197
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA59SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA59SCB"
    VALUE
    0x80807198
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inA59SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inA59SCG"
    VALUE
    0x80807199
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK10OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK10OR"
    VALUE
    0x8080719A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK10SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK10SCB"
    VALUE
    0x8080719B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK10SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK10SCG"
    VALUE
    0x8080719C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK11OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK11OR"
    VALUE
    0x8080719D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK11SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK11SCB"
    VALUE
    0x8080719E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK11SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK11SCG"
    VALUE
    0x8080719F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30AicSCB"
    VALUE
    0x808071A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30AicSCG"
    VALUE
    0x808071A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30OR"
    VALUE
    0x808071A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30SCB"
    VALUE
    0x808071A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30SCG"
    VALUE
    0x808071A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK30ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x808071A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK31OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK31OR"
    VALUE
    0x808071A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK31SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK31SCB"
    VALUE
    0x808071A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK31SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK31SCG"
    VALUE
    0x808071A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK32OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK32OR"
    VALUE
    0x808071A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK32SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK32SCB"
    VALUE
    0x808071AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK32SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK32SCG"
    VALUE
    0x808071AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK33OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK33OR"
    VALUE
    0x808071AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK33SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK33SCB"
    VALUE
    0x808071AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK33SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK33SCG"
    VALUE
    0x808071AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK34OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK34OR"
    VALUE
    0x808071AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK34SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK34SCB"
    VALUE
    0x808071B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK34SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK34SCG"
    VALUE
    0x808071B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK35OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK35OR"
    VALUE
    0x808071B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK35SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK35SCB"
    VALUE
    0x808071B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK35SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK35SCG"
    VALUE
    0x808071B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK36OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK36OR"
    VALUE
    0x808071B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK36SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK36SCB"
    VALUE
    0x808071B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK36SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK36SCG"
    VALUE
    0x808071B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37AicSCB"
    VALUE
    0x808071B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37AicSCG"
    VALUE
    0x808071B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37OR"
    VALUE
    0x808071BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37SCB"
    VALUE
    0x808071BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37SCG"
    VALUE
    0x808071BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK37ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x808071BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38AicSCB"
    VALUE
    0x808071BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38AicSCG"
    VALUE
    0x808071BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38OR"
    VALUE
    0x808071C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38SCB"
    VALUE
    0x808071C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38SCG"
    VALUE
    0x808071C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK38ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x808071C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39AicSCB"
    VALUE
    0x808071C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39AicSCG"
    VALUE
    0x808071C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39OR"
    VALUE
    0x808071C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39SCB"
    VALUE
    0x808071C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39SCG"
    VALUE
    0x808071C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK39ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x808071C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40AicSCB"
    VALUE
    0x808071CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40AicSCG"
    VALUE
    0x808071CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40OR"
    VALUE
    0x808071CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40SCB"
    VALUE
    0x808071CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40SCG"
    VALUE
    0x808071CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK40ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x808071CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41AicSCB"
    VALUE
    0x808071D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41AicSCG"
    VALUE
    0x808071D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41OR"
    VALUE
    0x808071D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41SCB"
    VALUE
    0x808071D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41SCG"
    VALUE
    0x808071D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK41ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x808071D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42AicSCB"
    VALUE
    0x808071D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42AicSCG"
    VALUE
    0x808071D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42OR"
    VALUE
    0x808071D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42SCB"
    VALUE
    0x808071D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42SCG"
    VALUE
    0x808071DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK42ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x808071DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK43OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK43OR"
    VALUE
    0x808071DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK43SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK43SCB"
    VALUE
    0x808071DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK43SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK43SCG"
    VALUE
    0x808071DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44AicSCB"
    VALUE
    0x808071DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44AicSCG"
    VALUE
    0x808071E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44OR"
    VALUE
    0x808071E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44SCB"
    VALUE
    0x808071E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44SCG"
    VALUE
    0x808071E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK44ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x808071E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45AicSCB"
    VALUE
    0x808071E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45AicSCG"
    VALUE
    0x808071E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45OR"
    VALUE
    0x808071E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45SCB"
    VALUE
    0x808071E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45SCG"
    VALUE
    0x808071E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK45ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x808071EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK52OR_C
