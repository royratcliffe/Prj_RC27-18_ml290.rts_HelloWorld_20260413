    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK52OR"
    VALUE
    0x808071EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK52SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK52SCB"
    VALUE
    0x808071EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK52SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK52SCG"
    VALUE
    0x808071ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK53OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK53OR"
    VALUE
    0x808071EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK53SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK53SCB"
    VALUE
    0x808071EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK53SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK53SCG"
    VALUE
    0x808071F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54AicSCB"
    VALUE
    0x808071F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54AicSCG"
    VALUE
    0x808071F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54OR"
    VALUE
    0x808071F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54SCB"
    VALUE
    0x808071F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54SCG"
    VALUE
    0x808071F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK54ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x808071F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55AicSCB"
    VALUE
    0x808071F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55AicSCG"
    VALUE
    0x808071F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55OR"
    VALUE
    0x808071F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55SCB"
    VALUE
    0x808071FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55SCG"
    VALUE
    0x808071FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK55ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x808071FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK56OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK56OR"
    VALUE
    0x808071FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK56SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK56SCB"
    VALUE
    0x808071FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK56SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK56SCG"
    VALUE
    0x808071FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK57OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK57OR"
    VALUE
    0x80807200
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK57SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK57SCB"
    VALUE
    0x80807201
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK57SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK57SCG"
    VALUE
    0x80807202
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK58OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK58OR"
    VALUE
    0x80807203
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK58SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK58SCB"
    VALUE
    0x80807204
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK58SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK58SCG"
    VALUE
    0x80807205
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK59OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK59OR"
    VALUE
    0x80807206
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK59SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK59SCB"
    VALUE
    0x80807207
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK59SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK59SCG"
    VALUE
    0x80807208
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK60OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK60OR"
    VALUE
    0x80807209
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK60SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK60SCB"
    VALUE
    0x8080720A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK60SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK60SCG"
    VALUE
    0x8080720B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61AicSCB"
    VALUE
    0x8080720C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61AicSCG"
    VALUE
    0x8080720D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61OR"
    VALUE
    0x8080720E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61SCB"
    VALUE
    0x8080720F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61SCG"
    VALUE
    0x80807210
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK61ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80807211
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK62OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK62OR"
    VALUE
    0x80807212
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK62SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK62SCB"
    VALUE
    0x80807213
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK62SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK62SCG"
    VALUE
    0x80807214
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80807215
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63AicSCG"
    VALUE
    0x80807216
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63OR"
    VALUE
    0x80807217
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63SCB"
    VALUE
    0x80807218
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63SCG"
    VALUE
    0x80807219
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK63ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x8080721A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64AicSCB"
    VALUE
    0x8080721B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64AicSCG"
    VALUE
    0x8080721C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64OR"
    VALUE
    0x8080721D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64SCB"
    VALUE
    0x8080721E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64SCG"
    VALUE
    0x8080721F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK64ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80807220
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65AicSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80807221
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65AicSCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80807222
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65OR"
    VALUE
    0x80807223
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65SCB"
    VALUE
    0x80807224
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65SCG"
    VALUE
    0x80807225
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK65ShuntSCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80807226
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK74OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK74OR"
    VALUE
    0x80807227
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK74SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK74SCB"
    VALUE
    0x80807228
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK74SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK74SCG"
    VALUE
    0x80807229
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK75OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK75OR"
    VALUE
    0x8080722A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK75SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK75SCB"
    VALUE
    0x8080722B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK75SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK75SCG"
    VALUE
    0x8080722C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK76OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK76OR"
    VALUE
    0x8080722D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK76SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK76SCB"
    VALUE
    0x8080722E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK76SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK76SCG"
    VALUE
    0x8080722F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK77OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK77OR"
    VALUE
    0x80807230
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK77SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK77SCB"
    VALUE
    0x80807231
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK77SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK77SCG"
    VALUE
    0x80807232
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK78OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK78OR"
    VALUE
    0x80807233
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK78SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK78SCB"
    VALUE
    0x80807234
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inK78SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inK78SCG"
    VALUE
    0x80807235
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_DvUBAT_FWs_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80807236
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OVErr_VPR6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80807237
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OVWarn_VPR6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80807238
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80807239
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x8080723A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_UBAT_MON_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x8080723B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x8080723C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x8080723D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_UBRM24_MON_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x8080723E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VDD5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x8080723F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VDD5_IN_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80807240
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VPR6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80807241
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VSS3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80807242
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VSS4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80807243
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_Temp1_HTErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80807244
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_Temp1_HTWarn_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80807245
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_Temp2_HTErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80807246
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_Temp2_HTWarn_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80807247
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80807248
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80807249
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VDD5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x8080724A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VDD5_IN_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x8080724B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VPR6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x8080724C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VSS3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x8080724D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VSS4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x8080724E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA01OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA01OL"
    VALUE
    0x8080724F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA01OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA01OT"
    VALUE
    0x80807250
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA01SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA01SCB"
    VALUE
    0x80807251
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA01SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA01SCG"
    VALUE
    0x80807252
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02OL"
    VALUE
    0x80807253
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02OR"
    VALUE
    0x80807254
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02OT"
    VALUE
    0x80807255
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02SCB"
    VALUE
    0x80807256
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02SCG"
    VALUE
    0x80807257
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03OL"
    VALUE
    0x80807258
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03OT"
    VALUE
    0x80807259
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03SCB"
    VALUE
    0x8080725A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03SCG"
    VALUE
    0x8080725B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04OL"
    VALUE
    0x8080725C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04OT"
    VALUE
    0x8080725D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04SCB"
    VALUE
    0x8080725E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04SCG"
    VALUE
    0x8080725F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05OL"
    VALUE
    0x80807260
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05OR"
    VALUE
    0x80807261
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05OT"
    VALUE
    0x80807262
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05SCB"
    VALUE
    0x80807263
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05SCG"
    VALUE
    0x80807264
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA06OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA06OL"
    VALUE
    0x80807265
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA06OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA06OR"
    VALUE
    0x80807266
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA06OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA06OT"
    VALUE
    0x80807267
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA06SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA06SCB"
    VALUE
    0x80807268
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA06SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA06SCG"
    VALUE
    0x80807269
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07OL"
    VALUE
    0x8080726A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07OT"
    VALUE
    0x8080726B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07SCB"
    VALUE
    0x8080726C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07SCG"
    VALUE
    0x8080726D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08OL"
    VALUE
    0x8080726E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08OT"
    VALUE
    0x8080726F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08SCB"
    VALUE
    0x80807270
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08SCG"
    VALUE
    0x80807271
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09OL"
    VALUE
    0x80807272
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09OR"
    VALUE
    0x80807273
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09OT"
    VALUE
    0x80807274
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09SCB"
    VALUE
    0x80807275
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09SCG"
    VALUE
    0x80807276
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10OL"
    VALUE
    0x80807277
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10OT"
    VALUE
    0x80807278
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10SCB"
    VALUE
    0x80807279
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10SCG"
    VALUE
    0x8080727A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA11OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA11OL"
    VALUE
    0x8080727B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA11OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA11OT"
    VALUE
    0x8080727C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA11SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA11SCB"
    VALUE
    0x8080727D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA11SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA11SCG"
    VALUE
    0x8080727E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA12OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA12OR"
    VALUE
    0x8080727F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA12SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA12SCB"
    VALUE
    0x80807280
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA12SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA12SCG"
    VALUE
    0x80807281
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA16OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA16OL"
    VALUE
    0x80807282
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA16OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA16OT"
    VALUE
    0x80807283
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA16SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA16SCB"
    VALUE
    0x80807284
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA16SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA16SCG"
    VALUE
    0x80807285
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17OL"
    VALUE
    0x80807286
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17OR"
    VALUE
    0x80807287
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17OT"
    VALUE
    0x80807288
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17SCB"
    VALUE
    0x80807289
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17SCG"
    VALUE
    0x8080728A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18OL"
    VALUE
    0x8080728B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18OT"
    VALUE
    0x8080728C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18SCB"
    VALUE
    0x8080728D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18SCG"
    VALUE
    0x8080728E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19OL"
    VALUE
    0x8080728F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19OR"
    VALUE
    0x80807290
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19OT"
    VALUE
    0x80807291
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19SCB"
    VALUE
    0x80807292
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19SCG"
    VALUE
    0x80807293
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20OL"
    VALUE
    0x80807294
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20OR"
    VALUE
    0x80807295
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20OT"
    VALUE
    0x80807296
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20SCB"
    VALUE
    0x80807297
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20SCG"
    VALUE
    0x80807298
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31OL"
    VALUE
    0x80807299
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31OR"
    VALUE
    0x8080729A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31OT"
    VALUE
    0x8080729B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31SCB"
    VALUE
    0x8080729C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31SCG"
    VALUE
    0x8080729D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32OL"
    VALUE
    0x8080729E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32OR"
    VALUE
    0x8080729F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32OT"
    VALUE
    0x808072A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32SCB"
    VALUE
    0x808072A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32SCG"
    VALUE
    0x808072A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33OL"
    VALUE
    0x808072A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33OR"
    VALUE
    0x808072A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33OT"
    VALUE
    0x808072A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33SCB"
    VALUE
    0x808072A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33SCG"
    VALUE
    0x808072A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34OL"
    VALUE
    0x808072A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34OR"
    VALUE
    0x808072A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34OT"
    VALUE
    0x808072AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34SCB"
    VALUE
    0x808072AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34SCG"
    VALUE
    0x808072AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35OL"
    VALUE
    0x808072AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35OR"
    VALUE
    0x808072AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35OT"
    VALUE
    0x808072AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35SCB"
    VALUE
    0x808072B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35SCG"
    VALUE
    0x808072B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46OL"
    VALUE
    0x808072B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46OR"
    VALUE
    0x808072B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46OT"
    VALUE
    0x808072B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46SCB"
    VALUE
    0x808072B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46SCG"
    VALUE
    0x808072B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47OL"
    VALUE
    0x808072B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47OR"
    VALUE
    0x808072B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47OT"
    VALUE
    0x808072B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47SCB"
    VALUE
    0x808072BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47SCG"
    VALUE
    0x808072BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48OL"
    VALUE
    0x808072BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48OR"
    VALUE
    0x808072BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48OT"
    VALUE
    0x808072BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48SCB"
    VALUE
    0x808072BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48SCG"
    VALUE
    0x808072C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA49OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA49OL"
    VALUE
    0x808072C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA49OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA49OT"
    VALUE
    0x808072C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA49SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA49SCB"
    VALUE
    0x808072C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA49SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA49SCG"
    VALUE
    0x808072C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA50OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA50OL"
    VALUE
    0x808072C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA50OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA50OT"
    VALUE
    0x808072C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA50SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA50SCB"
    VALUE
    0x808072C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA50SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA50SCG"
    VALUE
    0x808072C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51OL"
    VALUE
    0x808072C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51OR"
    VALUE
    0x808072CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51OT"
    VALUE
    0x808072CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51SCB"
    VALUE
    0x808072CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51SCG"
    VALUE
    0x808072CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52OL"
    VALUE
    0x808072CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52OR"
    VALUE
    0x808072CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52OT"
    VALUE
    0x808072D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52SCB"
    VALUE
    0x808072D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52SCG"
    VALUE
    0x808072D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53OL"
    VALUE
    0x808072D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53OR"
    VALUE
    0x808072D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53OT"
    VALUE
    0x808072D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53SCB"
    VALUE
    0x808072D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53SCG"
    VALUE
    0x808072D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54OL"
    VALUE
    0x808072D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54OR"
    VALUE
    0x808072D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54OT"
    VALUE
    0x808072DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54SCB"
    VALUE
    0x808072DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54SCG"
    VALUE
    0x808072DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA55OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA55OL"
    VALUE
    0x808072DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA55OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA55OT"
    VALUE
    0x808072DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA55SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA55SCB"
    VALUE
    0x808072DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA55SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA55SCG"
    VALUE
    0x808072E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA56OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA56OL"
    VALUE
    0x808072E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA56OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA56OT"
    VALUE
    0x808072E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA56SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA56SCB"
    VALUE
    0x808072E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA56SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA56SCG"
    VALUE
    0x808072E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA58OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA58OL"
    VALUE
    0x808072E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA58OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA58OT"
    VALUE
    0x808072E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA58SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA58SCB"
    VALUE
    0x808072E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA58SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA58SCG"
    VALUE
    0x808072E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07OL"
    VALUE
    0x808072E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07OR"
    VALUE
    0x808072EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07OT"
    VALUE
    0x808072EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07SCB"
    VALUE
    0x808072EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07SCG"
    VALUE
    0x808072ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08OL"
    VALUE
    0x808072EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08OR"
    VALUE
    0x808072EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08OT"
    VALUE
    0x808072F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08SCB"
    VALUE
    0x808072F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08SCG"
    VALUE
    0x808072F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09OL"
    VALUE
    0x808072F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09OR"
    VALUE
    0x808072F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09OT"
    VALUE
    0x808072F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09SCB"
    VALUE
    0x808072F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09SCG"
    VALUE
    0x808072F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12OL"
    VALUE
    0x808072F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12OT"
    VALUE
    0x808072F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12SCB"
    VALUE
    0x808072FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12SCG"
    VALUE
    0x808072FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13OL"
    VALUE
    0x808072FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13OT"
    VALUE
    0x808072FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13SCB"
    VALUE
    0x808072FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13SCG"
    VALUE
    0x808072FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14OL"
    VALUE
    0x80807300
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14OR"
    VALUE
    0x80807301
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14OT"
    VALUE
    0x80807302
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14SCB"
    VALUE
    0x80807303
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14SCG"
    VALUE
    0x80807304
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15OL"
    VALUE
    0x80807305
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15OR"
    VALUE
    0x80807306
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15OT"
    VALUE
    0x80807307
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15SCB"
    VALUE
    0x80807308
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15SCG"
    VALUE
    0x80807309
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16OL"
    VALUE
    0x8080730A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16OR"
    VALUE
    0x8080730B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16OT"
    VALUE
    0x8080730C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16SCB"
    VALUE
    0x8080730D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16SCG"
    VALUE
    0x8080730E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17OL"
    VALUE
    0x8080730F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17OR"
    VALUE
    0x80807310
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17OT"
    VALUE
    0x80807311
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17SCB"
    VALUE
    0x80807312
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17SCG"
    VALUE
    0x80807313
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK25OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK25OR"
    VALUE
    0x80807314
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK25SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK25SCB"
    VALUE
    0x80807315
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK25SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK25SCG"
    VALUE
    0x80807316
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29OL"
    VALUE
    0x80807317
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29OR"
    VALUE
    0x80807318
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29OT"
    VALUE
    0x80807319
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29SCB"
    VALUE
    0x8080731A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29SCG"
    VALUE
    0x8080731B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51OL"
    VALUE
    0x8080731C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51OT"
    VALUE
    0x8080731D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51SCB"
    VALUE
    0x8080731E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51SCG"
    VALUE
    0x8080731F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK62OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK62OR"
    VALUE
    0x80807320
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK62SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK62SCB"
    VALUE
    0x80807321
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK62SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK62SCG"
    VALUE
    0x80807322
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73OL"
    VALUE
    0x80807323
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73OR"
    VALUE
    0x80807324
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73OT"
    VALUE
    0x80807325
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73SCB"
    VALUE
    0x80807326
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73SCG"
    VALUE
    0x80807327
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK80OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK80OL"
    VALUE
    0x80807328
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK80OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK80OT"
    VALUE
    0x80807329
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK80SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK80SCB"
    VALUE
    0x8080732A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK80SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK80SCG"
    VALUE
    0x8080732B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK81OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK81OL"
    VALUE
    0x8080732C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK81OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK81OT"
    VALUE
    0x8080732D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK81SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK81SCB"
    VALUE
    0x8080732E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK81SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK81SCG"
    VALUE
    0x8080732F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK82OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK82OL"
    VALUE
    0x80807330
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK82OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK82OT"
    VALUE
    0x80807331
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK82SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK82SCB"
    VALUE
    0x80807332
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK82SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK82SCG"
    VALUE
    0x80807333
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK83OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK83OL"
    VALUE
    0x80807334
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK83OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK83OT"
    VALUE
    0x80807335
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK83SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK83SCB"
    VALUE
    0x80807336
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK83SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK83SCG"
    VALUE
    0x80807337
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK84OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK84OL"
    VALUE
    0x80807338
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK84OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK84OT"
    VALUE
    0x80807339
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK84SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK84SCB"
    VALUE
    0x8080733A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK84SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK84SCG"
    VALUE
    0x8080733B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK85OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK85OL"
    VALUE
    0x8080733C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK85OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK85OT"
    VALUE
    0x8080733D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK85SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK85SCB"
    VALUE
    0x8080733E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK85SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK85SCG"
    VALUE
    0x8080733F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK86OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK86OL"
    VALUE
    0x80807340
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK86OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK86OT"
    VALUE
    0x80807341
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK86SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK86SCB"
    VALUE
    0x80807342
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK86SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK86SCG"
    VALUE
    0x80807343
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK87OL_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK87OL"
    VALUE
    0x80807344
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK87OT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK87OT"
    VALUE
    0x80807345
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK87SCB_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK87SCB"
    VALUE
    0x80807346
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK87SCG_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK87SCG"
    VALUE
    0x80807347
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_DSMDummy_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_DSMDummy"
    VALUE
    0x80807348
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8000_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8000"
    VALUE
    0x80807349
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8001_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8001"
    VALUE
    0x8080734A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8002_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8002"
    VALUE
    0x8080734B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8003_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8003"
    VALUE
    0x8080734C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8004_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8004"
    VALUE
    0x8080734D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8005_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8005"
    VALUE
    0x8080734E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8006_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8006"
    VALUE
    0x8080734F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8007_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8007"
    VALUE
    0x80807350
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8008_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8008"
    VALUE
    0x80807351
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8009_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8009"
    VALUE
    0x80807352
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x800a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800a"
    VALUE
    0x80807353
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x800b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800b"
    VALUE
    0x80807354
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x800c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800c"
    VALUE
    0x80807355
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x800d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800d"
    VALUE
    0x80807356
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x800e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800e"
    VALUE
    0x80807357
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x800f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x800f"
    VALUE
    0x80807358
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8010_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8010"
    VALUE
    0x80807359
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8011_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8011"
    VALUE
    0x8080735A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8012_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8012"
    VALUE
    0x8080735B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8013_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8013"
    VALUE
    0x8080735C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8014_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8014"
    VALUE
    0x8080735D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8015_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8015"
    VALUE
    0x8080735E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8016_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8016"
    VALUE
    0x8080735F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8017_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8017"
    VALUE
    0x80807360
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8018_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8018"
    VALUE
    0x80807361
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8019_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8019"
    VALUE
    0x80807362
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x801a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801a"
    VALUE
    0x80807363
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x801b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801b"
    VALUE
    0x80807364
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x801c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801c"
    VALUE
    0x80807365
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x801d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801d"
    VALUE
    0x80807366
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x801e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801e"
    VALUE
    0x80807367
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x801f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x801f"
    VALUE
    0x80807368
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8020_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8020"
    VALUE
    0x80807369
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8021_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8021"
    VALUE
    0x8080736A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8022_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8022"
    VALUE
    0x8080736B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8023_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8023"
    VALUE
    0x8080736C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8024_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8024"
    VALUE
    0x8080736D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8025_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8025"
    VALUE
    0x8080736E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8026_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8026"
    VALUE
    0x8080736F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8027_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8027"
    VALUE
    0x80807370
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8028_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8028"
    VALUE
    0x80807371
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8029_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8029"
    VALUE
    0x80807372
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x802a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802a"
    VALUE
    0x80807373
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x802b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802b"
    VALUE
    0x80807374
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x802c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802c"
    VALUE
    0x80807375
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x802d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802d"
    VALUE
    0x80807376
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x802e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802e"
    VALUE
    0x80807377
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x802f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x802f"
    VALUE
    0x80807378
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8030_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8030"
    VALUE
    0x80807379
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8031_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8031"
    VALUE
    0x8080737A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8032_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8032"
    VALUE
    0x8080737B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8033_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8033"
    VALUE
    0x8080737C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8034_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8034"
    VALUE
    0x8080737D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8035_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8035"
    VALUE
    0x8080737E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8036_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8036"
    VALUE
    0x8080737F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8037_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8037"
    VALUE
    0x80807380
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8038_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8038"
    VALUE
    0x80807381
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8039_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8039"
    VALUE
    0x80807382
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x803a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803a"
    VALUE
    0x80807383
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x803b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803b"
    VALUE
    0x80807384
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x803c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803c"
    VALUE
    0x80807385
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x803d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803d"
    VALUE
    0x80807386
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x803e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803e"
    VALUE
    0x80807387
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x803f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x803f"
    VALUE
    0x80807388
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8040_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8040"
    VALUE
    0x80807389
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8041_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8041"
    VALUE
    0x8080738A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8042_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8042"
    VALUE
    0x8080738B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8043_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8043"
    VALUE
    0x8080738C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8044_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8044"
    VALUE
    0x8080738D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8045_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8045"
    VALUE
    0x8080738E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8046_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8046"
    VALUE
    0x8080738F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8047_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8047"
    VALUE
    0x80807390
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8048_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8048"
    VALUE
    0x80807391
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8049_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8049"
    VALUE
    0x80807392
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x804a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804a"
    VALUE
    0x80807393
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x804b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804b"
    VALUE
    0x80807394
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x804c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804c"
    VALUE
    0x80807395
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x804d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804d"
    VALUE
    0x80807396
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x804e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804e"
    VALUE
    0x80807397
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x804f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x804f"
    VALUE
    0x80807398
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8050_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8050"
    VALUE
    0x80807399
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8051_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8051"
    VALUE
    0x8080739A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8052_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8052"
    VALUE
    0x8080739B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8053_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8053"
    VALUE
    0x8080739C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8054_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8054"
    VALUE
    0x8080739D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8055_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8055"
    VALUE
    0x8080739E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8056_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8056"
    VALUE
    0x8080739F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8057_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8057"
    VALUE
    0x808073A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8058_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8058"
    VALUE
    0x808073A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8059_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8059"
    VALUE
    0x808073A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x805a_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805a"
    VALUE
    0x808073A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x805b_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805b"
    VALUE
    0x808073A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x805c_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805c"
    VALUE
    0x808073A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x805d_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805d"
    VALUE
    0x808073A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x805e_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805e"
    VALUE
    0x808073A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x805f_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x805f"
    VALUE
    0x808073A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8060_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8060"
    VALUE
    0x808073A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8061_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8061"
    VALUE
    0x808073AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8062_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8062"
    VALUE
    0x808073AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8C01_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8C01"
    VALUE
    0x808073AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8C02_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8C02"
    VALUE
    0x808073AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_bds_NoDeb0x8C03_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8C03"
    VALUE
    0x808073AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetDataNoBuf_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x808073AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetDataParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetDataParam"
    VALUE
    0x808073B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetDataboxNoInit_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x808073B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x808073B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetRxBufStatusParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x808073B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetStatusParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetStatusParam"
    VALUE
    0x808073B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canGetTxBufStatusParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x808073B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canInitParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canInitParam"
    VALUE
    0x808073B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canInitRxDataboxOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x808073B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canInitRxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x808073B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canInitTxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x808073B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canIpduGroupControl_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x808073BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canIsDataboxFreeNoInit_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x808073BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canIsDataboxFreeParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x808073BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canIsTxEmptyParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x808073BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegBusOffCallbInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x808073BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegBusOffCallbParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x808073BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxBufInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x808073C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxBufOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x808073C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxBufParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x808073C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxCallbInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x808073C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxCallbParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x808073C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxDataboxInvNumb_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x808073C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxDataboxInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x808073C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxDataboxOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x808073C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegRxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x808073C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxBufInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x808073C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxBufOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x808073CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxBufParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x808073CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxDataboxInvNumb_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x808073CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxDataboxInvState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x808073CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxDataboxOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x808073CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canRegTxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x808073CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canResetTxBufParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x808073D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canSendDataBufOvfl_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x808073D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canSendDataParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canSendDataParam"
    VALUE
    0x808073D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canSendDataboxNoInit_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x808073D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canSendDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x808073D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canSetTxCycleParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x808073D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canStartParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canStartParam"
    VALUE
    0x808073D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_canStopParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_canStopParam"
    VALUE
    0x808073D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_can_ClearIpduGroup_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x808073D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_can_ReceiveSignal_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x808073D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_can_SendSignal_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_can_SendSignal"
    VALUE
    0x808073DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_can_SetIpduGroup_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x808073DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmDTCJ1939_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x808073DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmDelDTCJ1939_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x808073DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmDelErrors_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmDelErrors"
    VALUE
    0x808073DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmGetDFES_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmGetDFES"
    VALUE
    0x808073DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmGetDTCJ1939_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x808073E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmGetErrors_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmGetErrors"
    VALUE
    0x808073E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmGetNumErrors_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x808073E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmInitQueueOverflow_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x808073E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmNumDTCJ1939_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x808073E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmTesterror_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmTesterror"
    VALUE
    0x808073E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmUpdateDebError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x808073E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmUpdateError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmUpdateError"
    VALUE
    0x808073E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmgetDFCStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x808073E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_dsmtestErrorDFC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x808073E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAi"
    VALUE
    0x808073EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAic_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAic"
    VALUE
    0x808073EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAicCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAicCfg"
    VALUE
    0x808073EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAicGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAicGetStatus"
    VALUE
    0x808073ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAid_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAid"
    VALUE
    0x808073EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAidCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAidCfg"
    VALUE
    0x808073EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAiv_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAiv"
    VALUE
    0x808073F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAivCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAivCfg"
    VALUE
    0x808073F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inAivGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inAivGetStatus"
    VALUE
    0x808073F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inDi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inDi"
    VALUE
    0x808073F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inFi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inFi"
    VALUE
    0x808073F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inFiCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inFiCfg"
    VALUE
    0x808073F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inFiGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inFiGetStatus"
    VALUE
    0x808073F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inFi_Buffered_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inFi_Buffered"
    VALUE
    0x808073F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inPhase_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inPhase"
    VALUE
    0x808073F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inPhaseGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x808073F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inPhaseResetCounter_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x808073FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inRi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inRi"
    VALUE
    0x808073FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inRiCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inRiCfg"
    VALUE
    0x808073FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inRiCfgTemp_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x808073FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inRiGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inRiGetStatus"
    VALUE
    0x808073FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inRiGetTemp_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inRiGetTemp"
    VALUE
    0x808073FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentCopyFDFifo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80807400
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentDisable_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentDisable"
    VALUE
    0x80807401
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentEnable_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentEnable"
    VALUE
    0x80807402
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentGetErrorStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80807403
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentGetFD_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentGetFD"
    VALUE
    0x80807404
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentGetSD_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentGetSD"
    VALUE
    0x80807405
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentGetSDDatabox_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80807406
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentGetStatus"
    VALUE
    0x80807407
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentInitSDDatabox_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80807408
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentRegisterCopyFDFifo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80807409
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentRegisterFDFifo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x8080740A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_inSentRegisterSDDataboxes_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x8080740B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusCanRxBufferOverflow_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x8080740C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusGetCaAddrParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x8080740D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusGetDiagnosticParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x8080740E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x8080740F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusGetStatusParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80807410
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitCommCaMissing_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80807411
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitCommParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80807412
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitCommState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitCommState"
    VALUE
    0x80807413
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitDiagnosticParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80807414
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitFailureListParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80807415
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitRxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80807416
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusInitTxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80807417
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegRxDataboxOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80807418
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegRxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80807419
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegRxDataboxState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x8080741A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegTxDataboxOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x8080741B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegTxDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x8080741C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegTxDataboxState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x8080741D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x8080741E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegisterInstancesOverlap_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x8080741F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegisterInstancesParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80807420
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusRegisterInstancesState_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80807421
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSendDataboxParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80807422
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSendRequestPGNParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80807423
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrCaUsed_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80807424
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrComm_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80807425
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrInvCan_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80807426
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaAddrParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80807427
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaInfoParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80807428
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSetCaNameParam_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80807429
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_isobusSftyCanTxErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x8080742A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_ReceiveSignal_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x8080742B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_SendSignal_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_SendSignal"
    VALUE
    0x8080742C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_getStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_getStatus"
    VALUE
    0x8080742D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_gotoSleep_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x8080742E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_scheduleRequest_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x8080742F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_lin_wakeUp_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_lin_wakeUp"
    VALUE
    0x80807430
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memFlsCfgShr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80807431
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memGetStatus"
    VALUE
    0x80807432
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memMarkBlock_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memMarkBlock"
    VALUE
    0x80807433
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadApi1Error_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80807434
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadApi2Error_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80807435
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadBlock_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadBlock"
    VALUE
    0x80807436
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadCalibInputError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80807437
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadCalibOuputError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80807438
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memReadSystemError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memReadSystemError"
    VALUE
    0x80807439
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_memWriteBlock_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_memWriteBlock"
    VALUE
    0x8080743A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_moOV_FirstConstADC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x8080743B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_moOV_SecondConstADC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x8080743C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_moUV_FirstConstADC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x8080743D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_moUV_SecondConstADC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x8080743E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_INH_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_INH"
    VALUE
    0x8080743F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_INHLatch_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_INHLatch"
    VALUE
    0x80807440
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_adcPDD_fail_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80807441
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_memoryProtection_err_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80807442
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02OC"
    VALUE
    0x80807443
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA02Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA02Unintended"
    VALUE
    0x80807444
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03OC"
    VALUE
    0x80807445
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA03Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA03Unintended"
    VALUE
    0x80807446
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04OC"
    VALUE
    0x80807447
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA04Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA04Unintended"
    VALUE
    0x80807448
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05OC"
    VALUE
    0x80807449
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA05Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA05Unintended"
    VALUE
    0x8080744A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07OC"
    VALUE
    0x8080744B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA07Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA07Unintended"
    VALUE
    0x8080744C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08OC"
    VALUE
    0x8080744D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA08Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA08Unintended"
    VALUE
    0x8080744E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09OC"
    VALUE
    0x8080744F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA09Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA09Unintended"
    VALUE
    0x80807450
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10OC"
    VALUE
    0x80807451
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA10Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA10Unintended"
    VALUE
    0x80807452
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17OC"
    VALUE
    0x80807453
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA17Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA17Unintended"
    VALUE
    0x80807454
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18OC"
    VALUE
    0x80807455
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA18Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA18Unintended"
    VALUE
    0x80807456
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19OC"
    VALUE
    0x80807457
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA19Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA19Unintended"
    VALUE
    0x80807458
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20OC"
    VALUE
    0x80807459
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA20Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA20Unintended"
    VALUE
    0x8080745A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31OC"
    VALUE
    0x8080745B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA31Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA31Unintended"
    VALUE
    0x8080745C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32OC"
    VALUE
    0x8080745D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA32Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA32Unintended"
    VALUE
    0x8080745E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33OC"
    VALUE
    0x8080745F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA33Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA33Unintended"
    VALUE
    0x80807460
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34OC"
    VALUE
    0x80807461
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA34Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA34Unintended"
    VALUE
    0x80807462
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35OC"
    VALUE
    0x80807463
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA35Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA35Unintended"
    VALUE
    0x80807464
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46OC"
    VALUE
    0x80807465
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA46Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA46Unintended"
    VALUE
    0x80807466
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47OC"
    VALUE
    0x80807467
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA47Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA47Unintended"
    VALUE
    0x80807468
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48OC"
    VALUE
    0x80807469
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA48Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA48Unintended"
    VALUE
    0x8080746A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51OC"
    VALUE
    0x8080746B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA51Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA51Unintended"
    VALUE
    0x8080746C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52OC"
    VALUE
    0x8080746D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA52Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA52Unintended"
    VALUE
    0x8080746E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53OC"
    VALUE
    0x8080746F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA53Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA53Unintended"
    VALUE
    0x80807470
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54OC"
    VALUE
    0x80807471
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outA54Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outA54Unintended"
    VALUE
    0x80807472
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAov_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAov"
    VALUE
    0x80807473
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAovCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAovCfg"
    VALUE
    0x80807474
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAovCfgPI_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAovCfgPI"
    VALUE
    0x80807475
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAovGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAovGetStatus"
    VALUE
    0x80807476
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAovGetVoltage_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80807477
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outAovResetError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outAovResetError"
    VALUE
    0x80807478
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDo"
    VALUE
    0x80807479
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDoCfgPwrLs_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x8080747A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDoDisable_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDoDisable"
    VALUE
    0x8080747B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDoGetCurrent_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x8080747C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDoGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDoGetStatus"
    VALUE
    0x8080747D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outDoResetError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outDoResetError"
    VALUE
    0x8080747E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07OC"
    VALUE
    0x8080747F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK07Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK07Unintended"
    VALUE
    0x80807480
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08OC"
    VALUE
    0x80807481
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK08Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK08Unintended"
    VALUE
    0x80807482
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09OC"
    VALUE
    0x80807483
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK09Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK09Unintended"
    VALUE
    0x80807484
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12OC"
    VALUE
    0x80807485
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK12Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK12Unintended"
    VALUE
    0x80807486
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13OC"
    VALUE
    0x80807487
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK13Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK13Unintended"
    VALUE
    0x80807488
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14OC"
    VALUE
    0x80807489
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK14Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK14Unintended"
    VALUE
    0x8080748A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15OC"
    VALUE
    0x8080748B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK15Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK15Unintended"
    VALUE
    0x8080748C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16OC"
    VALUE
    0x8080748D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK16Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK16Unintended"
    VALUE
    0x8080748E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17OC"
    VALUE
    0x8080748F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK17Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK17Unintended"
    VALUE
    0x80807490
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29OC"
    VALUE
    0x80807491
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK29Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK29Unintended"
    VALUE
    0x80807492
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51OC"
    VALUE
    0x80807493
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK51Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK51Unintended"
    VALUE
    0x80807494
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73OC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73OC"
    VALUE
    0x80807495
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outK73Unintended_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outK73Unintended"
    VALUE
    0x80807496
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPo"
    VALUE
    0x80807497
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoCfg"
    VALUE
    0x80807498
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoCfgPeriod_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80807499
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoCfgPwrLs_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x8080749A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoDisable_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoDisable"
    VALUE
    0x8080749B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoGetCurrent_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x8080749C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoGetStatus"
    VALUE
    0x8080749D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoResetError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoResetError"
    VALUE
    0x8080749E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPoc_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPoc"
    VALUE
    0x8080749F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPocCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPocCfg"
    VALUE
    0x808074A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPocCfgDither_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPocCfgDither"
    VALUE
    0x808074A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPocCfgPI_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPocCfgPI"
    VALUE
    0x808074A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPod_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPod"
    VALUE
    0x808074A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPodCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPodCfg"
    VALUE
    0x808074A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_outPodCfgPeriod_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x808074A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_rsmFfiApiCallErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x808074A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safout_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safout"
    VALUE
    0x808074A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutCfg"
    VALUE
    0x808074A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1"
    VALUE
    0x808074A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10"
    VALUE
    0x808074AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl10Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x808074AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl10OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x808074AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11"
    VALUE
    0x808074AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl11Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x808074AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl11OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x808074AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl12_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12"
    VALUE
    0x808074B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl12Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x808074B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl12OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x808074B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13"
    VALUE
    0x808074B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl13Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x808074B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl13OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x808074B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14"
    VALUE
    0x808074B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl14Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x808074B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl14OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x808074B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl15_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15"
    VALUE
    0x808074B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl15Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x808074BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl15OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x808074BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl16_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16"
    VALUE
    0x808074BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl16Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x808074BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl16OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x808074BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl17_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17"
    VALUE
    0x808074BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl17Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x808074C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl17OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x808074C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl18_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18"
    VALUE
    0x808074C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl18Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x808074C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl18OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x808074C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl1Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x808074C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl1OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x808074C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2"
    VALUE
    0x808074C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl2Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x808074C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl2OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x808074C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3"
    VALUE
    0x808074CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl3Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x808074CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl3OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x808074CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4"
    VALUE
    0x808074CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl4Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x808074CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl4OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x808074CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5"
    VALUE
    0x808074D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl5Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x808074D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl5OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x808074D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl6_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6"
    VALUE
    0x808074D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl6Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x808074D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl6OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x808074D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7"
    VALUE
    0x808074D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl7Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x808074D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl7OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x808074D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8"
    VALUE
    0x808074D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl8Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x808074DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl8OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x808074DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl9_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9"
    VALUE
    0x808074DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl9Dev_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x808074DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutChnl9OR_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x808074DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutDevError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutDevError"
    VALUE
    0x808074DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutGetStatus_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutGetStatus"
    VALUE
    0x808074E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutIgnoreError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x808074E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutResetError_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutResetError"
    VALUE
    0x808074E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safoutUnlock_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safoutUnlock"
    VALUE
    0x808074E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_safout_cfgDiag_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x808074E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secAccessDenied_RC_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x808074E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secAccessDenied_WDBI_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x808074E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secEvalRespKey_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secEvalRespKey"
    VALUE
    0x808074E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secFlashingFailure_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secFlashingFailure"
    VALUE
    0x808074E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secGetLevel_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secGetLevel"
    VALUE
    0x808074E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secGetRnd_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secGetRnd"
    VALUE
    0x808074EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secGetSeed_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secGetSeed"
    VALUE
    0x808074EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secInvalidPassword_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secInvalidPassword"
    VALUE
    0x808074EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secIsRequestAllowed_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x808074ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secResetLevel_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secResetLevel"
    VALUE
    0x808074EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secSaveSecret_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secSaveSecret"
    VALUE
    0x808074EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_secSetLevel_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_secSetLevel"
    VALUE
    0x808074F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysAit_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysAit"
    VALUE
    0x808074F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysAiv_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysAiv"
    VALUE
    0x808074F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysDi_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysDi"
    VALUE
    0x808074F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysDo_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysDo"
    VALUE
    0x808074F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysGetVss_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysGetVss"
    VALUE
    0x808074F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysInit_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysInit"
    VALUE
    0x808074F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysOperHrIntegrityErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x808074F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysOperHrsSaturated_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x808074F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sysSetVss_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sysSetVss"
    VALUE
    0x808074F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sys_coreload_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sys_coreload"
    VALUE
    0x808074FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_sys_taskload_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_sys_taskload"
    VALUE
    0x808074FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VSS1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x808074FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_OV_VSS2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x808074FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VSS1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x808074FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rbr_mo_UV_VSS2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x808074FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80807500
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80807501
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80807502
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80807503
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80807504
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_CAN_E_TIMEOUT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80807505
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80807506
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80807507
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80807508
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80807509
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x8080750A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x8080750B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_LIN_E_TIMEOUT_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x8080750C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_MultiStackTrace_Threshold_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x8080750D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_ETH_E_ACCESS_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x8080750E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x8080750F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80807510
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_MRly_Diag_Stk_Event_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80807511
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80807512
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_MemDiag_MemReadErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80807513
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_MemDiag_MemWrErr_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80807514
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80807515
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_T15_Diag_ComInVld_Event_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80807516
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80807517
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80807518
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80807519
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x8080751A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x8080751B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x8080751C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x8080751D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x8080751E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x8080751F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_22_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80807520
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_23_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80807521
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80807522
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80807523
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80807524
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM0_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80807525
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM10_16_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80807526
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM10_17_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80807527
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM10_21_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80807528
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80807529
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x8080752A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x8080752B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x8080752C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x8080752D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x8080752E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x8080752F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM11_9_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80807530
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80807531
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80807532
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80807533
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80807534
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80807535
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80807536
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80807537
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_22_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80807538
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_23_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80807539
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x8080753A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x8080753B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x8080753C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM1_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x8080753D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM21_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x8080753E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM21_16_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x8080753F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM21_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80807540
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80807541
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80807542
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80807543
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80807544
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80807545
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80807546
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_22_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80807547
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_23_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80807548
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80807549
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x8080754A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x8080754B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM2_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x8080754C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x8080754D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x8080754E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x8080754F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80807550
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80807551
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80807552
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_22_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80807553
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_23_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80807554
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80807555
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80807556
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80807557
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM3_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80807558
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80807559
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x8080755A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_12_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x8080755B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x8080755C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_15_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x8080755D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_17_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x8080755E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_18_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x8080755F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80807560
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_20_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80807561
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_21_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80807562
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_25_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80807563
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80807564
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_5_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80807565
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_7_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80807566
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM6_8_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80807567
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80807568
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_12_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80807569
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x8080756A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_14_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x8080756B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_15_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x8080756C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_16_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x8080756D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_17_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x8080756E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x8080756F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_20_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80807570
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_25_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80807571
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_26_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80807572
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_28_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80807573
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_29_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80807574
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_30_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80807575
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM7_31_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80807576
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80807577
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80807578
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_10_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80807579
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_11_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x8080757A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_12_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x8080757B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_13_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x8080757C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_16_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x8080757D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_18_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x8080757E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x8080757F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80807580
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_30_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80807581
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_31_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80807582
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM8_4_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80807583
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80807584
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80807585
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_15_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80807586
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MOXEMM_SMU_ALM9_3_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80807587
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoCSOPICO_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoCSOPICO"
    VALUE
    0x80807588
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoFVarPostBldSel_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoFVarPostBldSel"
    VALUE
    0x80807589
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoSysCtrlReIni_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoSysCtrlReIni"
    VALUE
    0x8080758A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTMCUFW_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x8080758B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTMonBIST_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x8080758C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTRegMonTest_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x8080758D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x8080758E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTTempSens_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x8080758F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_MoXEMMHwLTUCBCfg_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80807590
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_OCWDAABEActv_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_OCWDAABEActv"
    VALUE
    0x80807591
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_OCWDACom_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_OCWDACom"
    VALUE
    0x80807592
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_OCWDAErrPin_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_OCWDAErrPin"
    VALUE
    0x80807593
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_SWReset_0_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_SWReset_0"
    VALUE
    0x80807594
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_SWReset_1_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_SWReset_1"
    VALUE
    0x80807595
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAEFMI.DFC_SWReset_2_C
    "J1939FMI specific trouble code / J1939FMI specific specific diagnostic trouble code for check DFC_SWReset_2"
    VALUE
    0x80807596
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Env.xSet1_CA
    "set of signals per environment data / Signal selection for environment dataset 1"
    VAL_BLK
    0x808084F8
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 6 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Env.xSet2_CA
    "set of signals per environment data / Signal selection for environment dataset 2"
    VAL_BLK
    0x80808504
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 6 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Env.xSet3_CA
    "set of signals per environment data / Signal selection for environment dataset 3"
    VAL_BLK
    0x80808510
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 6 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Env.xSet4_CA
    "set of signals per environment data / Signal selection for environment dataset 4"
    VAL_BLK
    0x8080851C
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 6 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Env.xSet5_CA
    "set of signals per environment data / Signal selection for environment dataset 5"
    VAL_BLK
    0x80808528
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 6 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_Unused_C
    "used environment signals / "
    VALUE
    0x80807598
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80c7_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80807599
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80c8_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80c8"
    VALUE
    0x8080759A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80c9_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80c9"
    VALUE
    0x8080759B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ca_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ca"
    VALUE
    0x8080759C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80cb_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80cb"
    VALUE
    0x8080759D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80cc_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80cc"
    VALUE
    0x8080759E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80cd_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80cd"
    VALUE
    0x8080759F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ce_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ce"
    VALUE
    0x808075A0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80cf_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80cf"
    VALUE
    0x808075A1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80d0_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80d0"
    VALUE
    0x808075A2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80d1_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80d1"
    VALUE
    0x808075A3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80d2_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80d2"
    VALUE
    0x808075A4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80d3_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80d3"
    VALUE
    0x808075A5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80d4_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80d4"
    VALUE
    0x808075A6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80d5_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80d5"
    VALUE
    0x808075A7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80d6_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80d6"
    VALUE
    0x808075A8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80d7_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80d7"
    VALUE
    0x808075A9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80d8_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80d8"
    VALUE
    0x808075AA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80d9_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80d9"
    VALUE
    0x808075AB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80da_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80da"
    VALUE
    0x808075AC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80db_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80db"
    VALUE
    0x808075AD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80dc_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80dc"
    VALUE
    0x808075AE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80dd_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80dd"
    VALUE
    0x808075AF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80de_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80de"
    VALUE
    0x808075B0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80df_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80df"
    VALUE
    0x808075B1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80e0_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80e0"
    VALUE
    0x808075B2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80e1_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80e1"
    VALUE
    0x808075B3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80e2_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80e2"
    VALUE
    0x808075B4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80e3_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80e3"
    VALUE
    0x808075B5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80e4_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80e4"
    VALUE
    0x808075B6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80e5_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80e5"
    VALUE
    0x808075B7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80e6_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80e6"
    VALUE
    0x808075B8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80e7_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80e7"
    VALUE
    0x808075B9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80e8_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80e8"
    VALUE
    0x808075BA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80e9_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80e9"
    VALUE
    0x808075BB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ea_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ea"
    VALUE
    0x808075BC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80eb_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80eb"
    VALUE
    0x808075BD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ec_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ec"
    VALUE
    0x808075BE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ed_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ed"
    VALUE
    0x808075BF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ee_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ee"
    VALUE
    0x808075C0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ef_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ef"
    VALUE
    0x808075C1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80f0_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80f0"
    VALUE
    0x808075C2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80f1_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80f1"
    VALUE
    0x808075C3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80f2_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80f2"
    VALUE
    0x808075C4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80f3_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80f3"
    VALUE
    0x808075C5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80f4_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80f4"
    VALUE
    0x808075C6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80f5_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80f5"
    VALUE
    0x808075C7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80f6_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80f6"
    VALUE
    0x808075C8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80f7_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80f7"
    VALUE
    0x808075C9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80f8_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80f8"
    VALUE
    0x808075CA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80f9_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80f9"
    VALUE
    0x808075CB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80fa_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80fa"
    VALUE
    0x808075CC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80fb_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80fb"
    VALUE
    0x808075CD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80fc_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80fc"
    VALUE
    0x808075CE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80fd_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80fd"
    VALUE
    0x808075CF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80fe_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80fe"
    VALUE
    0x808075D0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ff_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ff"
    VALUE
    0x808075D1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8100_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8100"
    VALUE
    0x808075D2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8101_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8101"
    VALUE
    0x808075D3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8102_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8102"
    VALUE
    0x808075D4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8103_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8103"
    VALUE
    0x808075D5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8104_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8104"
    VALUE
    0x808075D6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8105_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8105"
    VALUE
    0x808075D7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8106_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8106"
    VALUE
    0x808075D8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8107_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8107"
    VALUE
    0x808075D9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8108_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8108"
    VALUE
    0x808075DA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8109_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8109"
    VALUE
    0x808075DB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x810a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x810a"
    VALUE
    0x808075DC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x810b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x810b"
    VALUE
    0x808075DD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x810c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x810c"
    VALUE
    0x808075DE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x810d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x810d"
    VALUE
    0x808075DF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x810e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x810e"
    VALUE
    0x808075E0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x810f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x810f"
    VALUE
    0x808075E1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8110_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8110"
    VALUE
    0x808075E2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8111_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8111"
    VALUE
    0x808075E3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8112_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8112"
    VALUE
    0x808075E4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8113_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8113"
    VALUE
    0x808075E5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8114_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8114"
    VALUE
    0x808075E6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8115_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8115"
    VALUE
    0x808075E7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8116_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8116"
    VALUE
    0x808075E8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8117_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8117"
    VALUE
    0x808075E9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8118_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8118"
    VALUE
    0x808075EA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8119_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8119"
    VALUE
    0x808075EB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x811a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x811a"
    VALUE
    0x808075EC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x811b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x811b"
    VALUE
    0x808075ED
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x811c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x811c"
    VALUE
    0x808075EE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x811d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x811d"
    VALUE
    0x808075EF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x811e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x811e"
    VALUE
    0x808075F0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x811f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x811f"
    VALUE
    0x808075F1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8120_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8120"
    VALUE
    0x808075F2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8121_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8121"
    VALUE
    0x808075F3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8122_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8122"
    VALUE
    0x808075F4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8123_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8123"
    VALUE
    0x808075F5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8124_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8124"
    VALUE
    0x808075F6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8125_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8125"
    VALUE
    0x808075F7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8126_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8126"
    VALUE
    0x808075F8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8127_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8127"
    VALUE
    0x808075F9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8128_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8128"
    VALUE
    0x808075FA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8129_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8129"
    VALUE
    0x808075FB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x812a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x812a"
    VALUE
    0x808075FC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_TiInRow0x8B01_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_TiInRow0x8B01"
    VALUE
    0x808075FD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_TiInRow0x8B02_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_TiInRow0x8B02"
    VALUE
    0x808075FE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_TiInRow0x8B03_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_TiInRow0x8B03"
    VALUE
    0x808075FF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_DevLibBattUHi_C
    "used environment signals / Reference to used environment condition set for check DFC_DevLibBattUHi"
    VALUE
    0x80807600
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_DevLibBattULo_C
    "used environment signals / Reference to used environment condition set for check DFC_DevLibBattULo"
    VALUE
    0x80807601
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8063_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8063"
    VALUE
    0x80807602
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8064_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8064"
    VALUE
    0x80807603
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8065_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8065"
    VALUE
    0x80807604
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8066_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8066"
    VALUE
    0x80807605
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8067_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8067"
    VALUE
    0x80807606
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8068_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8068"
    VALUE
    0x80807607
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8069_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8069"
    VALUE
    0x80807608
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x806a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x806a"
    VALUE
    0x80807609
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x806b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x806b"
    VALUE
    0x8080760A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x806c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x806c"
    VALUE
    0x8080760B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x806d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x806d"
    VALUE
    0x8080760C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x806e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x806e"
    VALUE
    0x8080760D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x806f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x806f"
    VALUE
    0x8080760E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8070_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8070"
    VALUE
    0x8080760F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8071_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8071"
    VALUE
    0x80807610
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8072_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8072"
    VALUE
    0x80807611
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8073_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8073"
    VALUE
    0x80807612
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8074_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8074"
    VALUE
    0x80807613
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8075_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8075"
    VALUE
    0x80807614
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8076_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8076"
    VALUE
    0x80807615
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8077_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8077"
    VALUE
    0x80807616
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8078_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8078"
    VALUE
    0x80807617
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8079_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8079"
    VALUE
    0x80807618
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x807a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x807a"
    VALUE
    0x80807619
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x807b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x807b"
    VALUE
    0x8080761A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x807c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x807c"
    VALUE
    0x8080761B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x807d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x807d"
    VALUE
    0x8080761C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x807e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x807e"
    VALUE
    0x8080761D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x807f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x807f"
    VALUE
    0x8080761E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8080_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8080"
    VALUE
    0x8080761F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8081_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8081"
    VALUE
    0x80807620
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8082_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8082"
    VALUE
    0x80807621
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8083_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8083"
    VALUE
    0x80807622
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8084_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8084"
    VALUE
    0x80807623
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8085_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8085"
    VALUE
    0x80807624
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8086_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8086"
    VALUE
    0x80807625
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8087_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8087"
    VALUE
    0x80807626
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8088_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8088"
    VALUE
    0x80807627
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8089_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8089"
    VALUE
    0x80807628
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x808a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x808a"
    VALUE
    0x80807629
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x808b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x808b"
    VALUE
    0x8080762A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x808c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x808c"
    VALUE
    0x8080762B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x808d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x808d"
    VALUE
    0x8080762C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x808e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x808e"
    VALUE
    0x8080762D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x808f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x808f"
    VALUE
    0x8080762E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8090_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8090"
    VALUE
    0x8080762F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8091_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8091"
    VALUE
    0x80807630
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8092_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8092"
    VALUE
    0x80807631
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8093_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8093"
    VALUE
    0x80807632
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8094_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8094"
    VALUE
    0x80807633
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8095_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8095"
    VALUE
    0x80807634
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8096_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8096"
    VALUE
    0x80807635
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8097_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8097"
    VALUE
    0x80807636
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8098_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8098"
    VALUE
    0x80807637
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8099_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8099"
    VALUE
    0x80807638
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x809a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x809a"
    VALUE
    0x80807639
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x809b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x809b"
    VALUE
    0x8080763A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x809c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x809c"
    VALUE
    0x8080763B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x809d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x809d"
    VALUE
    0x8080763C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x809e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x809e"
    VALUE
    0x8080763D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x809f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x809f"
    VALUE
    0x8080763E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80a0_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80a0"
    VALUE
    0x8080763F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80a1_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80a1"
    VALUE
    0x80807640
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80a2_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80a2"
    VALUE
    0x80807641
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80a3_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80a3"
    VALUE
    0x80807642
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80a4_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80a4"
    VALUE
    0x80807643
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80a5_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80807644
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80a6_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80a6"
    VALUE
    0x80807645
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80a7_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80a7"
    VALUE
    0x80807646
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80a8_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80a8"
    VALUE
    0x80807647
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80a9_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80a9"
    VALUE
    0x80807648
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80aa_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80aa"
    VALUE
    0x80807649
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ab_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ab"
    VALUE
    0x8080764A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ac_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ac"
    VALUE
    0x8080764B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ad_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ad"
    VALUE
    0x8080764C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ae_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ae"
    VALUE
    0x8080764D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80af_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80af"
    VALUE
    0x8080764E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80b0_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80b0"
    VALUE
    0x8080764F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80b1_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80b1"
    VALUE
    0x80807650
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80b2_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80b2"
    VALUE
    0x80807651
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80b3_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80b3"
    VALUE
    0x80807652
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80b4_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80b4"
    VALUE
    0x80807653
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80b5_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80b5"
    VALUE
    0x80807654
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80b6_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80b6"
    VALUE
    0x80807655
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80b7_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80b7"
    VALUE
    0x80807656
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80b8_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80b8"
    VALUE
    0x80807657
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80b9_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80b9"
    VALUE
    0x80807658
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80ba_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80ba"
    VALUE
    0x80807659
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80bb_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80bb"
    VALUE
    0x8080765A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80bc_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80bc"
    VALUE
    0x8080765B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80bd_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80bd"
    VALUE
    0x8080765C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80be_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80be"
    VALUE
    0x8080765D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80bf_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80bf"
    VALUE
    0x8080765E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80c0_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80c0"
    VALUE
    0x8080765F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80c1_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80c1"
    VALUE
    0x80807660
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80c2_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80c2"
    VALUE
    0x80807661
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80c3_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80c3"
    VALUE
    0x80807662
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80c4_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80c4"
    VALUE
    0x80807663
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80c5_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80c5"
    VALUE
    0x80807664
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x80c6_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x80c6"
    VALUE
    0x80807665
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_TiUpDwn0x8A01_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x80807666
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_TiUpDwn0x8A02_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x80807667
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_TiUpDwn0x8A03_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x80807668
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA13OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA13OR"
    VALUE
    0x80807669
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA13SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA13SCB"
    VALUE
    0x8080766A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA13SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA13SCG"
    VALUE
    0x8080766B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA14OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA14OR"
    VALUE
    0x8080766C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA14SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA14SCB"
    VALUE
    0x8080766D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA14SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA14SCG"
    VALUE
    0x8080766E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA21OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA21OR"
    VALUE
    0x8080766F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA21SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA21SCB"
    VALUE
    0x80807670
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA21SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA21SCG"
    VALUE
    0x80807671
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA22OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA22OR"
    VALUE
    0x80807672
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA22SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA22SCB"
    VALUE
    0x80807673
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA22SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA22SCG"
    VALUE
    0x80807674
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA23OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA23OR"
    VALUE
    0x80807675
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA23SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA23SCB"
    VALUE
    0x80807676
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA23SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA23SCG"
    VALUE
    0x80807677
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA24OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA24OR"
    VALUE
    0x80807678
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA24SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA24SCB"
    VALUE
    0x80807679
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA24SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA24SCG"
    VALUE
    0x8080767A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA25OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA25OR"
    VALUE
    0x8080767B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA25SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA25SCB"
    VALUE
    0x8080767C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA25SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA25SCG"
    VALUE
    0x8080767D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA26OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA26OR"
    VALUE
    0x8080767E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA26SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA26SCB"
    VALUE
    0x8080767F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA26SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA26SCG"
    VALUE
    0x80807680
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA27OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA27OR"
    VALUE
    0x80807681
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA27SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA27SCB"
    VALUE
    0x80807682
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA27SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA27SCG"
    VALUE
    0x80807683
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA28OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA28OR"
    VALUE
    0x80807684
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA28SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA28SCB"
    VALUE
    0x80807685
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA28SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA28SCG"
    VALUE
    0x80807686
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA29OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA29OR"
    VALUE
    0x80807687
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA29SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA29SCB"
    VALUE
    0x80807688
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA29SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA29SCG"
    VALUE
    0x80807689
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36AicSCB"
    VALUE
    0x8080768A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36AicSCG"
    VALUE
    0x8080768B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36OR"
    VALUE
    0x8080768C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36SCB"
    VALUE
    0x8080768D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36SCG"
    VALUE
    0x8080768E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA36ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x8080768F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37AicSCB"
    VALUE
    0x80807690
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37AicSCG"
    VALUE
    0x80807691
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37OR"
    VALUE
    0x80807692
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37SCB"
    VALUE
    0x80807693
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37SCG"
    VALUE
    0x80807694
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA37ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80807695
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80807696
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38AicSCG"
    VALUE
    0x80807697
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38OR"
    VALUE
    0x80807698
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38SCB"
    VALUE
    0x80807699
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38SCG"
    VALUE
    0x8080769A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA38ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x8080769B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39AicSCB"
    VALUE
    0x8080769C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39AicSCG"
    VALUE
    0x8080769D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39OR"
    VALUE
    0x8080769E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39SCB"
    VALUE
    0x8080769F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39SCG"
    VALUE
    0x808076A0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA39ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x808076A1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA40OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA40OR"
    VALUE
    0x808076A2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA40SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA40SCB"
    VALUE
    0x808076A3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA40SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA40SCG"
    VALUE
    0x808076A4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA41OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA41OR"
    VALUE
    0x808076A5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA41SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA41SCB"
    VALUE
    0x808076A6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA41SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA41SCG"
    VALUE
    0x808076A7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA42OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA42OR"
    VALUE
    0x808076A8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA42SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA42SCB"
    VALUE
    0x808076A9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA42SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA42SCG"
    VALUE
    0x808076AA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43AicSCB"
    VALUE
    0x808076AB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43AicSCG"
    VALUE
    0x808076AC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43OR"
    VALUE
    0x808076AD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43SCB"
    VALUE
    0x808076AE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43SCG"
    VALUE
    0x808076AF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA43ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x808076B0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA44OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA44OL"
    VALUE
    0x808076B1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA44SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA44SCB"
    VALUE
    0x808076B2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA44SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA44SCG"
    VALUE
    0x808076B3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA57OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA57OR"
    VALUE
    0x808076B4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA57SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA57SCB"
    VALUE
    0x808076B5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA57SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA57SCG"
    VALUE
    0x808076B6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA59OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA59OL"
    VALUE
    0x808076B7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA59SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA59SCB"
    VALUE
    0x808076B8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inA59SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inA59SCG"
    VALUE
    0x808076B9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK10OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK10OR"
    VALUE
    0x808076BA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK10SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK10SCB"
    VALUE
    0x808076BB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK10SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK10SCG"
    VALUE
    0x808076BC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK11OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK11OR"
    VALUE
    0x808076BD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK11SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK11SCB"
    VALUE
    0x808076BE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK11SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK11SCG"
    VALUE
    0x808076BF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30AicSCB"
    VALUE
    0x808076C0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30AicSCG"
    VALUE
    0x808076C1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30OR"
    VALUE
    0x808076C2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30SCB"
    VALUE
    0x808076C3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30SCG"
    VALUE
    0x808076C4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK30ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x808076C5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK31OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK31OR"
    VALUE
    0x808076C6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK31SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK31SCB"
    VALUE
    0x808076C7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK31SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK31SCG"
    VALUE
    0x808076C8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK32OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK32OR"
    VALUE
    0x808076C9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK32SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK32SCB"
    VALUE
    0x808076CA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK32SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK32SCG"
    VALUE
    0x808076CB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK33OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK33OR"
    VALUE
    0x808076CC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK33SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK33SCB"
    VALUE
    0x808076CD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK33SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK33SCG"
    VALUE
    0x808076CE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK34OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK34OR"
    VALUE
    0x808076CF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK34SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK34SCB"
    VALUE
    0x808076D0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK34SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK34SCG"
    VALUE
    0x808076D1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK35OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK35OR"
    VALUE
    0x808076D2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK35SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK35SCB"
    VALUE
    0x808076D3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK35SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK35SCG"
    VALUE
    0x808076D4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK36OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK36OR"
    VALUE
    0x808076D5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK36SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK36SCB"
    VALUE
    0x808076D6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK36SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK36SCG"
    VALUE
    0x808076D7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37AicSCB"
    VALUE
    0x808076D8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37AicSCG"
    VALUE
    0x808076D9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37OR"
    VALUE
    0x808076DA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37SCB"
    VALUE
    0x808076DB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37SCG"
    VALUE
    0x808076DC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK37ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x808076DD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38AicSCB"
    VALUE
    0x808076DE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38AicSCG"
    VALUE
    0x808076DF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38OR"
    VALUE
    0x808076E0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38SCB"
    VALUE
    0x808076E1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38SCG"
    VALUE
    0x808076E2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK38ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x808076E3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39AicSCB"
    VALUE
    0x808076E4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39AicSCG"
    VALUE
    0x808076E5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39OR"
    VALUE
    0x808076E6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39SCB"
    VALUE
    0x808076E7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39SCG"
    VALUE
    0x808076E8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK39ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x808076E9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40AicSCB"
    VALUE
    0x808076EA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40AicSCG"
    VALUE
    0x808076EB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40OR"
    VALUE
    0x808076EC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40SCB"
    VALUE
    0x808076ED
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40SCG"
    VALUE
    0x808076EE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK40ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x808076EF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK41AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41AicSCB"
    VALUE
    0x808076F0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK41AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41AicSCG"
    VALUE
    0x808076F1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK41OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41OR"
    VALUE
    0x808076F2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

