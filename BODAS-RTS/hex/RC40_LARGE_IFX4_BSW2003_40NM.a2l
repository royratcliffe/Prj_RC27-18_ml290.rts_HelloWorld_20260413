    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09SCG"
    VAL_BLK
    0x80804570
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10OL"
    VAL_BLK
    0x80804572
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10OT"
    VAL_BLK
    0x80804574
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10SCB"
    VAL_BLK
    0x80804576
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10SCG"
    VAL_BLK
    0x80804578
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA11OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA11OL"
    VAL_BLK
    0x8080457A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA11OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA11OT"
    VAL_BLK
    0x8080457C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA11SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA11SCB"
    VAL_BLK
    0x8080457E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA11SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA11SCG"
    VAL_BLK
    0x80804580
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA12OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA12OR"
    VAL_BLK
    0x80804582
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA12SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA12SCB"
    VAL_BLK
    0x80804584
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA12SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA12SCG"
    VAL_BLK
    0x80804586
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA16OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA16OL"
    VAL_BLK
    0x80804588
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA16OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA16OT"
    VAL_BLK
    0x8080458A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA16SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA16SCB"
    VAL_BLK
    0x8080458C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA16SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA16SCG"
    VAL_BLK
    0x8080458E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17OL"
    VAL_BLK
    0x80804590
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17OR"
    VAL_BLK
    0x80804592
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17OT"
    VAL_BLK
    0x80804594
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17SCB"
    VAL_BLK
    0x80804596
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17SCG"
    VAL_BLK
    0x80804598
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18OL"
    VAL_BLK
    0x8080459A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18OT"
    VAL_BLK
    0x8080459C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18SCB"
    VAL_BLK
    0x8080459E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18SCG"
    VAL_BLK
    0x808045A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19OL"
    VAL_BLK
    0x808045A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19OR"
    VAL_BLK
    0x808045A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19OT"
    VAL_BLK
    0x808045A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19SCB"
    VAL_BLK
    0x808045A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19SCG"
    VAL_BLK
    0x808045AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20OL"
    VAL_BLK
    0x808045AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20OR"
    VAL_BLK
    0x808045AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20OT"
    VAL_BLK
    0x808045B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20SCB"
    VAL_BLK
    0x808045B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20SCG"
    VAL_BLK
    0x808045B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31OL"
    VAL_BLK
    0x808045B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31OR"
    VAL_BLK
    0x808045B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31OT"
    VAL_BLK
    0x808045BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31SCB"
    VAL_BLK
    0x808045BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31SCG"
    VAL_BLK
    0x808045BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32OL"
    VAL_BLK
    0x808045C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32OR"
    VAL_BLK
    0x808045C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32OT"
    VAL_BLK
    0x808045C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32SCB"
    VAL_BLK
    0x808045C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32SCG"
    VAL_BLK
    0x808045C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33OL"
    VAL_BLK
    0x808045CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33OR"
    VAL_BLK
    0x808045CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33OT"
    VAL_BLK
    0x808045CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33SCB"
    VAL_BLK
    0x808045D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33SCG"
    VAL_BLK
    0x808045D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34OL"
    VAL_BLK
    0x808045D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34OR"
    VAL_BLK
    0x808045D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34OT"
    VAL_BLK
    0x808045D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34SCB"
    VAL_BLK
    0x808045DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34SCG"
    VAL_BLK
    0x808045DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35OL"
    VAL_BLK
    0x808045DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35OR"
    VAL_BLK
    0x808045E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35OT"
    VAL_BLK
    0x808045E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35SCB"
    VAL_BLK
    0x808045E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35SCG"
    VAL_BLK
    0x808045E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46OL"
    VAL_BLK
    0x808045E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46OR"
    VAL_BLK
    0x808045EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46OT"
    VAL_BLK
    0x808045EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46SCB"
    VAL_BLK
    0x808045EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46SCG"
    VAL_BLK
    0x808045F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47OL"
    VAL_BLK
    0x808045F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47OR"
    VAL_BLK
    0x808045F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47OT"
    VAL_BLK
    0x808045F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47SCB"
    VAL_BLK
    0x808045F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47SCG"
    VAL_BLK
    0x808045FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48OL"
    VAL_BLK
    0x808045FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48OR"
    VAL_BLK
    0x808045FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48OT"
    VAL_BLK
    0x80804600
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48SCB"
    VAL_BLK
    0x80804602
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48SCG"
    VAL_BLK
    0x80804604
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA49OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA49OL"
    VAL_BLK
    0x80804606
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA49OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA49OT"
    VAL_BLK
    0x80804608
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA49SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA49SCB"
    VAL_BLK
    0x8080460A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA49SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA49SCG"
    VAL_BLK
    0x8080460C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA50OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA50OL"
    VAL_BLK
    0x8080460E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA50OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA50OT"
    VAL_BLK
    0x80804610
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA50SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA50SCB"
    VAL_BLK
    0x80804612
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA50SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA50SCG"
    VAL_BLK
    0x80804614
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51OL"
    VAL_BLK
    0x80804616
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51OR"
    VAL_BLK
    0x80804618
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51OT"
    VAL_BLK
    0x8080461A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51SCB"
    VAL_BLK
    0x8080461C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51SCG"
    VAL_BLK
    0x8080461E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52OL"
    VAL_BLK
    0x80804620
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52OR"
    VAL_BLK
    0x80804622
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52OT"
    VAL_BLK
    0x80804624
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52SCB"
    VAL_BLK
    0x80804626
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52SCG"
    VAL_BLK
    0x80804628
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53OL"
    VAL_BLK
    0x8080462A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53OR"
    VAL_BLK
    0x8080462C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53OT"
    VAL_BLK
    0x8080462E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53SCB"
    VAL_BLK
    0x80804630
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53SCG"
    VAL_BLK
    0x80804632
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54OL"
    VAL_BLK
    0x80804634
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54OR"
    VAL_BLK
    0x80804636
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54OT"
    VAL_BLK
    0x80804638
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54SCB"
    VAL_BLK
    0x8080463A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54SCG"
    VAL_BLK
    0x8080463C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA55OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA55OL"
    VAL_BLK
    0x8080463E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA55OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA55OT"
    VAL_BLK
    0x80804640
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA55SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA55SCB"
    VAL_BLK
    0x80804642
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA55SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA55SCG"
    VAL_BLK
    0x80804644
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA56OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA56OL"
    VAL_BLK
    0x80804646
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA56OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA56OT"
    VAL_BLK
    0x80804648
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA56SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA56SCB"
    VAL_BLK
    0x8080464A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA56SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA56SCG"
    VAL_BLK
    0x8080464C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA58OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA58OL"
    VAL_BLK
    0x8080464E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA58OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA58OT"
    VAL_BLK
    0x80804650
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA58SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA58SCB"
    VAL_BLK
    0x80804652
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA58SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA58SCG"
    VAL_BLK
    0x80804654
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07OL"
    VAL_BLK
    0x80804656
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07OR"
    VAL_BLK
    0x80804658
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07OT"
    VAL_BLK
    0x8080465A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07SCB"
    VAL_BLK
    0x8080465C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07SCG"
    VAL_BLK
    0x8080465E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08OL"
    VAL_BLK
    0x80804660
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08OR"
    VAL_BLK
    0x80804662
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08OT"
    VAL_BLK
    0x80804664
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08SCB"
    VAL_BLK
    0x80804666
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08SCG"
    VAL_BLK
    0x80804668
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09OL"
    VAL_BLK
    0x8080466A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09OR"
    VAL_BLK
    0x8080466C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09OT"
    VAL_BLK
    0x8080466E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09SCB"
    VAL_BLK
    0x80804670
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09SCG"
    VAL_BLK
    0x80804672
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12OL"
    VAL_BLK
    0x80804674
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12OT"
    VAL_BLK
    0x80804676
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12SCB"
    VAL_BLK
    0x80804678
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12SCG"
    VAL_BLK
    0x8080467A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13OL"
    VAL_BLK
    0x8080467C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13OT"
    VAL_BLK
    0x8080467E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13SCB"
    VAL_BLK
    0x80804680
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13SCG"
    VAL_BLK
    0x80804682
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14OL"
    VAL_BLK
    0x80804684
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14OR"
    VAL_BLK
    0x80804686
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14OT"
    VAL_BLK
    0x80804688
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14SCB"
    VAL_BLK
    0x8080468A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14SCG"
    VAL_BLK
    0x8080468C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15OL"
    VAL_BLK
    0x8080468E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15OR"
    VAL_BLK
    0x80804690
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15OT"
    VAL_BLK
    0x80804692
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15SCB"
    VAL_BLK
    0x80804694
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15SCG"
    VAL_BLK
    0x80804696
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16OL"
    VAL_BLK
    0x80804698
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16OR"
    VAL_BLK
    0x8080469A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16OT"
    VAL_BLK
    0x8080469C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16SCB"
    VAL_BLK
    0x8080469E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16SCG"
    VAL_BLK
    0x808046A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17OL"
    VAL_BLK
    0x808046A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17OR"
    VAL_BLK
    0x808046A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17OT"
    VAL_BLK
    0x808046A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17SCB"
    VAL_BLK
    0x808046A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17SCG"
    VAL_BLK
    0x808046AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK25OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK25OR"
    VAL_BLK
    0x808046AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK25SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK25SCB"
    VAL_BLK
    0x808046AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK25SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK25SCG"
    VAL_BLK
    0x808046B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29OL"
    VAL_BLK
    0x808046B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29OR"
    VAL_BLK
    0x808046B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29OT"
    VAL_BLK
    0x808046B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29SCB"
    VAL_BLK
    0x808046B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29SCG"
    VAL_BLK
    0x808046BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51OL"
    VAL_BLK
    0x808046BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51OT"
    VAL_BLK
    0x808046BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51SCB"
    VAL_BLK
    0x808046C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51SCG"
    VAL_BLK
    0x808046C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK62OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK62OR"
    VAL_BLK
    0x808046C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK62SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK62SCB"
    VAL_BLK
    0x808046C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK62SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK62SCG"
    VAL_BLK
    0x808046C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73OL"
    VAL_BLK
    0x808046CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73OR"
    VAL_BLK
    0x808046CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73OT"
    VAL_BLK
    0x808046CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73SCB"
    VAL_BLK
    0x808046D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73SCG"
    VAL_BLK
    0x808046D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK80OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK80OL"
    VAL_BLK
    0x808046D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK80OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK80OT"
    VAL_BLK
    0x808046D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK80SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK80SCB"
    VAL_BLK
    0x808046D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK80SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK80SCG"
    VAL_BLK
    0x808046DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK81OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK81OL"
    VAL_BLK
    0x808046DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK81OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK81OT"
    VAL_BLK
    0x808046DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK81SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK81SCB"
    VAL_BLK
    0x808046E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK81SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK81SCG"
    VAL_BLK
    0x808046E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK82OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK82OL"
    VAL_BLK
    0x808046E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK82OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK82OT"
    VAL_BLK
    0x808046E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK82SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK82SCB"
    VAL_BLK
    0x808046E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK82SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK82SCG"
    VAL_BLK
    0x808046EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK83OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK83OL"
    VAL_BLK
    0x808046EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK83OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK83OT"
    VAL_BLK
    0x808046EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK83SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK83SCB"
    VAL_BLK
    0x808046F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK83SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK83SCG"
    VAL_BLK
    0x808046F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK84OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK84OL"
    VAL_BLK
    0x808046F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK84OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK84OT"
    VAL_BLK
    0x808046F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK84SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK84SCB"
    VAL_BLK
    0x808046F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK84SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK84SCG"
    VAL_BLK
    0x808046FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK85OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK85OL"
    VAL_BLK
    0x808046FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK85OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK85OT"
    VAL_BLK
    0x808046FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK85SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK85SCB"
    VAL_BLK
    0x80804700
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK85SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK85SCG"
    VAL_BLK
    0x80804702
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK86OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK86OL"
    VAL_BLK
    0x80804704
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK86OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK86OT"
    VAL_BLK
    0x80804706
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK86SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK86SCB"
    VAL_BLK
    0x80804708
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK86SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK86SCG"
    VAL_BLK
    0x8080470A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK87OL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK87OL"
    VAL_BLK
    0x8080470C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK87OT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK87OT"
    VAL_BLK
    0x8080470E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK87SCB_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK87SCB"
    VAL_BLK
    0x80804710
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK87SCG_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK87SCG"
    VAL_BLK
    0x80804712
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_DSMDummy_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_DSMDummy"
    VAL_BLK
    0x80804714
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8000_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8000"
    VAL_BLK
    0x80804716
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8001_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8001"
    VAL_BLK
    0x80804718
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8002_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8002"
    VAL_BLK
    0x8080471A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8003_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8003"
    VAL_BLK
    0x8080471C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8004_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8004"
    VAL_BLK
    0x8080471E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8005_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8005"
    VAL_BLK
    0x80804720
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8006_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8006"
    VAL_BLK
    0x80804722
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8007_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8007"
    VAL_BLK
    0x80804724
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8008_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8008"
    VAL_BLK
    0x80804726
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8009_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8009"
    VAL_BLK
    0x80804728
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x800a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x800a"
    VAL_BLK
    0x8080472A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x800b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x800b"
    VAL_BLK
    0x8080472C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x800c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x800c"
    VAL_BLK
    0x8080472E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x800d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x800d"
    VAL_BLK
    0x80804730
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x800e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x800e"
    VAL_BLK
    0x80804732
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x800f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x800f"
    VAL_BLK
    0x80804734
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8010_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8010"
    VAL_BLK
    0x80804736
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8011_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8011"
    VAL_BLK
    0x80804738
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8012_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8012"
    VAL_BLK
    0x8080473A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8013_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8013"
    VAL_BLK
    0x8080473C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8014_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8014"
    VAL_BLK
    0x8080473E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8015_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8015"
    VAL_BLK
    0x80804740
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8016_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8016"
    VAL_BLK
    0x80804742
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8017_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8017"
    VAL_BLK
    0x80804744
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8018_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8018"
    VAL_BLK
    0x80804746
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8019_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8019"
    VAL_BLK
    0x80804748
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x801a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x801a"
    VAL_BLK
    0x8080474A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x801b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x801b"
    VAL_BLK
    0x8080474C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x801c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x801c"
    VAL_BLK
    0x8080474E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x801d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x801d"
    VAL_BLK
    0x80804750
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x801e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x801e"
    VAL_BLK
    0x80804752
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x801f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x801f"
    VAL_BLK
    0x80804754
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8020_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8020"
    VAL_BLK
    0x80804756
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8021_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8021"
    VAL_BLK
    0x80804758
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8022_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8022"
    VAL_BLK
    0x8080475A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8023_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8023"
    VAL_BLK
    0x8080475C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8024_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8024"
    VAL_BLK
    0x8080475E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8025_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8025"
    VAL_BLK
    0x80804760
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8026_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8026"
    VAL_BLK
    0x80804762
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8027_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8027"
    VAL_BLK
    0x80804764
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8028_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8028"
    VAL_BLK
    0x80804766
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8029_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8029"
    VAL_BLK
    0x80804768
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x802a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x802a"
    VAL_BLK
    0x8080476A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x802b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x802b"
    VAL_BLK
    0x8080476C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x802c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x802c"
    VAL_BLK
    0x8080476E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x802d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x802d"
    VAL_BLK
    0x80804770
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x802e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x802e"
    VAL_BLK
    0x80804772
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x802f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x802f"
    VAL_BLK
    0x80804774
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8030_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8030"
    VAL_BLK
    0x80804776
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8031_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8031"
    VAL_BLK
    0x80804778
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8032_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8032"
    VAL_BLK
    0x8080477A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8033_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8033"
    VAL_BLK
    0x8080477C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8034_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8034"
    VAL_BLK
    0x8080477E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8035_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8035"
    VAL_BLK
    0x80804780
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8036_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8036"
    VAL_BLK
    0x80804782
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8037_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8037"
    VAL_BLK
    0x80804784
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8038_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8038"
    VAL_BLK
    0x80804786
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8039_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8039"
    VAL_BLK
    0x80804788
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x803a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x803a"
    VAL_BLK
    0x8080478A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x803b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x803b"
    VAL_BLK
    0x8080478C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x803c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x803c"
    VAL_BLK
    0x8080478E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x803d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x803d"
    VAL_BLK
    0x80804790
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x803e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x803e"
    VAL_BLK
    0x80804792
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x803f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x803f"
    VAL_BLK
    0x80804794
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8040_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8040"
    VAL_BLK
    0x80804796
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8041_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8041"
    VAL_BLK
    0x80804798
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8042_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8042"
    VAL_BLK
    0x8080479A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8043_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8043"
    VAL_BLK
    0x8080479C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8044_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8044"
    VAL_BLK
    0x8080479E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8045_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8045"
    VAL_BLK
    0x808047A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8046_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8046"
    VAL_BLK
    0x808047A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8047_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8047"
    VAL_BLK
    0x808047A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8048_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8048"
    VAL_BLK
    0x808047A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8049_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8049"
    VAL_BLK
    0x808047A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x804a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x804a"
    VAL_BLK
    0x808047AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x804b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x804b"
    VAL_BLK
    0x808047AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x804c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x804c"
    VAL_BLK
    0x808047AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x804d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x804d"
    VAL_BLK
    0x808047B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x804e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x804e"
    VAL_BLK
    0x808047B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x804f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x804f"
    VAL_BLK
    0x808047B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8050_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8050"
    VAL_BLK
    0x808047B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8051_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8051"
    VAL_BLK
    0x808047B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8052_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8052"
    VAL_BLK
    0x808047BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8053_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8053"
    VAL_BLK
    0x808047BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8054_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8054"
    VAL_BLK
    0x808047BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8055_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8055"
    VAL_BLK
    0x808047C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8056_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8056"
    VAL_BLK
    0x808047C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8057_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8057"
    VAL_BLK
    0x808047C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8058_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8058"
    VAL_BLK
    0x808047C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8059_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8059"
    VAL_BLK
    0x808047C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x805a_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x805a"
    VAL_BLK
    0x808047CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x805b_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x805b"
    VAL_BLK
    0x808047CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x805c_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x805c"
    VAL_BLK
    0x808047CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x805d_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x805d"
    VAL_BLK
    0x808047D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x805e_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x805e"
    VAL_BLK
    0x808047D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x805f_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x805f"
    VAL_BLK
    0x808047D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8060_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8060"
    VAL_BLK
    0x808047D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8061_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8061"
    VAL_BLK
    0x808047D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8062_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8062"
    VAL_BLK
    0x808047DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8C01_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8C01"
    VAL_BLK
    0x808047DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8C02_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8C02"
    VAL_BLK
    0x808047DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_bds_NoDeb0x8C03_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_bds_NoDeb0x8C03"
    VAL_BLK
    0x808047E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetDataNoBuf_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetDataNoBuf"
    VAL_BLK
    0x808047E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetDataParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetDataParam"
    VAL_BLK
    0x808047E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetDataboxNoInit_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetDataboxNoInit"
    VAL_BLK
    0x808047E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetDataboxParam"
    VAL_BLK
    0x808047E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetRxBufStatusParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetRxBufStatusParam"
    VAL_BLK
    0x808047EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetStatusParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetStatusParam"
    VAL_BLK
    0x808047EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canGetTxBufStatusParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canGetTxBufStatusParam"
    VAL_BLK
    0x808047EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canInitParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canInitParam"
    VAL_BLK
    0x808047F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canInitRxDataboxOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canInitRxDataboxOverlap"
    VAL_BLK
    0x808047F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canInitRxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canInitRxDataboxParam"
    VAL_BLK
    0x808047F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canInitTxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canInitTxDataboxParam"
    VAL_BLK
    0x808047F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canIpduGroupControl_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canIpduGroupControl"
    VAL_BLK
    0x808047F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canIsDataboxFreeNoInit_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canIsDataboxFreeNoInit"
    VAL_BLK
    0x808047FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canIsDataboxFreeParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canIsDataboxFreeParam"
    VAL_BLK
    0x808047FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canIsTxEmptyParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canIsTxEmptyParam"
    VAL_BLK
    0x808047FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegBusOffCallbInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegBusOffCallbInvState"
    VAL_BLK
    0x80804800
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegBusOffCallbParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegBusOffCallbParam"
    VAL_BLK
    0x80804802
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxBufInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxBufInvState"
    VAL_BLK
    0x80804804
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxBufOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxBufOverlap"
    VAL_BLK
    0x80804806
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxBufParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxBufParam"
    VAL_BLK
    0x80804808
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxCallbInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxCallbInvState"
    VAL_BLK
    0x8080480A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxCallbParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxCallbParam"
    VAL_BLK
    0x8080480C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxDataboxInvNumb_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxDataboxInvNumb"
    VAL_BLK
    0x8080480E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxDataboxInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxDataboxInvState"
    VAL_BLK
    0x80804810
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxDataboxOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxDataboxOverlap"
    VAL_BLK
    0x80804812
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegRxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegRxDataboxParam"
    VAL_BLK
    0x80804814
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxBufInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxBufInvState"
    VAL_BLK
    0x80804816
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxBufOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxBufOverlap"
    VAL_BLK
    0x80804818
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxBufParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxBufParam"
    VAL_BLK
    0x8080481A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxDataboxInvNumb_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxDataboxInvNumb"
    VAL_BLK
    0x8080481C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxDataboxInvState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxDataboxInvState"
    VAL_BLK
    0x8080481E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxDataboxOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxDataboxOverlap"
    VAL_BLK
    0x80804820
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canRegTxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canRegTxDataboxParam"
    VAL_BLK
    0x80804822
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canResetTxBufParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canResetTxBufParam"
    VAL_BLK
    0x80804824
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canSendDataBufOvfl_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canSendDataBufOvfl"
    VAL_BLK
    0x80804826
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canSendDataParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canSendDataParam"
    VAL_BLK
    0x80804828
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canSendDataboxNoInit_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canSendDataboxNoInit"
    VAL_BLK
    0x8080482A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canSendDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canSendDataboxParam"
    VAL_BLK
    0x8080482C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canSetTxCycleParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canSetTxCycleParam"
    VAL_BLK
    0x8080482E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canStartParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canStartParam"
    VAL_BLK
    0x80804830
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_canStopParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_canStopParam"
    VAL_BLK
    0x80804832
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_can_ClearIpduGroup_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_can_ClearIpduGroup"
    VAL_BLK
    0x80804834
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_can_ReceiveSignal_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_can_ReceiveSignal"
    VAL_BLK
    0x80804836
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_can_SendSignal_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_can_SendSignal"
    VAL_BLK
    0x80804838
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_can_SetIpduGroup_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_can_SetIpduGroup"
    VAL_BLK
    0x8080483A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmDTCJ1939_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmDTCJ1939"
    VAL_BLK
    0x8080483C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmDelDTCJ1939_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmDelDTCJ1939"
    VAL_BLK
    0x8080483E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmDelErrors_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmDelErrors"
    VAL_BLK
    0x80804840
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmGetDFES_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmGetDFES"
    VAL_BLK
    0x80804842
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmGetDTCJ1939_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmGetDTCJ1939"
    VAL_BLK
    0x80804844
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmGetErrors_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmGetErrors"
    VAL_BLK
    0x80804846
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmGetNumErrors_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmGetNumErrors"
    VAL_BLK
    0x80804848
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmInitQueueOverflow_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmInitQueueOverflow"
    VAL_BLK
    0x8080484A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmNumDTCJ1939_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmNumDTCJ1939"
    VAL_BLK
    0x8080484C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmTesterror_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmTesterror"
    VAL_BLK
    0x8080484E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmUpdateDebError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmUpdateDebError"
    VAL_BLK
    0x80804850
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmUpdateError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmUpdateError"
    VAL_BLK
    0x80804852
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmgetDFCStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmgetDFCStatus"
    VAL_BLK
    0x80804854
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_dsmtestErrorDFC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_dsmtestErrorDFC"
    VAL_BLK
    0x80804856
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAi"
    VAL_BLK
    0x80804858
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAic_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAic"
    VAL_BLK
    0x8080485A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAicCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAicCfg"
    VAL_BLK
    0x8080485C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAicGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAicGetStatus"
    VAL_BLK
    0x8080485E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAid_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAid"
    VAL_BLK
    0x80804860
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAidCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAidCfg"
    VAL_BLK
    0x80804862
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAiv_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAiv"
    VAL_BLK
    0x80804864
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAivCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAivCfg"
    VAL_BLK
    0x80804866
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inAivGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inAivGetStatus"
    VAL_BLK
    0x80804868
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inDi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inDi"
    VAL_BLK
    0x8080486A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inFi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inFi"
    VAL_BLK
    0x8080486C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inFiCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inFiCfg"
    VAL_BLK
    0x8080486E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inFiGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inFiGetStatus"
    VAL_BLK
    0x80804870
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inFi_Buffered_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inFi_Buffered"
    VAL_BLK
    0x80804872
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inPhase_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inPhase"
    VAL_BLK
    0x80804874
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inPhaseGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inPhaseGetStatus"
    VAL_BLK
    0x80804876
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inPhaseResetCounter_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inPhaseResetCounter"
    VAL_BLK
    0x80804878
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inRi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inRi"
    VAL_BLK
    0x8080487A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inRiCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inRiCfg"
    VAL_BLK
    0x8080487C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inRiCfgTemp_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inRiCfgTemp"
    VAL_BLK
    0x8080487E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inRiGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inRiGetStatus"
    VAL_BLK
    0x80804880
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inRiGetTemp_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inRiGetTemp"
    VAL_BLK
    0x80804882
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentCopyFDFifo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentCopyFDFifo"
    VAL_BLK
    0x80804884
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentDisable_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentDisable"
    VAL_BLK
    0x80804886
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentEnable_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentEnable"
    VAL_BLK
    0x80804888
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentGetErrorStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentGetErrorStatus"
    VAL_BLK
    0x8080488A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentGetFD_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentGetFD"
    VAL_BLK
    0x8080488C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentGetSD_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentGetSD"
    VAL_BLK
    0x8080488E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentGetSDDatabox_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentGetSDDatabox"
    VAL_BLK
    0x80804890
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentGetStatus"
    VAL_BLK
    0x80804892
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentInitSDDatabox_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentInitSDDatabox"
    VAL_BLK
    0x80804894
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentRegisterCopyFDFifo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentRegisterCopyFDFifo"
    VAL_BLK
    0x80804896
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentRegisterFDFifo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentRegisterFDFifo"
    VAL_BLK
    0x80804898
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_inSentRegisterSDDataboxes_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_inSentRegisterSDDataboxes"
    VAL_BLK
    0x8080489A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusCanRxBufferOverflow_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusCanRxBufferOverflow"
    VAL_BLK
    0x8080489C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusGetCaAddrParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusGetCaAddrParam"
    VAL_BLK
    0x8080489E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusGetDiagnosticParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusGetDiagnosticParam"
    VAL_BLK
    0x808048A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusGetRxDataboxStatusParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusGetRxDataboxStatusParam"
    VAL_BLK
    0x808048A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusGetStatusParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusGetStatusParam"
    VAL_BLK
    0x808048A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitCommCaMissing_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitCommCaMissing"
    VAL_BLK
    0x808048A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitCommParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitCommParam"
    VAL_BLK
    0x808048A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitCommState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitCommState"
    VAL_BLK
    0x808048AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitDiagnosticParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitDiagnosticParam"
    VAL_BLK
    0x808048AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitFailureListParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitFailureListParam"
    VAL_BLK
    0x808048AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitRxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitRxDataboxParam"
    VAL_BLK
    0x808048B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusInitTxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusInitTxDataboxParam"
    VAL_BLK
    0x808048B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegRxDataboxOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegRxDataboxOverlap"
    VAL_BLK
    0x808048B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegRxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegRxDataboxParam"
    VAL_BLK
    0x808048B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegRxDataboxState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegRxDataboxState"
    VAL_BLK
    0x808048B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegTxDataboxOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegTxDataboxOverlap"
    VAL_BLK
    0x808048BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegTxDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegTxDataboxParam"
    VAL_BLK
    0x808048BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegTxDataboxState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegTxDataboxState"
    VAL_BLK
    0x808048BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegisterErrClrCallbackParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegisterErrClrCallbackParam"
    VAL_BLK
    0x808048C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegisterInstancesOverlap_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegisterInstancesOverlap"
    VAL_BLK
    0x808048C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegisterInstancesParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegisterInstancesParam"
    VAL_BLK
    0x808048C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusRegisterInstancesState_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusRegisterInstancesState"
    VAL_BLK
    0x808048C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSendDataboxParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSendDataboxParam"
    VAL_BLK
    0x808048C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSendRequestPGNParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSendRequestPGNParam"
    VAL_BLK
    0x808048CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaAddrCaUsed_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaAddrCaUsed"
    VAL_BLK
    0x808048CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaAddrComm_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaAddrComm"
    VAL_BLK
    0x808048CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaAddrInvCan_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaAddrInvCan"
    VAL_BLK
    0x808048D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaAddrParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaAddrParam"
    VAL_BLK
    0x808048D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaInfoParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaInfoParam"
    VAL_BLK
    0x808048D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSetCaNameParam_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSetCaNameParam"
    VAL_BLK
    0x808048D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_isobusSftyCanTxErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_isobusSftyCanTxErr"
    VAL_BLK
    0x808048D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_ReceiveSignal_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_ReceiveSignal"
    VAL_BLK
    0x808048DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_SendSignal_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_SendSignal"
    VAL_BLK
    0x808048DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_getStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_getStatus"
    VAL_BLK
    0x808048DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_gotoSleep_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_gotoSleep"
    VAL_BLK
    0x808048E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_scheduleRequest_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_scheduleRequest"
    VAL_BLK
    0x808048E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_lin_wakeUp_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_lin_wakeUp"
    VAL_BLK
    0x808048E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memFlsCfgShr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memFlsCfgShr"
    VAL_BLK
    0x808048E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memGetStatus"
    VAL_BLK
    0x808048E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memMarkBlock_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memMarkBlock"
    VAL_BLK
    0x808048EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadApi1Error_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadApi1Error"
    VAL_BLK
    0x808048EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadApi2Error_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadApi2Error"
    VAL_BLK
    0x808048EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadBlock_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadBlock"
    VAL_BLK
    0x808048F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadCalibInputError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadCalibInputError"
    VAL_BLK
    0x808048F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadCalibOuputError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadCalibOuputError"
    VAL_BLK
    0x808048F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memReadSystemError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memReadSystemError"
    VAL_BLK
    0x808048F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_memWriteBlock_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_memWriteBlock"
    VAL_BLK
    0x808048F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_moOV_FirstConstADC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_moOV_FirstConstADC"
    VAL_BLK
    0x808048FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_moOV_SecondConstADC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_moOV_SecondConstADC"
    VAL_BLK
    0x808048FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_moUV_FirstConstADC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_moUV_FirstConstADC"
    VAL_BLK
    0x808048FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_moUV_SecondConstADC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_moUV_SecondConstADC"
    VAL_BLK
    0x80804900
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_INH_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_INH"
    VAL_BLK
    0x80804902
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_INHLatch_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_INHLatch"
    VAL_BLK
    0x80804904
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_adcPDD_fail_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_adcPDD_fail"
    VAL_BLK
    0x80804906
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_memoryProtection_err_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_memoryProtection_err"
    VAL_BLK
    0x80804908
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02OC"
    VAL_BLK
    0x8080490A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA02Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA02Unintended"
    VAL_BLK
    0x8080490C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03OC"
    VAL_BLK
    0x8080490E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA03Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA03Unintended"
    VAL_BLK
    0x80804910
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04OC"
    VAL_BLK
    0x80804912
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA04Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA04Unintended"
    VAL_BLK
    0x80804914
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05OC"
    VAL_BLK
    0x80804916
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA05Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA05Unintended"
    VAL_BLK
    0x80804918
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07OC"
    VAL_BLK
    0x8080491A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA07Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA07Unintended"
    VAL_BLK
    0x8080491C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08OC"
    VAL_BLK
    0x8080491E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA08Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA08Unintended"
    VAL_BLK
    0x80804920
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09OC"
    VAL_BLK
    0x80804922
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA09Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA09Unintended"
    VAL_BLK
    0x80804924
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10OC"
    VAL_BLK
    0x80804926
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA10Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA10Unintended"
    VAL_BLK
    0x80804928
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17OC"
    VAL_BLK
    0x8080492A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA17Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA17Unintended"
    VAL_BLK
    0x8080492C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18OC"
    VAL_BLK
    0x8080492E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA18Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA18Unintended"
    VAL_BLK
    0x80804930
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19OC"
    VAL_BLK
    0x80804932
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA19Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA19Unintended"
    VAL_BLK
    0x80804934
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20OC"
    VAL_BLK
    0x80804936
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA20Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA20Unintended"
    VAL_BLK
    0x80804938
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31OC"
    VAL_BLK
    0x8080493A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA31Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA31Unintended"
    VAL_BLK
    0x8080493C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32OC"
    VAL_BLK
    0x8080493E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA32Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA32Unintended"
    VAL_BLK
    0x80804940
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33OC"
    VAL_BLK
    0x80804942
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA33Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA33Unintended"
    VAL_BLK
    0x80804944
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34OC"
    VAL_BLK
    0x80804946
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA34Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA34Unintended"
    VAL_BLK
    0x80804948
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35OC"
    VAL_BLK
    0x8080494A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA35Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA35Unintended"
    VAL_BLK
    0x8080494C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46OC"
    VAL_BLK
    0x8080494E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA46Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA46Unintended"
    VAL_BLK
    0x80804950
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47OC"
    VAL_BLK
    0x80804952
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA47Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA47Unintended"
    VAL_BLK
    0x80804954
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48OC"
    VAL_BLK
    0x80804956
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA48Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA48Unintended"
    VAL_BLK
    0x80804958
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51OC"
    VAL_BLK
    0x8080495A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA51Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA51Unintended"
    VAL_BLK
    0x8080495C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52OC"
    VAL_BLK
    0x8080495E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA52Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA52Unintended"
    VAL_BLK
    0x80804960
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53OC"
    VAL_BLK
    0x80804962
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA53Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA53Unintended"
    VAL_BLK
    0x80804964
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54OC"
    VAL_BLK
    0x80804966
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outA54Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outA54Unintended"
    VAL_BLK
    0x80804968
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAov_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAov"
    VAL_BLK
    0x8080496A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAovCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAovCfg"
    VAL_BLK
    0x8080496C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAovCfgPI_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAovCfgPI"
    VAL_BLK
    0x8080496E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAovGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAovGetStatus"
    VAL_BLK
    0x80804970
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAovGetVoltage_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAovGetVoltage"
    VAL_BLK
    0x80804972
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outAovResetError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outAovResetError"
    VAL_BLK
    0x80804974
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDo"
    VAL_BLK
    0x80804976
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDoCfgPwrLs_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDoCfgPwrLs"
    VAL_BLK
    0x80804978
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDoDisable_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDoDisable"
    VAL_BLK
    0x8080497A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDoGetCurrent_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDoGetCurrent"
    VAL_BLK
    0x8080497C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDoGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDoGetStatus"
    VAL_BLK
    0x8080497E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outDoResetError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outDoResetError"
    VAL_BLK
    0x80804980
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07OC"
    VAL_BLK
    0x80804982
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK07Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK07Unintended"
    VAL_BLK
    0x80804984
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08OC"
    VAL_BLK
    0x80804986
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK08Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK08Unintended"
    VAL_BLK
    0x80804988
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09OC"
    VAL_BLK
    0x8080498A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK09Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK09Unintended"
    VAL_BLK
    0x8080498C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12OC"
    VAL_BLK
    0x8080498E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK12Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK12Unintended"
    VAL_BLK
    0x80804990
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13OC"
    VAL_BLK
    0x80804992
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK13Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK13Unintended"
    VAL_BLK
    0x80804994
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14OC"
    VAL_BLK
    0x80804996
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK14Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK14Unintended"
    VAL_BLK
    0x80804998
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15OC"
    VAL_BLK
    0x8080499A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK15Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK15Unintended"
    VAL_BLK
    0x8080499C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16OC"
    VAL_BLK
    0x8080499E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK16Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK16Unintended"
    VAL_BLK
    0x808049A0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17OC"
    VAL_BLK
    0x808049A2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK17Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK17Unintended"
    VAL_BLK
    0x808049A4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29OC"
    VAL_BLK
    0x808049A6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK29Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK29Unintended"
    VAL_BLK
    0x808049A8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51OC"
    VAL_BLK
    0x808049AA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK51Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK51Unintended"
    VAL_BLK
    0x808049AC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73OC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73OC"
    VAL_BLK
    0x808049AE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outK73Unintended_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outK73Unintended"
    VAL_BLK
    0x808049B0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPo"
    VAL_BLK
    0x808049B2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoCfg"
    VAL_BLK
    0x808049B4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoCfgPeriod_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoCfgPeriod"
    VAL_BLK
    0x808049B6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoCfgPwrLs_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoCfgPwrLs"
    VAL_BLK
    0x808049B8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoDisable_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoDisable"
    VAL_BLK
    0x808049BA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoGetCurrent_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoGetCurrent"
    VAL_BLK
    0x808049BC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoGetStatus"
    VAL_BLK
    0x808049BE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoResetError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoResetError"
    VAL_BLK
    0x808049C0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPoc_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPoc"
    VAL_BLK
    0x808049C2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPocCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPocCfg"
    VAL_BLK
    0x808049C4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPocCfgDither_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPocCfgDither"
    VAL_BLK
    0x808049C6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPocCfgPI_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPocCfgPI"
    VAL_BLK
    0x808049C8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPod_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPod"
    VAL_BLK
    0x808049CA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPodCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPodCfg"
    VAL_BLK
    0x808049CC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_outPodCfgPeriod_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_outPodCfgPeriod"
    VAL_BLK
    0x808049CE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_rsmFfiApiCallErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_rsmFfiApiCallErr"
    VAL_BLK
    0x808049D0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safout_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safout"
    VAL_BLK
    0x808049D2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutCfg"
    VAL_BLK
    0x808049D4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl1"
    VAL_BLK
    0x808049D6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl10"
    VAL_BLK
    0x808049D8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl10Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl10Dev"
    VAL_BLK
    0x808049DA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl10OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl10OR"
    VAL_BLK
    0x808049DC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl11"
    VAL_BLK
    0x808049DE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl11Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl11Dev"
    VAL_BLK
    0x808049E0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl11OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl11OR"
    VAL_BLK
    0x808049E2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl12_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl12"
    VAL_BLK
    0x808049E4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl12Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl12Dev"
    VAL_BLK
    0x808049E6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl12OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl12OR"
    VAL_BLK
    0x808049E8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl13"
    VAL_BLK
    0x808049EA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl13Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl13Dev"
    VAL_BLK
    0x808049EC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl13OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl13OR"
    VAL_BLK
    0x808049EE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl14"
    VAL_BLK
    0x808049F0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl14Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl14Dev"
    VAL_BLK
    0x808049F2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl14OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl14OR"
    VAL_BLK
    0x808049F4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl15_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl15"
    VAL_BLK
    0x808049F6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl15Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl15Dev"
    VAL_BLK
    0x808049F8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl15OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl15OR"
    VAL_BLK
    0x808049FA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl16_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl16"
    VAL_BLK
    0x808049FC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl16Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl16Dev"
    VAL_BLK
    0x808049FE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl16OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl16OR"
    VAL_BLK
    0x80804A00
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl17_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl17"
    VAL_BLK
    0x80804A02
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl17Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl17Dev"
    VAL_BLK
    0x80804A04
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl17OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl17OR"
    VAL_BLK
    0x80804A06
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl18_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl18"
    VAL_BLK
    0x80804A08
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl18Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl18Dev"
    VAL_BLK
    0x80804A0A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl18OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl18OR"
    VAL_BLK
    0x80804A0C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl1Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl1Dev"
    VAL_BLK
    0x80804A0E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl1OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl1OR"
    VAL_BLK
    0x80804A10
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl2"
    VAL_BLK
    0x80804A12
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl2Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl2Dev"
    VAL_BLK
    0x80804A14
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl2OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl2OR"
    VAL_BLK
    0x80804A16
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl3"
    VAL_BLK
    0x80804A18
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl3Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl3Dev"
    VAL_BLK
    0x80804A1A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl3OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl3OR"
    VAL_BLK
    0x80804A1C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl4"
    VAL_BLK
    0x80804A1E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl4Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl4Dev"
    VAL_BLK
    0x80804A20
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl4OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl4OR"
    VAL_BLK
    0x80804A22
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl5"
    VAL_BLK
    0x80804A24
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl5Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl5Dev"
    VAL_BLK
    0x80804A26
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl5OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl5OR"
    VAL_BLK
    0x80804A28
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl6_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl6"
    VAL_BLK
    0x80804A2A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl6Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl6Dev"
    VAL_BLK
    0x80804A2C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl6OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl6OR"
    VAL_BLK
    0x80804A2E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl7"
    VAL_BLK
    0x80804A30
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl7Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl7Dev"
    VAL_BLK
    0x80804A32
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl7OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl7OR"
    VAL_BLK
    0x80804A34
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl8"
    VAL_BLK
    0x80804A36
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl8Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl8Dev"
    VAL_BLK
    0x80804A38
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl8OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl8OR"
    VAL_BLK
    0x80804A3A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl9_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl9"
    VAL_BLK
    0x80804A3C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl9Dev_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl9Dev"
    VAL_BLK
    0x80804A3E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutChnl9OR_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutChnl9OR"
    VAL_BLK
    0x80804A40
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutDevError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutDevError"
    VAL_BLK
    0x80804A42
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutGetStatus_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutGetStatus"
    VAL_BLK
    0x80804A44
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutIgnoreError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutIgnoreError"
    VAL_BLK
    0x80804A46
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutResetError_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutResetError"
    VAL_BLK
    0x80804A48
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safoutUnlock_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safoutUnlock"
    VAL_BLK
    0x80804A4A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_safout_cfgDiag_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_safout_cfgDiag"
    VAL_BLK
    0x80804A4C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secAccessDenied_RC_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secAccessDenied_RC"
    VAL_BLK
    0x80804A4E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secAccessDenied_WDBI_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secAccessDenied_WDBI"
    VAL_BLK
    0x80804A50
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secEvalRespKey_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secEvalRespKey"
    VAL_BLK
    0x80804A52
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secFlashingFailure_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secFlashingFailure"
    VAL_BLK
    0x80804A54
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secGetLevel_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secGetLevel"
    VAL_BLK
    0x80804A56
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secGetRnd_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secGetRnd"
    VAL_BLK
    0x80804A58
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secGetSeed_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secGetSeed"
    VAL_BLK
    0x80804A5A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secInvalidPassword_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secInvalidPassword"
    VAL_BLK
    0x80804A5C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secIsRequestAllowed_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secIsRequestAllowed"
    VAL_BLK
    0x80804A5E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secResetLevel_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secResetLevel"
    VAL_BLK
    0x80804A60
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secSaveSecret_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secSaveSecret"
    VAL_BLK
    0x80804A62
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_secSetLevel_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_secSetLevel"
    VAL_BLK
    0x80804A64
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysAit_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysAit"
    VAL_BLK
    0x80804A66
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysAiv_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysAiv"
    VAL_BLK
    0x80804A68
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysDi_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysDi"
    VAL_BLK
    0x80804A6A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysDo_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysDo"
    VAL_BLK
    0x80804A6C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysGetVss_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysGetVss"
    VAL_BLK
    0x80804A6E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysInit_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysInit"
    VAL_BLK
    0x80804A70
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysOperHrIntegrityErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysOperHrIntegrityErr"
    VAL_BLK
    0x80804A72
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysOperHrsSaturated_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysOperHrsSaturated"
    VAL_BLK
    0x80804A74
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sysSetVss_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sysSetVss"
    VAL_BLK
    0x80804A76
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sys_coreload_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sys_coreload"
    VAL_BLK
    0x80804A78
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_sys_taskload_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_sys_taskload"
    VAL_BLK
    0x80804A7A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VSS1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VSS1"
    VAL_BLK
    0x80804A7C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_OV_VSS2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_OV_VSS2"
    VAL_BLK
    0x80804A7E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VSS1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VSS1"
    VAL_BLK
    0x80804A80
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rbr_mo_UV_VSS2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rbr_mo_UV_VSS2"
    VAL_BLK
    0x80804A82
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VAL_BLK
    0x80804A84
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VAL_BLK
    0x80804A86
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VAL_BLK
    0x80804A88
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CANSM_E_BUS_OFF_NETWORK_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VAL_BLK
    0x80804A8A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VAL_BLK
    0x80804A8C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_CAN_E_TIMEOUT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_CAN_E_TIMEOUT"
    VAL_BLK
    0x80804A8E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VAL_BLK
    0x80804A90
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VAL_BLK
    0x80804A92
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VAL_BLK
    0x80804A94
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VAL_BLK
    0x80804A96
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VAL_BLK
    0x80804A98
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_COMM_E_NET_START_IND_CHANNEL_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VAL_BLK
    0x80804A9A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_LIN_E_TIMEOUT_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_LIN_E_TIMEOUT"
    VAL_BLK
    0x80804A9C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_MultiStackTrace_Threshold_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_MultiStackTrace_Threshold"
    VAL_BLK
    0x80804A9E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_ETH_E_ACCESS_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_ETH_E_ACCESS_0"
    VAL_BLK
    0x80804AA0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VAL_BLK
    0x80804AA2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VAL_BLK
    0x80804AA4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_MRly_Diag_Stk_Event_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_MRly_Diag_Stk_Event"
    VAL_BLK
    0x80804AA6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_MemDiagExtd_MemReadSngErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_MemDiagExtd_MemReadSngErr"
    VAL_BLK
    0x80804AA8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_MemDiag_MemReadErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_MemDiag_MemReadErr"
    VAL_BLK
    0x80804AAA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_MemDiag_MemWrErr_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_MemDiag_MemWrErr"
    VAL_BLK
    0x80804AAC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VAL_BLK
    0x80804AAE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_T15_Diag_ComInVld_Event_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_T15_Diag_ComInVld_Event"
    VAL_BLK
    0x80804AB0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_T15_Diag_ComOff_HwOn_Event_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VAL_BLK
    0x80804AB2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_rba_T15_Diag_ComOn_HwOff_Event_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VAL_BLK
    0x80804AB4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_0"
    VAL_BLK
    0x80804AB6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_1"
    VAL_BLK
    0x80804AB8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_10"
    VAL_BLK
    0x80804ABA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_11"
    VAL_BLK
    0x80804ABC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_13"
    VAL_BLK
    0x80804ABE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_14"
    VAL_BLK
    0x80804AC0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_2"
    VAL_BLK
    0x80804AC2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_22_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_22"
    VAL_BLK
    0x80804AC4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_23_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_23"
    VAL_BLK
    0x80804AC6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_4"
    VAL_BLK
    0x80804AC8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_5"
    VAL_BLK
    0x80804ACA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_7"
    VAL_BLK
    0x80804ACC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM0_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM0_8"
    VAL_BLK
    0x80804ACE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM10_16_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM10_16"
    VAL_BLK
    0x80804AD0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM10_17_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM10_17"
    VAL_BLK
    0x80804AD2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM10_21_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM10_21"
    VAL_BLK
    0x80804AD4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_0"
    VAL_BLK
    0x80804AD6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_1"
    VAL_BLK
    0x80804AD8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_2"
    VAL_BLK
    0x80804ADA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_3"
    VAL_BLK
    0x80804ADC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_4"
    VAL_BLK
    0x80804ADE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_5"
    VAL_BLK
    0x80804AE0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_8"
    VAL_BLK
    0x80804AE2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM11_9_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM11_9"
    VAL_BLK
    0x80804AE4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_0"
    VAL_BLK
    0x80804AE6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_1"
    VAL_BLK
    0x80804AE8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_10"
    VAL_BLK
    0x80804AEA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_11"
    VAL_BLK
    0x80804AEC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_13"
    VAL_BLK
    0x80804AEE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_14"
    VAL_BLK
    0x80804AF0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_2"
    VAL_BLK
    0x80804AF2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_22_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_22"
    VAL_BLK
    0x80804AF4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_23_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_23"
    VAL_BLK
    0x80804AF6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_4"
    VAL_BLK
    0x80804AF8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_5"
    VAL_BLK
    0x80804AFA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_7"
    VAL_BLK
    0x80804AFC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM1_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM1_8"
    VAL_BLK
    0x80804AFE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM21_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM21_0"
    VAL_BLK
    0x80804B00
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM21_16_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM21_16"
    VAL_BLK
    0x80804B02
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM21_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM21_3"
    VAL_BLK
    0x80804B04
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_1"
    VAL_BLK
    0x80804B06
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_10"
    VAL_BLK
    0x80804B08
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_11"
    VAL_BLK
    0x80804B0A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_13"
    VAL_BLK
    0x80804B0C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_14"
    VAL_BLK
    0x80804B0E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_2"
    VAL_BLK
    0x80804B10
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_22_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_22"
    VAL_BLK
    0x80804B12
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_23_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_23"
    VAL_BLK
    0x80804B14
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_4"
    VAL_BLK
    0x80804B16
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_5"
    VAL_BLK
    0x80804B18
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_7"
    VAL_BLK
    0x80804B1A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM2_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM2_8"
    VAL_BLK
    0x80804B1C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_1"
    VAL_BLK
    0x80804B1E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_10"
    VAL_BLK
    0x80804B20
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_11"
    VAL_BLK
    0x80804B22
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_13"
    VAL_BLK
    0x80804B24
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_14"
    VAL_BLK
    0x80804B26
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_2"
    VAL_BLK
    0x80804B28
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_22_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_22"
    VAL_BLK
    0x80804B2A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_23_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_23"
    VAL_BLK
    0x80804B2C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_4"
    VAL_BLK
    0x80804B2E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_5"
    VAL_BLK
    0x80804B30
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_7"
    VAL_BLK
    0x80804B32
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM3_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM3_8"
    VAL_BLK
    0x80804B34
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_0"
    VAL_BLK
    0x80804B36
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_11"
    VAL_BLK
    0x80804B38
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_12_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_12"
    VAL_BLK
    0x80804B3A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_14"
    VAL_BLK
    0x80804B3C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_15_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_15"
    VAL_BLK
    0x80804B3E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_17_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_17"
    VAL_BLK
    0x80804B40
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_18_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_18"
    VAL_BLK
    0x80804B42
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_2"
    VAL_BLK
    0x80804B44
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_20_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_20"
    VAL_BLK
    0x80804B46
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_21_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_21"
    VAL_BLK
    0x80804B48
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_25_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_25"
    VAL_BLK
    0x80804B4A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_4"
    VAL_BLK
    0x80804B4C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_5_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_5"
    VAL_BLK
    0x80804B4E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_7_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_7"
    VAL_BLK
    0x80804B50
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM6_8_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM6_8"
    VAL_BLK
    0x80804B52
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_1"
    VAL_BLK
    0x80804B54
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_12_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_12"
    VAL_BLK
    0x80804B56
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_13"
    VAL_BLK
    0x80804B58
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_14_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_14"
    VAL_BLK
    0x80804B5A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_15_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_15"
    VAL_BLK
    0x80804B5C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_16_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_16"
    VAL_BLK
    0x80804B5E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_17_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_17"
    VAL_BLK
    0x80804B60
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_2"
    VAL_BLK
    0x80804B62
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_20_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_20"
    VAL_BLK
    0x80804B64
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_25_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_25"
    VAL_BLK
    0x80804B66
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_26_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_26"
    VAL_BLK
    0x80804B68
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_28_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_28"
    VAL_BLK
    0x80804B6A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_29_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_29"
    VAL_BLK
    0x80804B6C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_30_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_30"
    VAL_BLK
    0x80804B6E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM7_31_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM7_31"
    VAL_BLK
    0x80804B70
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_0"
    VAL_BLK
    0x80804B72
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_1"
    VAL_BLK
    0x80804B74
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_10_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_10"
    VAL_BLK
    0x80804B76
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_11_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_11"
    VAL_BLK
    0x80804B78
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_12_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_12"
    VAL_BLK
    0x80804B7A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_13_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_13"
    VAL_BLK
    0x80804B7C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_16_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_16"
    VAL_BLK
    0x80804B7E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_18_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_18"
    VAL_BLK
    0x80804B80
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_2"
    VAL_BLK
    0x80804B82
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_3"
    VAL_BLK
    0x80804B84
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_30_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_30"
    VAL_BLK
    0x80804B86
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_31_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_31"
    VAL_BLK
    0x80804B88
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM8_4_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM8_4"
    VAL_BLK
    0x80804B8A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM9_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM9_0"
    VAL_BLK
    0x80804B8C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM9_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM9_1"
    VAL_BLK
    0x80804B8E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM9_15_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM9_15"
    VAL_BLK
    0x80804B90
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MOXEMM_SMU_ALM9_3_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MOXEMM_SMU_ALM9_3"
    VAL_BLK
    0x80804B92
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoCSOPICO_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoCSOPICO"
    VAL_BLK
    0x80804B94
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoFVarPostBldSel_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoFVarPostBldSel"
    VAL_BLK
    0x80804B96
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoSysCtrlReIni_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoSysCtrlReIni"
    VAL_BLK
    0x80804B98
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTMCUFW_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTMCUFW"
    VAL_BLK
    0x80804B9A
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTMonBIST_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTMonBIST"
    VAL_BLK
    0x80804B9C
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTRegMonTest_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTRegMonTest"
    VAL_BLK
    0x80804B9E
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTStbySMUAlvTest_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTStbySMUAlvTest"
    VAL_BLK
    0x80804BA0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTTempSens_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTTempSens"
    VAL_BLK
    0x80804BA2
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_MoXEMMHwLTUCBCfg_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_MoXEMMHwLTUCBCfg"
    VAL_BLK
    0x80804BA4
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_OCWDAABEActv_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_OCWDAABEActv"
    VAL_BLK
    0x80804BA6
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_OCWDACom_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_OCWDACom"
    VAL_BLK
    0x80804BA8
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_OCWDAErrPin_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_OCWDAErrPin"
    VAL_BLK
    0x80804BAA
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_SWReset_0_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_SWReset_0"
    VAL_BLK
    0x80804BAC
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_SWReset_1_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_SWReset_1"
    VAL_BLK
    0x80804BAE
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DFC_SWReset_2_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DFC_SWReset_2"
    VAL_BLK
    0x80804BB0
    ValA_Wu8
    18.0000000000
    DINH_LimDFCVerb
    0.00
    18.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_DSMInhibitAlways_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_DSMInhibitAlways"
    VAL_BLK
    0x80804BB2
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 3 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_ErrLmpActrMIL_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_ErrLmpActrMIL"
    VAL_BLK
    0x80804BB5
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_ErrLmpActrSVS_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_ErrLmpActrSVS"
    VAL_BLK
    0x80804BB7
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_StopLmp_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_StopLmp"
    VAL_BLK
    0x80804BB9
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_T15TurnOfDly_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_T15TurnOfDly"
    VAL_BLK
    0x80804BBB
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_Lim.DSQ_WrnLmp_CA
    "inhibit conditions / inhibit limit conditions for inhibit source DSQ_WrnLmp"
    VAL_BLK
    0x80804BBD
    ValA_Wu8
    16.0000000000
    DINH_LimDSQVerb
    0.00
    16.0000000000

    FORMAT "%13.10"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_tiUpdObsv_C
    "Paging interval time of FId observer"
    VALUE
    0x80805BF8
    Val_Wu16
    326.6000
    Time_s
    1.0000
    327.6000

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_xFIDObsv_C
    "Function identifier to scan by FId observer"
    VALUE
    0x80805BFA
    Val_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_Check_CA
    "Assigned fault checks for IUMPR calculation (variant 1)"
    VAL_BLK
    0x80802D6E
    ValA_Wu16
    1310.
    DFC_Verb
    0.00
    1310.

    FORMAT "%2.0"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.l500MDInc_C
    "criterias to count general denominator and ignition cycle counter / Number of increments of the internal odometer to reach a interval of 10 km"
    VALUE
    0x80802DBE
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.l500MD_C
    "criterias to count general denominator and ignition cycle counter / minimal driven distance to release special 500 miles denominator"
    VALUE
    0x80802DC0
    Val_Wu8
    1260.
    DIUMPR_l10km
    0.00
    1260.

    FORMAT "%5.0"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.pEnvMin_C
    "criterias to count general denominator and ignition cycle counter / maximum elevation (represented by minimum air pressure)"
    VALUE
    0x80802DCA
    Val_Ws16
    65535.00
    Pres_hPa
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.rAPPMax_C
    "criterias to count general denominator and ignition cycle counter / maximum accelerator pedal position for idle detection"
    VALUE
    0x80802DCC
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tEnvMin_C
    "criterias to count general denominator and ignition cycle counter / mimimum ambient temperatur"
    VALUE
    0x80802DD2
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiActrMin_C
    "criterias to count general denominator and ignition cycle counter / minimum activation time of a component to increment denominator"
    VALUE
    0x80802DD4
    Val_Wu8
    25.50
    DIUMPR_ti100ms
    0.00
    25.50

    FORMAT "%5.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiFuEngOpMin_C
    "criterias to count general denominator and ignition cycle counter / Minimal time for fueled engine firm(operation)"
    VALUE
    0x80802DDA
    Val_Wu16
    6553.500
    DIUMPR_ti100ms
    0.00
    6553.500

    FORMAT "%8.3"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiIdlMin_C
    "criterias to count general denominator and ignition cycle counter / minimum operation time in idle state"
    VALUE
    0x80802DDC
    Val_Wu16
    6553.500
    DIUMPR_ti100ms
    0.00
    6553.500

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiIgnMin_C
    "criterias to count general denominator and ignition cycle counter / minimum detection time for ignition cycle counter after engine start"
    VALUE
    0x80802DDE
    Val_Wu8
    25.50
    DIUMPR_ti100ms
    0.00
    25.50

    FORMAT "%5.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiOpMin_C
    "criterias to count general denominator and ignition cycle counter / minimum operation time"
    VALUE
    0x80802DE0
    Val_Wu16
    6553.500
    DIUMPR_ti100ms
    0.00
    6553.500

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiSigContActv_C
    "criterias to count general denominator and ignition cycle counter / minimum energising time twice required for a component to increment the denominator"
    VALUE
    0x80802DE2
    Val_Wu8
    3.000
    DIUMPR_ti100ms
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiSigContSnglActv_C
    "criterias to count general denominator and ignition cycle counter / minimum continuous energizing time required once for a component to increment the denominator"
    VALUE
    0x80802DE3
    Val_Wu8
    25.50
    DIUMPR_ti100ms
    0.00
    25.50

    FORMAT "%5.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiVehSpdMin_C
    "criterias to count general denominator and ignition cycle counter / minimum operation time about 25 miles per hour"
    VALUE
    0x80802DE4
    Val_Wu16
    6553.500
    DIUMPR_ti100ms
    0.00
    6553.500

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.vVehIdlMax_C
    "criterias to count general denominator and ignition cycle counter / maximim vehicle speed for idle detection"
    VALUE
    0x80802DE6
    Val_Ws16
    655.3500
    Vel
    -327.6800
    327.6700

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.vVehMin_C
    "criterias to count general denominator and ignition cycle counter / minimum vehicle speed"
    VALUE
    0x80802DE8
    Val_Ws16
    655.3500
    Vel
    -327.6800
    327.6700

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_ctGen.tiIgnCycMin_C
    "criterias to count general denominator and ignition cycle counter / Minimum TIme limit for increment of Ignition cycle counter"
    VALUE
    0x80802DEA
    Val_Wu8
    25.50
    DIUMPR_ti100ms
    0.00
    25.50

    FORMAT "%5.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_FID_CA
    "Assigned function identifier for IUMPR calculation (variant 1)"
    VAL_BLK
    0x80802DEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_Group_CA
    "Assigned component groups for IUMPR calculation (variant 1)"
    VAL_BLK
    0x80802E3C
    ValA_Wu8
    8.
    DIUMPR_J1979_GroupVerb
    0.00
    8.

    FORMAT "%2.0"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_numSigActv_CA
    "Assigned signal for IUMPR calculation to detect physical activity (variant 1)"
    VAL_BLK
    0x80802E64
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_stSigActv_CA
    "Assigned physical activation detection type for IUMPR calculation (variant 1)"
    VAL_BLK
    0x80802EB4
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_valSigActvMax_CA
    "Assigned upper limits of signal to detect physical activity (variant 1)"
    VAL_BLK
    0x80802EDC
    ValA_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DIUMPR_valSigActvMin_CA
    "Assigned lower limits of signal to detect physical activity (variant 1)"
    VAL_BLK
    0x80802F2C
    ValA_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    
    MATRIX_DIM 40 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DPSWATCHINDEX
    "Index of the observed output stage (in case of diagnosis problem)"
    VALUE
    0x80809052
    KwUb
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DrvPrgSwt_numCurrCAN_C
    "Calibration for Value of the driving program that is sent on the CAN"
    VALUE
    0x808091C2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DrvPrgSwt_stEffModReqd_C
    "calibration variable"
    VALUE
    0x808091C3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DrvPrgSwt_st_C
    "Calibration for State of the driving program"
    VALUE
    0x808091C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_BsPrio.FId_InhibitAlways_C
    "base priority / Base priority for scheduled FId FId_InhibitAlways"
    VALUE
    0x80804BC0
    Val_Wu16
    8191.000
    DFC_OneToOne
    0.00
    8191.000

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_DrvModeMsk.FId_InhibitAlways_C
    "drive mode mask / Drive Mode Mask for scheduled FId FId_InhibitAlways"
    VALUE
    0x80804BD2
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_FacPhys.FId_InhibitAlways_C
    "weighting physical priority / Factor for physical Prio for scheduled FId FId_InhibitAlways"
    VALUE
    0x80804BC2
    Val_Wu8
    255.0
    DFC_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_JmpActvPrio.FId_InhibitAlways_C
    "priotity bonus while active / Jump Active Prio for scheduled FId FId_InhibitAlways"
    VALUE
    0x80804BC4
    Val_Wu16
    8191.000
    DFC_OneToOne
    0.00
    8191.000

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_LimPrio.FId_InhibitAlways_C
    "upper priority limit / Upper priority limit if rate calculation is disabled for scheduled FId FId_InhibitAlways"
    VALUE
    0x80804BC6
    Val_Wu16
    8191.000
    DFC_OneToOne
    0.00
    8191.000

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_OpModeMsk.FId_InhibitAlways_C
    "operation mode mask / Operation Mode Mask for scheduled FId FId_InhibitAlways"
    VALUE
    0x80804BD4
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpIniPrio.FId_InhibitAlways_C
    "initial ramp priority / Ramp init Prio for scheduled FId FId_InhibitAlways"
    VALUE
    0x80804BC8
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpActv.FId_InhibitAlways_C
    "ramp slope active / Ramp Slope Active for scheduled FId FId_InhibitAlways"
    VALUE
    0x80804BCA
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpPas.FId_InhibitAlways_C
    "ramp slope passive / Ramp slope passive for scheduled FId FId_InhibitAlways"
    VALUE
    0x80804BCC
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpUpLim.FId_InhibitAlways_C
    "upper ramp limit / Ramp upper Limit for scheduled FId FId_InhibitAlways"
    VALUE
    0x80804BCE
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_stMode_C
    "Central disable switch for all scheduled FIDs (disabled if set to 0)"
    VALUE
    0x80804BD6
    Val_Wu8
    255.0
    DINH_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_valDflOpMode_C
    "Default request value for operation mode coordinator during disable state (DSCHED_stMode_C = 0)"
    VALUE
    0x80804BD8
    Val_Wu16
    65535.00
    DINH_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_valOfsPrioOpMode_C
    "Jump Priority Operation Mode (additional priority if operation mode is compatible to possible operation modes)"
    VALUE
    0x80804BD0
    Val_Wu16
    65535.00
    DINH_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_nEngLim2_C
    ""
    VALUE
    0x80809108
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_nEngLim_C
    ""
    VALUE
    0x8080910A
    Val_Ws16
    200.0000
    EngN
    100.0000
    300.0000

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_tiDelAftRun_C
    ""
    VALUE
    0x8080910C
    Val_Wu16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_tiDelBatt_C
    ""
    VALUE
    0x8080910E
    Val_Wu16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_tiDelBusOff_C
    ""
    VALUE
    0x80809110
    Val_Wu16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_tiDelECUInit_C
    ""
    VALUE
    0x80809112
    Val_Wu16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_tiDelEngStrt_C
    ""
    VALUE
    0x80809114
    Val_Wu16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAppl_uBatt_C
    ""
    VALUE
    0x80809116
    Val_Wu16
    36000.00
    Volt_Batt
    0.00
    36000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_dtWUCMin_C
    "minimum temperature raise for warm up cycle detection"
    VALUE
    0x80802F7C
    Val_Ws16
    6553.500
    TempDiff_Kelv
    -3276.800
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_nEngDCSMin_C
    ""
    VALUE
    0x80802F7E
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_tWUCMin_C
    "minimum temperature for warm up cycle detection"
    VALUE
    0x80802F80
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_vVehDCSMin_C
    ""
    VALUE
    0x80802F82
    Val_Ws16
    655.3500
    Vel
    -327.6800
    327.6700

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_xClearMode_C
    "clear mode for clear trigger"
    VALUE
    0x80802F84
    Val_Wu16
    1310.
    DFC_Verb
    0.00
    1310.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMAUX_xClearTrg_C
    "clear trigger to delete diagnostic information"
    VALUE
    0x80802F86
    Val_Wu8
    255.0
    DFC_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMDur_valEvntQntDist_C
    "increment quantization for travelled distance counter"
    VALUE
    0x80802F88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMDur_valEvntQntTi_C
    "increment quantization for operation time counter"
    VALUE
    0x80802F8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMDur_xEnaGlb_CA
    "Enable conditions for global duration counters"
    VAL_BLK
    0x80802F8C
    ValA_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMDur_xRstGlb_CA
    "Reset conditions for global duration counters"
    VAL_BLK
    0x80802F94
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMDur_xSelEvntGlb_CA
    "Counting event selection for global duration counters"
    VAL_BLK
    0x80802F98
    ValA_Wu8
    8.00000000000
    DSMDur_EvntSel_Verb
    0.00
    8.00000000000

    FORMAT "%13.11"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.Misf_CA
    "Fault checks for readiness calculation / Checks for group Misf"
    VAL_BLK
    0x80804BDA
    ValA_Wu16
    1310.
    DFC_Verb
    0.00
    1310.

    FORMAT "%2.0"
    
    MATRIX_DIM 50 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.FlSys_CA
    "Fault checks for readiness calculation / Checks for group FlSys"
    VAL_BLK
    0x80804C3E
    ValA_Wu16
    1310.
    DFC_Verb
    0.00
    1310.

    FORMAT "%2.0"
    
    MATRIX_DIM 50 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.ComprCmpnt_CA
    "Fault checks for readiness calculation / Checks for group ComprCmpnt"
    VAL_BLK
    0x80804CA2
    ValA_Wu16
    1310.
    DFC_Verb
    0.00
    1310.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.HCCat_CA
    "Fault checks for readiness calculation / Checks for group HCCat"
    VAL_BLK
    0x80804D6A
    ValA_Wu16
    1310.
    DFC_Verb
    0.00
    1310.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.NOxCat_CA
    "Fault checks for readiness calculation / Checks for group NOxCat"
    VAL_BLK
    0x80804E32
    ValA_Wu16
    1310.
    DFC_Verb
    0.00
    1310.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.BP_CA
    "Fault checks for readiness calculation / Checks for group BP"
    VAL_BLK
    0x80804EFC
    ValA_Wu16
    1310.
    DFC_Verb
    0.00
    1310.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.EGSens_CA
    "Fault checks for readiness calculation / Checks for group EGSens"
    VAL_BLK
    0x80804FC6
    ValA_Wu16
    1310.
    DFC_Verb
    0.00
    1310.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.PMFlt_CA
    "Fault checks for readiness calculation / Checks for group PMFlt"
    VAL_BLK
    0x8080508E
    ValA_Wu16
    1310.
    DFC_Verb
    0.00
    1310.

    FORMAT "%2.0"
    
    MATRIX_DIM 100 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_Grp.EGR_CA
    "Fault checks for readiness calculation / Checks for group EGR"
    VAL_BLK
    0x80805156
    ValA_Wu16
    1310.
    DFC_Verb
    0.00
    1310.

    FORMAT "%2.0"
    
    MATRIX_DIM 50 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_X.PID1ForceLowMsk_C
    "DSMRdy calibration masks / Enforced zero bits of PID$01 output"
    VALUE
    0x80802F9C
    Val_Wu32
    4294967295.00
    DSMRdy_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_X.PID1ForceHighMsk_C
    "DSMRdy calibration masks / Enforced one bits of PID$01 output"
    VALUE
    0x80802FA0
    Val_Wu32
    4294967295.00
    DSMRdy_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_X.PID41ForceLowMsk_C
    "DSMRdy calibration masks / Enforced zero bits of PID$41 output"
    VALUE
    0x80802FA4
    Val_Wu32
    4294967295.00
    DSMRdy_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_X.PID41ForceHighMsk_C
    "DSMRdy calibration masks / Enforced one bits of PID$41 output"
    VALUE
    0x80802FA8
    Val_Wu32
    4294967295.00
    DSMRdy_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DTR_OBDMID.DTR_Dummy_C
    ""
    VALUE
    0x80802FAC
    Val_Wu8
    255.0
    DFC_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DTR_Suprt.DTR_Dummy_C
    ""
    VALUE
    0x80802FAD
    Val_Wu8
    1.00000000000
    DTR_Suprt_Compu
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DTR_TID.DTR_Dummy_C
    ""
    VALUE
    0x80802FAE
    Val_Wu8
    255.0
    DFC_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Eep_ClrWrCounter_CW
    "Codeword to clear write counters"
    VALUE
    0x8080028E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Eep_EnFirstInit_CW
    "Codeword to start a first initialization in EEP"
    VALUE
    0x8080028D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Eep_EnvRamClr_CW
    "Codeword to clear contents of ENVRAM"
    VALUE
    0x8080028C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EngDem_stErr_C
    "calibration parameter for application variable"
    VALUE
    0x808091C5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EROTAN
    "Exhaust Regulation or Type Approval Number"
    VAL_BLK
    0x80809030
    ValA_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 17 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.LimitTypeMsk_C
    "Actuator test ErrLmpMIL_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x80809064
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.CnvNorm_C
    "Actuator test ErrLmpMIL_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x80809065
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.LowLim_C
    "Actuator test ErrLmpMIL_ATS / Lower limit for monitoring"
    VALUE
    0x80809066
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.UpLim_C
    "Actuator test ErrLmpMIL_ATS / Upper limit for monitoring"
    VALUE
    0x80809068
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.CnvFac_C
    "Actuator test ErrLmpMIL_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8080906C
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.CnvOfs_C
    "Actuator test ErrLmpMIL_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x80809070
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpMIL_ATS.DfltVal_C
    "Actuator test ErrLmpMIL_ATS / Default value for standbytest"
    VALUE
    0x80809072
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.LimitTypeMsk_C
    "Actuator test ErrLmpSVS_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x80809074
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.CnvNorm_C
    "Actuator test ErrLmpSVS_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x80809075
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.LowLim_C
    "Actuator test ErrLmpSVS_ATS / Lower limit for monitoring"
    VALUE
    0x80809076
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.UpLim_C
    "Actuator test ErrLmpSVS_ATS / Upper limit for monitoring"
    VALUE
    0x80809078
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.CnvFac_C
    "Actuator test ErrLmpSVS_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8080907C
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.CnvOfs_C
    "Actuator test ErrLmpSVS_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x80809080
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmpSVS_ATS.DfltVal_C
    "Actuator test ErrLmpSVS_ATS / Default value for standbytest"
    VALUE
    0x80809082
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.nThres_C
    "Parameter structure for MIL-test / Engine speed for switching off error lamp test"
    VALUE
    0x8080920C
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.tiMax_C
    "Parameter structure for MIL-test / Maximum duration for Error lamp test"
    VALUE
    0x8080920E
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.tiTst_C
    "Parameter structure for MIL-test / Maximum duration for error lamp test after engine speed limit was reached"
    VALUE
    0x80809210
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.tiDel_C
    "Parameter structure for MIL-test / Delay for MIL activation due to error, time for Power Stage tests during MIL off"
    VALUE
    0x80809212
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.tiBln_C
    "Parameter structure for MIL-test / Blink period for status MIL blinking"
    VALUE
    0x80809214
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.stEna_C
    "Parameter structure for MIL-test / Enable or disable illumination"
    VALUE
    0x80809216
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_MIL.tiFastBlink_C
    "Parameter structure for MIL-test / Lamp test parameters structure"
    VALUE
    0x80809218
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_Rdy.st_C
    "Structure for Error lamp Readiness / Status of the readiness functionality"
    VALUE
    0x8080921A
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_Rdy.ti_C
    "Structure for Error lamp Readiness / Maximum limit for the blinking phase during the readiness visualization via MIL"
    VALUE
    0x8080921C
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_Rdy.tiBlnOn_C
    "Structure for Error lamp Readiness / Blink on period during the blinking phase"
    VALUE
    0x8080921E
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_Rdy.tiBlnOff_C
    "Structure for Error lamp Readiness / Blink Off period during the blinking phase"
    VALUE
    0x80809220
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_stMIL_b6_C
    "calibration parameter for application variable"
    VALUE
    0x808091C6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_stPsMILDisbl_C
    "status word for activation of the power stage"
    VALUE
    0x80809222
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_stPsSVSDisbl_C
    "status word for activation of SVS Lamp"
    VALUE
    0x80809224
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.nThres_C
    "Parameter structure for SVS-test / Engine speed for switching off error lamp test"
    VALUE
    0x80809226
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.tiMax_C
    "Parameter structure for SVS-test / Maximum duration for Error lamp test"
    VALUE
    0x80809228
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.tiTst_C
    "Parameter structure for SVS-test / Maximum duration for error lamp test after engine speed limit was reached"
    VALUE
    0x8080922A
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.tiDel_C
    "Parameter structure for SVS-test / Delay for MIL activation due to error, time for Power Stage tests during MIL off"
    VALUE
    0x8080922C
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.tiBln_C
    "Parameter structure for SVS-test / Blink period for status MIL blinking"
    VALUE
    0x8080922E
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.stEna_C
    "Parameter structure for SVS-test / Enable or disable illumination"
    VALUE
    0x80809230
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_SVS.tiFastBlink_C
    "Parameter structure for SVS-test / Lamp test parameters structure"
    VALUE
    0x80809232
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ErrLmp_swtSVSEqGlwLmp_C
    "Switch for enabling glow lamp instead of SVS lamp"
    VALUE
    0x80809234
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Etc_MaxReqTO_C
    "Maximum time between 2 engine test requests. Value is applicated on 10ms time base (Value of 500 means 5s), but the smallest possible resolution is 100ms. Active tests will be stopped if this times has run out."
    VALUE
    0x8080913C
    Val_Wu16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FanCtl_stHotLmp_C
    "calibration variable"
    VALUE
    0x808091C7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FanCtl_stOk_C
    "Calibration for Status defect-free control of KMTR"
    VALUE
    0x808091C8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Fan_r1Ps_C
    ""
    VALUE
    0x808091CA
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Fan_r2Ps_C
    ""
    VALUE
    0x808091CC
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_volFlConsDspl_C
    "calibration parameter for application variable"
    VALUE
    0x808091D0
    Val_Ws32
    4294967295.00
    FlConsum_ul
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HESrv_swtScndFlwActv_C
    "Calibration parameter to switch off the second flow within a twin-flow system if this feature was enabled"
    VALUE
    0x8080928E
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HLSDem_nMaxDspl_C
    "Maximum engine speed limit for display (calibratable value)"
    VALUE
    0x808091D4
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HLSDem_nSetPLo_C
    "calibration variable"
    VALUE
    0x808091D6
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HLSDem_stNMaxWarnDspl_C
    "calibration variable"
    VALUE
    0x808091D8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_nMaxSrv4_C
    "Maximum engine speed for Mode$04 Clear Diagnostic Information"
    VALUE
    0x80809236
    Val_Ws16
    10000.00
    EngN
    0.00
    10000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID13_C
    "Location of oxigen sensor"
    VALUE
    0x80809248
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID1C_C
    "OBD requirements to which vehicle is designed"
    VALUE
    0x80809249
    Val_Wu8
    42.0000000000
    I15031_PID1CVerb
    1.0000000000
    43.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID1D_C
    "Location of oxygen sensors"
    VALUE
    0x8080924A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID4FA_C
    "External Test Equipment Configuration Information. Maximum value for Equivalence Ratio"
    VALUE
    0x8080924B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID4FB_C
    "External Test Equipment Configuration Information. Maximum value for Oxygen Sensor Voltage"
    VALUE
    0x8080924C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID4FC_C
    "External Test Equipment Configuration Information. Maximum value for Oxygen Sensor Current"
    VALUE
    0x8080924D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID4FD_C
    "External Test Equipment Configuration Information. Maximum value for Intake Manifold Absolute Pressure."
    VALUE
    0x8080924E
    Val_Wu8
    2550.
    OneToTenCarb
    0.00
    2550.

    FORMAT "%5.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID50A_C
    "External Test Equipment Configuration Information. Maximum value for ""Air Flow Rate from Mass Air Flow Sensor"""
    VALUE
    0x8080924F
    Val_Wu8
    2550.
    OneToTenCarb
    0.00
    2550.

    FORMAT "%5.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID5F_C
    "OBD requirements to which vehicle is designed"
    VALUE
    0x80809250
    Val_Wu8
    3.00000000000
    I15031_PID5FVerb
    14.0000000000
    17.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID65A_C
    "Shows which Auxiliary Inputs / Outputs are supported in PID65"
    VALUE
    0x80809251
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID66A_C
    "Shows which Mass Air Flow Sensor data are supported in PID66"
    VALUE
    0x80809252
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID67A_C
    "Shows which Engine Coolant Temperature data are supported in PID67"
    VALUE
    0x80809253
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID68A_C
    "Shows which Intake Air Temperature Sensor data are supported in PID68"
    VALUE
    0x80809254
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID69A_C
    "Shows which Commanded EGR System data are supported in PID69"
    VALUE
    0x80809255
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6AA_C
    "Shows which Commanded Diesel Intake Air Flow Control and Relative Intake Air Flow Position data are supported in PID6A"
    VALUE
    0x80809256
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6BA_C
    "Shows which Exhaust Gas Recirculation Temperature data are supported in PID6B"
    VALUE
    0x80809257
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6CA_C
    "Shows which Commanded Throttle Actuator Control and Relative Throttle Position data are supported in PID6C"
    VALUE
    0x80809258
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6DA_C
    "Shows which Fuel Pressure Control System data are supported in PID6D"
    VALUE
    0x80809259
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6EA_C
    "Shows which Injection Pressure Control System data are supported in PID6E"
    VALUE
    0x8080925A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID6FA_C
    "Shows which Turbocharger Compressor Inlet Pressure data are supported in PID6F"
    VALUE
    0x8080925B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID70A_C
    "Shows which Boost Pressure Control data are supported in PID70"
    VALUE
    0x8080925C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID71A_C
    "Shows which Variable Geometry Turbo (VGT) Control data are supported in PID71"
    VALUE
    0x8080925D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID72A_C
    "Shows which Wastegate Control data are supported in PID72"
    VALUE
    0x8080925E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID73A_C
    "Shows which Exhaust Pressure data are supported in PID73"
    VALUE
    0x8080925F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID74A_C
    "Shows which Turbocharger RPM data are supported in PID74"
    VALUE
    0x80809260
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID75A_C
    "Shows which Turbocharger A Temperature data are supported in PID75"
    VALUE
    0x80809261
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID76A_C
    "Shows which Turbocharger B Temperature data are supported in PID76"
    VALUE
    0x80809262
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID77A_C
    "Shows which Charge Air Cooler Temperature (CACT) data are supported in PID77"
    VALUE
    0x80809263
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID78A_C
    "Shows which Exhaust Gas Temperature (EGT) Bank 1 data are supported in PID78"
    VALUE
    0x80809264
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID79A_C
    "Shows which Exhaust Gas Temperature (EGT) Bank 2 data are supported in PID79"
    VALUE
    0x80809265
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID7AA_C
    "Shows which Particulate Filter (PF) Bank 1 data are supported in PID7A"
    VALUE
    0x80809266
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID7BA_C
    "Shows which Particulate Filter (PF) Bank 2 data are supported in PID7B"
    VALUE
    0x80809267
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID7CA_C
    "Shows which Particulate Filter (PF) Temperature data are supported in PID7C"
    VALUE
    0x80809268
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID7FA_C
    "Shows which Engine Run Time is supported in PID7F"
    VALUE
    0x80809269
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID81A_C
    "Shows which Engine Run Time for AECD #1 - #5 is supported in PID81"
    VALUE
    0x8080926A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID82A_C
    "Shows which Engine Run Time for AECD #6 - #10 is supported in PID82"
    VALUE
    0x8080926B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID83A_C
    "Shows which NOx Sensor data are supported in PID83"
    VALUE
    0x8080926C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID85A_C
    "Shows which NOx Control System data are supported in PID85"
    VALUE
    0x8080926D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID86A_C
    "Shows which Particulate Matter (PM) Sensor data are supported in PID86"
    VALUE
    0x8080926E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID87A_C
    "Shows which Intake Manifold Absolute Pressure data are supported in PID87"
    VALUE
    0x8080926F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID89A_C
    "Shows which Engine Run Time for AECD #11 - #15 is supported in PID89"
    VALUE
    0x80809270
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID8AA_C
    "Shows which Engine Run Time for AECD #16 - #20 is supported in PID8A"
    VALUE
    0x80809271
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID8BA_C
    "Shows which Aftertreatment Status is supported in PID8B ByteB."
    VALUE
    0x80809272
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID8CA_C
    "Calibration for O2 Sensor Data support information(Sensor 1, Sensor 2)"
    VALUE
    0x80809273
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID8FA_C
    "Shows which PM (Particulate Matter) Sensor Output is supported in PID8F"
    VALUE
    0x80809274
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID92A_C
    "Calibration for Fuel System Status support information"
    VALUE
    0x80809275
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID93A_C
    "Calibration for WWH B1 counter support information"
    VALUE
    0x80809276
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID94A_C
    "Calibration for Inducement Counters support information"
    VALUE
    0x80809277
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID97A_C
    ""
    VALUE
    0x80809278
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID98A_C
    "Shows which exhaust gas temperature for bank 1 data are supported in PID98"
    VALUE
    0x80809279
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID99A_C
    "Calibration for Exhaust Gas Temperature Sensor Data support information"
    VALUE
    0x8080927A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID9AA_C
    "Shows if HybridEV Vehicle State is supported in PID9A"
    VALUE
    0x8080927B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID9BA_C
    "Diesel exhaust fluid sensor output"
    VALUE
    0x8080927C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID9CA_C
    "Calibration for O2 Sensor Data support information(Sensor 3, Sensor 4)"
    VALUE
    0x8080927D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PID9FA_C
    "Support of fuel system percentage use"
    VALUE
    0x8080927E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA1A_C
    "Displays the NOx Sensor Corrected Data supported in PIDA1"
    VALUE
    0x8080927F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA3A_C
    "Evap System Vapor Pressure"
    VALUE
    0x80809280
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA4A_C
    "Transmission Actual Gear"
    VALUE
    0x80809281
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA5A_C
    "calibration parameter to update message of byte A ini PIDA5 for Diesel Exhaust Fluid Dosing"
    VALUE
    0x80809282
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA7A_C
    "Support of NOx Sensor Data"
    VALUE
    0x80809283
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA8A_C
    "NOx Sensor Corrected"
    VALUE
    0x80809284
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDA9A_C
    "Motorcycle InputOutput Status"
    VALUE
    0x80809285
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_PIDACA_C
    ""
    VALUE
    0x80809286
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PID0_C
    ""
    VALUE
    0x80809238
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PID2_C
    ""
    VALUE
    0x8080923A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PID4_C
    ""
    VALUE
    0x8080923C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PID6_C
    ""
    VALUE
    0x8080923E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PID8_C
    ""
    VALUE
    0x80809240
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PIDA_C
    ""
    VALUE
    0x80809242
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PIDB_C
    ""
    VALUE
    0x80809243
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9PIDTable.PIDF_C
    ""
    VALUE
    0x80809247
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_srv9_VT_SupprRecent_C
    ""
    VALUE
    0x80809288
    Val_Wu8
    1.00000000000
    I15031_srv9_VT_SupprRecent_CalVerb
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    I15031_stRfrshCal_C
    "Start of support calculation for Service0102"
    VALUE
    0x80809287
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LLim_stMaxActvLvlECU_C
    "Calibration for demand from Lvl ECU for speed limiting"
    VALUE
    0x808091D9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    medc_datasetid
    "Text with the dataset identification"
    ASCII
    0x808090A4
    ValA_Wu8
    255.0
    defaultAscii
    0.00
    255.0
    NUMBER 99
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCCPU_stLockStepTstActv_CW
    ""
    VALUE
    0x808095B0
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGTM_cntrCMPErrbitHealMax_C
    ""
    VALUE
    0x80809510
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGTM_cntrDebErrMax_C
    ""
    VALUE
    0x80809511
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGTM_stChksTstActv_CW
    ""
    VALUE
    0x808095B2
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGTM_stSWResetDem_CW
    ""
    VALUE
    0x80809516
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCGTM_stTestActv_CW
    ""
    VALUE
    0x808095B3
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCHwLogicTest_stTestActv_CW
    ""
    VALUE
    0x808095B4
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCHwLogicTest_swtDisblErrReactn_CW
    ""
    VALUE
    0x80809518
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCHwLogicTest_swtDisblFwChk_CA
    ""
    VAL_BLK
    0x8080954C
    ValA_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    
    MATRIX_DIM 5 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCIWDH_stPtlRespTstActv_CW
    ""
    VALUE
    0x808095B5
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMemStrtUp_chkRamTest_C
    ""
    VALUE
    0x808095B6
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMemStrtUp_chkRomTest_C
    ""
    VALUE
    0x808095B7
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebErrChkRAM_C
    ""
    VALUE
    0x8080951A
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebErrChkROM_C
    ""
    VALUE
    0x8080951B
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkRAMCpl_C
    ""
    VALUE
    0x808095B8
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkRAM_C
    ""
    VALUE
    0x8080951C
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkROMCpl_C
    ""
    VALUE
    0x808095B9
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_ctDebHealChkROM_C
    ""
    VALUE
    0x8080951D
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_noMEMChkRstCpl_CW
    ""
    VALUE
    0x808095BA
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_noMEMChkRst_CW
    ""
    VALUE
    0x8080951E
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_numRamChk_C
    ""
    VALUE
    0x80809590
    Val_Wu16
    65535.00
    dez
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_numRomChk_CA
    ""
    VAL_BLK
    0x80809592
    ValA_Wu16
    65535.00
    dez
    0.00
    65535.00

    FORMAT "%8.2"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_RamTst_CW
    ""
    VALUE
    0x808095BB
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_RomTst_CW
    ""
    VALUE
    0x808095BC
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_stSwtAutRamChkConf_C
    ""
    VALUE
    0x8080951F
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCMem_stSwtAutRomChkConf_C
    ""
    VALUE
    0x80809520
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCPFC_stPtlRespTestActv_CW
    ""
    VALUE
    0x808095BE
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSCC_cntrDebMax_C
    ""
    VALUE
    0x80809522
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSCC_stSCCTstActv_CW
    ""
    VALUE
    0x808095C6
    Val_Wu16
    65535.00
    dez
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSCC_swtDisblEmmChk_CA
    ""
    VAL_BLK
    0x80809560
    ValA_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    
    MATRIX_DIM 12 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSCC_swtLfastWrkarndActv_CW
    ""
    VALUE
    0x80809523
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_cntrDebCtrlLinesActvThd_C
    ""
    VALUE
    0x808095C0
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_ctDebSOPTst_C
    "max. no. responses to the UM for rectification of vehicle in shutdown-path test"
    VALUE
    0x8080959A
    Val_Wu16
    65535.00
    dez
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_ctDebSycDrv_C
    ""
    VALUE
    0x80809524
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_ctRst_C
    ""
    VALUE
    0x80809525
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_nEngMaxOVLthDisbl_C
    ""
    VALUE
    0x8080959C
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stCANErrReac_CW
    "codeword for activating the error reaction CAN-driver-disabling"
    VALUE
    0x80809526
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stCtrlLineErrReactn_C
    ""
    VALUE
    0x80809527
    Val_Wu8
    1.00000000000
    MoCSOP_stCtrlLineErrReactn_C_Compu
    1.00000000000
    2.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stErrReactn_CA
    ""
    VAL_BLK
    0x80809528
    ValA_Wu8
    2.00000000000
    MoCSOP_stErrReactn_CA_Compu
    0.00
    2.00000000000

    FORMAT "%13.11"
    
    MATRIX_DIM 16 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stMMErrReac_CW
    "code word for activating the fault reaction MM reset"
    VALUE
    0x80809538
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stOVErrReactn_C
    ""
    VALUE
    0x80809539
    Val_Wu8
    1.00000000000
    MoCSOP_stOVErrReactn_C_Compu
    1.00000000000
    2.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stSWResetDem_CW
    ""
    VALUE
    0x8080953A
    Val_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_stTestActv_CW
    ""
    VALUE
    0x808095C1
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoCSOP_swtAlwysPsTest_C
    ""
    VALUE
    0x8080953B
    Val_Wu8
    1.000
    dez
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrActvPostBldCfg_C
    ""
    VALUE
    0x8080953C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrNegChkPostBldCfg_C
    ""
    VALUE
    0x8080953D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrPosChkPostBldCfg_C
    ""
    VALUE
    0x8080953E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrRstPostBldSel_C
    ""
    VALUE
    0x8080953F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrStabyChkPostBldCfg_C
    ""
    VALUE
    0x80809540
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_cntrTestPostBldSel_C
    ""
    VALUE
    0x808095C2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoFTrqPtd_stSwtPbsChk_C
    ""
    VALUE
    0x80809541
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctErrReIniAllowd_C
    ""
    VALUE
    0x80809542
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctReIniAllowd_C
    ""
    VALUE
    0x80809543
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctReIniTstDeb_C
    ""
    VALUE
    0x808095C3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctT15RsngEdgDetnAllwd_C
    ""
    VALUE
    0x80809544
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctT15RsngEdgDetnPlausy_C
    ""
    VALUE
    0x80809545
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_ctT15RsngEdgTurnOff_C
    ""
    VALUE
    0x80809546
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoSysCtrl_stSwtT15PlausEna_C
    ""
    VALUE
    0x80809547
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoXEMM_nrHwLTErrSimn_C
    ""
    VALUE
    0x80809042
    RB_Val_Wu16
    65535.0000000
    MoXEMM_HwLTErrorSimnCode_VERB
    0.00
    65535.0000000

    FORMAT "%13.7"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MoXEMM_nrSmuAlmErrSimn_C
    ""
    VALUE
    0x80809044
    RB_Val_Wu16
    65535.0000000
    MoXEMM_SMUErrorSimnCode_VERB
    0.00
    65535.0000000

    FORMAT "%13.7"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Mo_cwMstSlave_C
    ""
    VALUE
    0x80809548
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Mo_stSwtHyb_C
    ""
    VALUE
    0x80809549
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Mo_swtClrCntrMax_C
    ""
    VALUE
    0x808095C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Mo_swtCyclCalUpdt_C
    ""
    VALUE
    0x8080954A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Mo_trqIdcMax_C
    ""
    VALUE
    0x8080959E
    Val_Ws16
    3276.600
    md_q0p1
    0.100
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    NDECJ
    "Engine speed threshold for power stage diagnosis"
    VALUE
    0x8080904C
    KwWU8
    10200.
    EngN_LRes
    0.00
    10200.

    FORMAT "%5.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    NEngInd_nOpt_C
    "calibration parameter for application variable"
    VALUE
    0x808091DA
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    NMHigh_xSNI_C
    ""
    VALUE
    0x808091DC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    OCWDA_ctDebActvErr_C
    ""
    VALUE
    0x80809046
    RB_Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    OCWDA_stErrSimn_C
    ""
    VALUE
    0x80809047
    RB_Val_Wu8
    8.00000000000
    OCWDA_stErrSimn_C_compu_VERB
    0.00
    8.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    OCWDA_swtOffRst_C
    ""
    VALUE
    0x80809048
    RB_Val_Wu8
    1.00000000000
    OCWDA_swtOffRst_C_compu_VERB
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Oil_bPresWarn_C
    "calibration parameter for application variable"
    VALUE
    0x808091DD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PCR_pDesVal_C
    "desired boost pressure"
    VALUE
    0x80809290
    Val_Ws16
    65535.00
    Pres_hPa
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PFltRgn_stTxtMsg_C
    "calibration variable"
    VALUE
    0x808091DE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PhyMod_moiEng_C
    "moment of inertia"
    VALUE
    0x808091E0
    Val_Ws16
    655.3500
    Moment_Inertia
    -327.6800
    327.6700

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PhyMod_trqDynEng_C
    "calibration variable"
    VALUE
    0x808091E2
    Val_Ws16
    6553.500
    Trq
    -3276.800
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    PspCtl_stFlPmpAct_C
    "Calibration for Information auxiliar heater was on"
    VALUE
    0x808091E4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_DisableProcExec_KWB
    ""
    VAL_BLK
    0xB93E005C
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 5 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_ResIdSrvPt_KWB
    ""
    VAL_BLK
    0xB93E0040
    ValA_Wu16
    4.00000000000
    rba_SvbbEtk_SpName
    0.00
    4.00000000000

    FORMAT "%13.11"
    
    MATRIX_DIM 4 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_SrvPtEnabled_KWB
    ""
    VAL_BLK
    0xB93E0058
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_SrvPtResId_KWB
    ""
    VAL_BLK
    0xB93E0061
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 5 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_TimeOutPost_KWB
    ""
    VAL_BLK
    0xB93E0050
    ValA_Wu16
    500.0000
    rba_Svbb_Time_us
    0.00
    500.0000

    FORMAT "%8.4"
    
    MATRIX_DIM 4 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    rba_SvbbEtk_TimeOutPre_KWB
    ""
    VAL_BLK
    0xB93E0048
    ValA_Wu16
    500.0000
    rba_Svbb_Time_us
    0.00
    500.0000

    FORMAT "%8.4"
    
    MATRIX_DIM 4 
    MAX_REFRESH 3 200

/end CHARACTERISTIC

/begin CHARACTERISTIC

    RBR_HW_INH_MV_C
    ""
    VALUE
    0x8080904A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SCRCtl_stAcoustic_C
    "Calibration to SCR acoustic warning information"
    VALUE
    0x808091E5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SCRCtl_stDsplStgy_C
    "Applicationlabel for the calibration of the display strategy"
    VALUE
    0x808091E6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SCRCtl_stWarnText_C
    "Calibration to state of SCR warning text"
    VALUE
    0x808091E7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Signals_Mode1Pid_CA
    "Array welches alle konfigurierten PID Nummer für Signals beinhaltet (read-only für GS)."
    VAL_BLK
    0x8080929C
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 207 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Signals_Mode1SigNum_CA
    "Array welches die zu Signals_Mode1Pid_CA gehörenden Signalnummern beinhaltet (read-only für GS)."
    VAL_BLK
    0x8080936C
    ValA_Wu16
    112.000000000
    Signals_IntSigNumVerb
    0.00
    112.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 207 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SLmpCtl_rOilLvl_C
    "calibration parameter for application variable"
    VALUE
    0x808091E8
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SLmpCtl_stOil_C
    "calibration parameter for application variable"
    VALUE
    0x808091EA
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SLmpCtl_volOil_C
    "calibration variable"
    VALUE
    0x808091EC
    Val_Ws16
    65535.00
    volFilgLvl_ml
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSEUI_stDemNoStopCanMeas_C
    "Calibration to test CAN signal MO_Stoppverbot_Anz"
    VALUE
    0x808091EE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SSEUI_stStrtDesCanMeas_C
    "Calibration to test Status of StartStop-start request for CAN version MQB"
    VALUE
    0x808091EF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.LimitTypeMsk_C
    "Actuator test StopLmp_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x80809084
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.CnvNorm_C
    "Actuator test StopLmp_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x80809085
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.LowLim_C
    "Actuator test StopLmp_ATS / Lower limit for monitoring"
    VALUE
    0x80809086
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.UpLim_C
    "Actuator test StopLmp_ATS / Upper limit for monitoring"
    VALUE
    0x80809088
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.CnvFac_C
    "Actuator test StopLmp_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8080908C
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.CnvOfs_C
    "Actuator test StopLmp_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x80809090
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_ATS.DfltVal_C
    "Actuator test StopLmp_ATS / Default value for standbytest"
    VALUE
    0x80809092
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_nThres_C
    ""
    VALUE
    0x80808F7C
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_stEna_C
    ""
    VALUE
    0x80808F7E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_stPsDisbl_C
    ""
    VALUE
    0x80808F80
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_tiBln_C
    ""
    VALUE
    0x80808F82
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_tiDel_C
    ""
    VALUE
    0x80808F84
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_tiMax_C
    ""
    VALUE
    0x80808F86
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StopLmp_tiTst_C
    ""
    VALUE
    0x80808F88
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StrtCtl_stStrtStopDspl_C
    "Calibration for StrtCtl_stStrtStopDspl"
    VALUE
    0x808091F0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StrtCtl_stT75_C
    "SwsVW"
    VALUE
    0x808091F1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Strt_st_C
    "Calibration to test the Control signal for the starter relay(Strt_st)"
    VALUE
    0x808091F2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StSys_stStrtDisengaFrm_C
    "calibration variable"
    VALUE
    0x808091F3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    StSys_stStrtRlsFrm_C
    "calibration variable"
    VALUE
    0x808091F4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SWaPmp_tiHtgPmp_C
    "calibration parameter for application variable"
    VALUE
    0x808091F6
    Val_Ws16
    65535.00
    TimeEngOn
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_bBrkStopReqSupp_C
    "calibration parameter for application variable"
    VALUE
    0x808091F8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_bRstrtActv_C
    "calibration variable"
    VALUE
    0x808091F9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_bStopActv_C
    "calibration variable"
    VALUE
    0x808091FA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_bStopReqEnaIdc_C
    "calibration parameter for application variable"
    VALUE
    0x808091FB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_bVlvGbxClgPrs_C
    "calibration variable"
    VALUE
    0x808091FC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_bVlvGbxClg_C
    "Calibration for bit valve gearbox cooling open"
    VALUE
    0x808091FD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_noSetDrvModStrtStopSwt_C
    "Calibration to test SW sharing interface for StartStop switch charisma driveprogram reply"
    VALUE
    0x808091FE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_numGearActDspl_C
    "Calibration for actual gear from shiftup-information"
    VALUE
    0x808091FF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_numGearDesDspl_C
    "Calibration for desired gear from shiftup-information"
    VALUE
    0x80809200
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_stLmpOutStrtStopSwt_C
    "Calibration to test SW sharing interface for desired StartStop switch lamp status"
    VALUE
    0x80809201
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_stStopInhIdcCordStrtStop_C
    "Calibration for binary output of stop inhibition reasons from startstop coordinator for external display"
    VALUE
    0x80809202
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_stStrtReqIdcCordStrtStop_C
    "Calibration for binary output of start request reasons from startstop coordinator for external display"
    VALUE
    0x80809204
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwSVW_stStrtStopCharStrtStopSwt_C
    "Calibration to test SW sharing interface for StartStop charisma status"
    VALUE
    0x80809205
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_stStrtStopDrv_C
    "Calibration for Driver stop request for CAN"
    VALUE
    0x80809206
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_stStrtStopSys_C
    "Calibration for system status for startstop"
    VALUE
    0x80809207
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_stVlvHeat_C
    "Calibration for status of valve heating-closing"
    VALUE
    0x80809208
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    SwsVW_stWtPmpEng_C
    "calibration parameter for application variable"
    VALUE
    0x80809209
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    test_bypass_rbaBypDrv_u16_C
    ""
    VALUE
    0x80809292
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    test_bypass_rbaBypDrv_u32_C
    ""
    VALUE
    0x80809294
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    test_bypass_rbaBypDrv_u8_C
    ""
    VALUE
    0x80809298
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    THP
    "delay time failure heiling powerstage diagnosis"
    VALUE
    0x80809053
    KwUb
    25.00
    t_q0p1
    0.50
    25.50

    FORMAT "%5.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    TVP
    "delay time failure verification powerstage diagnosis ME(D) 9"
    VALUE
    0x80809054
    KwUb
    25.00
    t_q0p1
    0.50
    25.50

    FORMAT "%5.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    UBCJMN
    "Min. Ubat-threshold for release of the power stage diagnosis"
    VALUE
    0x8080904E
    KwWU16
    15000.00
    Volt_Batt
    0.00
    15000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    UBCJMX
    "Max. Ubat-threshold f. release of the BSP 752 R-power stage diagnosis"
    VALUE
    0x80809050
    KwWU16
    25500.00
    Volt_Batt
    0.00
    25500.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WaPmp_stInfoSysExt_C
    "calibration variable"
    VALUE
    0x8080920A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.LimitTypeMsk_C
    "Actuator test WrnLmp_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x80809094
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.CnvNorm_C
    "Actuator test WrnLmp_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x80809095
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.LowLim_C
    "Actuator test WrnLmp_ATS / Lower limit for monitoring"
    VALUE
    0x80809096
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.UpLim_C
    "Actuator test WrnLmp_ATS / Upper limit for monitoring"
    VALUE
    0x80809098
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.CnvFac_C
    "Actuator test WrnLmp_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8080909C
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.CnvOfs_C
    "Actuator test WrnLmp_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x808090A0
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_ATS.DfltVal_C
    "Actuator test WrnLmp_ATS / Default value for standbytest"
    VALUE
    0x808090A2
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_nThres_C
    ""
    VALUE
    0x80808F8A
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_stEna_C
    ""
    VALUE
    0x80808F8C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_stPsDisbl_C
    ""
    VALUE
    0x80808F8E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_tiBln_C
    ""
    VALUE
    0x80808F90
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_tiDel_C
    ""
    VALUE
    0x80808F92
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_tiMax_C
    ""
    VALUE
    0x80808F94
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    WrnLmp_tiTst_C
    ""
    VALUE
    0x80808F96
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC



/***********   Start of merged MEASUREMENT blocks    ***********/


/begin MEASUREMENT

    CanIf_Prv_ControllerState_ast[0].Ctrl_Pdu_mode
    "Can Interface controller State[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60010654


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_ControllerState_ast[1].Ctrl_Pdu_mode
    "Can Interface controller State[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60010658


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_ControllerState_ast[2].Ctrl_Pdu_mode
    "Can Interface controller State[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001065C


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_ControllerState_ast[3].Ctrl_Pdu_mode
    "Can Interface controller State[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60010660


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_InitStatus_b
    "Flag to check if CANIF is Initialized(TRUE) or Not Initialized (FALSE)"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    1.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60010664


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[0].last_index
    "Can Interface Buffer Status[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EFC


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[1].last_index
    "Can Interface Buffer Status[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EFE


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[2].last_index
    "Can Interface Buffer Status[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F00


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[3].last_index
    "Can Interface Buffer Status[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F02


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[4].last_index
    "Can Interface Buffer Status[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F04


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[5].last_index
    "Can Interface Buffer Status[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F06


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[6].last_index
    "Can Interface Buffer Status[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F08


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[7].last_index
    "Can Interface Buffer Status[7]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F0A


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[8].last_index
    "Can Interface Buffer Status[8]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F0C


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[9].last_index
    "Can Interface Buffer Status[9]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F0E


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[10].last_index
    "Can Interface Buffer Status[10]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F10


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[11].last_index
    "Can Interface Buffer Status[11]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F12


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[12].last_index
    "Can Interface Buffer Status[12]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F14


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[0].bufferstatus
    "Can Interface Buffer Status[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EFD


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[1].bufferstatus
    "Can Interface Buffer Status[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011EFF


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[2].bufferstatus
    "Can Interface Buffer Status[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F01


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[3].bufferstatus
    "Can Interface Buffer Status[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F03


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[4].bufferstatus
    "Can Interface Buffer Status[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F05


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[5].bufferstatus
    "Can Interface Buffer Status[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F07


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[6].bufferstatus
    "Can Interface Buffer Status[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F09


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[7].bufferstatus
    "Can Interface Buffer Status[7]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F0B


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[8].bufferstatus
    "Can Interface Buffer Status[8]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F0D


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[9].bufferstatus
    "Can Interface Buffer Status[9]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F0F


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[10].bufferstatus
    "Can Interface Buffer Status[10]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F11


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[11].bufferstatus
    "Can Interface Buffer Status[11]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F13


/end MEASUREMENT




/begin MEASUREMENT

    CanIf_Prv_TxBufferRam_ast[12].bufferstatus
    "Can Interface Buffer Status[12]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F15


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_BORMode_au8
    "Variable to SET/RESET the BOR mode"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D14B
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_BusOffISRPend_ab
    "To Set the BOR ISR Pending Request to True or False"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FBC
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_BusOff_Cntr_au8
    "Bus-Off counter for CanSM"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D14F
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_CurrNw_Mode_en
    "current ComM mode"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_NetworkModeStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FD0
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_MutexMode_au8
    "Used to set"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000D147
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_Network_Init_ab
    "Setting this leads to initialisation of the network"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011F90
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_ReqComM_Mode_en
    "stores the requested communication mode"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FC4
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[0].cntTick_u16
    "CanSM timer configuration[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FD8


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[1].cntTick_u16
    "CanSM timer configuration[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FDC


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[2].cntTick_u16
    "CanSM timer configuration[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FE0


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[3].cntTick_u16
    "CanSM timer configuration[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FE4


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[0].stTimer
    "CanSM timer configuration[0]/"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_TimerStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FD6


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[1].stTimer
    "CanSM timer configuration[1]/"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_TimerStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FDA


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[2].stTimer
    "CanSM timer configuration[2]/"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_TimerStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FDE


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_TimerConfig_ast[3].stTimer
    "CanSM timer configuration[3]/"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_TimerStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FE2


/end MEASUREMENT




/begin MEASUREMENT

    CanSM_currBOR_State_en
    "Current Bus-Off recovery state for CanSM"
    UBYTE
    AUTOSAR_CanSM_CompuMethods_CanSM_BusOffRecoveryStateType_Enum_comp
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60011FCC
    MATRIX_DIM 4 


/end MEASUREMENT




/begin MEASUREMENT

    CanTp_MainState
    "MainState of CanTp indicating whether Tp Communication on CanStack is possible."
    UBYTE
    DefaultIdenticalCompu
    1
    100
    0.0
    255.
    FORMAT "%5.1"
    ECU_ADDRESS 0x6000D153


/end MEASUREMENT




/begin MEASUREMENT

    Com_SigType_u16
    "Measurement variable for Signals of type - uint16,sint16. To refer Individual element in the Buffer array, Fetch Buffer Index from Com_PBcfg.c for each signal."
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000B64A
    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    Com_SigType_u8
    "Measurement variable for Signals of type - uint8,sint8,boolean,uint8_n. To refer Individual element in the Buffer array, Fetch Buffer Index from Com_PBcfg.c for each signal."
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CAEB
    MATRIX_DIM 2 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dComIPdu_CCVS_xTxByte
    "Tx Ipdu buffer of IPdu -ComIPdu_CCVS_xTx- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CB0E
    MATRIX_DIM 3 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dComIPdu_C_xRxByte
    "Rx Local Ipdu buffer of IPdu -ComIPdu_C_xRx- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CAF7
    MATRIX_DIM 8 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dComIPdu_C_xTxByte
    "Tx Ipdu buffer of IPdu -ComIPdu_C_xTx- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CB06
    MATRIX_DIM 8 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dComIPdu_EngCtrl1_xRxByte
    "Rx Local Ipdu buffer of IPdu -ComIPdu_EngCtrl1_xRx- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CAF2
    MATRIX_DIM 5 


/end MEASUREMENT




/begin MEASUREMENT

    Com_dNM_TX_FAByte
    "Tx Ipdu buffer of IPdu -NM_TX_FA- as a Measurement parameter"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6000CAFF
    MATRIX_DIM 7 


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].ChannelState_e
    "ComM Channel structure[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012044


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].ChannelState_e
    "ComM Channel structure[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012064


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].ChannelState_e
    "ComM Channel structure[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012084


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].ChannelState_e
    "ComM Channel structure[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120A4


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].ChannelState_e
    "ComM Channel structure[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120C4


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].ChannelState_e
    "ComM Channel structure[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120E4


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].LightTimeoutCtr_u32
    "ComM Channel structure[0]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012048


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].LightTimeoutCtr_u32
    "ComM Channel structure[1]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012068


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].LightTimeoutCtr_u32
    "ComM Channel structure[2]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012088


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].LightTimeoutCtr_u32
    "ComM Channel structure[3]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120A8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].LightTimeoutCtr_u32
    "ComM Channel structure[4]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120C8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].LightTimeoutCtr_u32
    "ComM Channel structure[5]/"
    ULONG
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    4.294967295E9
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120E8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].MinFullComTimeoutCtr_u16
    "ComM Channel structure[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001204C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].MinFullComTimeoutCtr_u16
    "ComM Channel structure[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001206C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].MinFullComTimeoutCtr_u16
    "ComM Channel structure[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001208C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].MinFullComTimeoutCtr_u16
    "ComM Channel structure[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120AC


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].MinFullComTimeoutCtr_u16
    "ComM Channel structure[4]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120CC


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].MinFullComTimeoutCtr_u16
    "ComM Channel structure[5]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120EC


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].UserRequestCtr_u16
    "ComM Channel structure[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001204E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].UserRequestCtr_u16
    "ComM Channel structure[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001206E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].UserRequestCtr_u16
    "ComM Channel structure[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001208E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].UserRequestCtr_u16
    "ComM Channel structure[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120AE


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].UserRequestCtr_u16
    "ComM Channel structure[4]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120CE


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].UserRequestCtr_u16
    "ComM Channel structure[5]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120EE


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].ChannelMode_u8
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012050


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].ChannelMode_u8
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012070


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].ChannelMode_u8
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012090


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].ChannelMode_u8
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B0


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].ChannelMode_u8
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D0


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].ChannelMode_u8
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120F0


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].BusSmMode_u8
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012051


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].BusSmMode_u8
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012071


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].BusSmMode_u8
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012091


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].BusSmMode_u8
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B1


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].BusSmMode_u8
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D1


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].BusSmMode_u8
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120F1


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].PassiveRequestState_u8
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012052


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].PassiveRequestState_u8
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012072


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].PassiveRequestState_u8
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012092


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].PassiveRequestState_u8
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B2


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].PassiveRequestState_u8
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D2


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].PassiveRequestState_u8
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120F2


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].PncRequestCtr_u8
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012053


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].PncRequestCtr_u8
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012073


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].PncRequestCtr_u8
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012093


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].PncRequestCtr_u8
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B3


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].PncRequestCtr_u8
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D3


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].PncRequestCtr_u8
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120F3


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].InhibitionReqStatus_u8
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012054


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].InhibitionReqStatus_u8
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012074


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].InhibitionReqStatus_u8
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012094


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].InhibitionReqStatus_u8
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B4


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].InhibitionReqStatus_u8
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D4


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].InhibitionReqStatus_u8
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120F4


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].NmNetworkRequestStatus_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012055


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].NmNetworkRequestStatus_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012075


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].NmNetworkRequestStatus_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012095


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].NmNetworkRequestStatus_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B5


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].NmNetworkRequestStatus_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D5


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].NmNetworkRequestStatus_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120F5


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].DiagnosticRequestState_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012056


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].DiagnosticRequestState_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012076


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].DiagnosticRequestState_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012096


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].DiagnosticRequestState_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B6


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].DiagnosticRequestState_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D6


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].DiagnosticRequestState_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120F6


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].CommunicationAllowed_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012057


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].CommunicationAllowed_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012077


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].CommunicationAllowed_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012097


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].CommunicationAllowed_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B7


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].CommunicationAllowed_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D7


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].CommunicationAllowed_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120F7


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].NmBusSleepIndicationStatus_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012058


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].NmBusSleepIndicationStatus_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012078


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].NmBusSleepIndicationStatus_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012098


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].NmBusSleepIndicationStatus_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].NmBusSleepIndicationStatus_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].NmBusSleepIndicationStatus_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120F8


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012059


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012079


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012099


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120B9


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120D9


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].NmPrepareBusSleepIndicationStatus_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120F9


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[0].NmNetworkModeStatus_b
    "ComM Channel structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001205A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[1].NmNetworkModeStatus_b
    "ComM Channel structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001207A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[2].NmNetworkModeStatus_b
    "ComM Channel structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001209A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[3].NmNetworkModeStatus_b
    "ComM Channel structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120BA


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[4].NmNetworkModeStatus_b
    "ComM Channel structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120DA


/end MEASUREMENT




/begin MEASUREMENT

    ComM_ChannelStruct[5].NmNetworkModeStatus_b
    "ComM Channel structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120FA


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].WakeUpInhibitionCtr_u16
    "ComM user structure[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120FC


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].WakeUpInhibitionCtr_u16
    "ComM user structure[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012106


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].WakeUpInhibitionCtr_u16
    "ComM user structure[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012110


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].WakeUpInhibitionCtr_u16
    "ComM user structure[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001211A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].WakeUpInhibitionCtr_u16
    "ComM user structure[4]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012124


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].WakeUpInhibitionCtr_u16
    "ComM user structure[5]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001212E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].WakeUpInhibitionCtr_u16
    "ComM user structure[6]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012138


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].LimitToNoComCtr_u16
    "ComM user structure[0]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600120FE


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].LimitToNoComCtr_u16
    "ComM user structure[1]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012108


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].LimitToNoComCtr_u16
    "ComM user structure[2]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012112


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].LimitToNoComCtr_u16
    "ComM user structure[3]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001211C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].LimitToNoComCtr_u16
    "ComM user structure[4]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012126


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].LimitToNoComCtr_u16
    "ComM user structure[5]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012130


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].LimitToNoComCtr_u16
    "ComM user structure[6]/"
    UWORD
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    65535.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001213A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].RequestedUserMode_t
    "ComM user structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012100


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].RequestedUserMode_t
    "ComM user structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001210A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].RequestedUserMode_t
    "ComM user structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012114


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].RequestedUserMode_t
    "ComM user structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001211E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].RequestedUserMode_t
    "ComM user structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012128


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].RequestedUserMode_t
    "ComM user structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012132


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].RequestedUserMode_t
    "ComM user structure[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001213C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].IndicatedUserMode_t
    "ComM user structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012101


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].IndicatedUserMode_t
    "ComM user structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001210B


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].IndicatedUserMode_t
    "ComM user structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012115


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].IndicatedUserMode_t
    "ComM user structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001211F


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].IndicatedUserMode_t
    "ComM user structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012129


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].IndicatedUserMode_t
    "ComM user structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012133


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].IndicatedUserMode_t
    "ComM user structure[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001213D


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].numChannelsInFullCom_u8
    "ComM user structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012102


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].numChannelsInFullCom_u8
    "ComM user structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001210C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].numChannelsInFullCom_u8
    "ComM user structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012116


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].numChannelsInFullCom_u8
    "ComM user structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012120


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].numChannelsInFullCom_u8
    "ComM user structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001212A


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].numChannelsInFullCom_u8
    "ComM user structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012134


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].numChannelsInFullCom_u8
    "ComM user structure[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001213E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].numChannelsInSilentCom_u8
    "ComM user structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012103


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].numChannelsInSilentCom_u8
    "ComM user structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001210D


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].numChannelsInSilentCom_u8
    "ComM user structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012117


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].numChannelsInSilentCom_u8
    "ComM user structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012121


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].numChannelsInSilentCom_u8
    "ComM user structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001212B


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].numChannelsInSilentCom_u8
    "ComM user structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012135


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].numChannelsInSilentCom_u8
    "ComM user structure[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001213F


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[0].numChannelsInNoCom_u8
    "ComM user structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012104


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[1].numChannelsInNoCom_u8
    "ComM user structure[1]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001210E


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[2].numChannelsInNoCom_u8
    "ComM user structure[2]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012118


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[3].numChannelsInNoCom_u8
    "ComM user structure[3]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012122


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[4].numChannelsInNoCom_u8
    "ComM user structure[4]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x6001212C


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[5].numChannelsInNoCom_u8
    "ComM user structure[5]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012136


/end MEASUREMENT




/begin MEASUREMENT

    ComM_UserStruct[6].numChannelsInNoCom_u8
    "ComM user structure[6]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012140


/end MEASUREMENT




/begin MEASUREMENT

    EthSM_NetState_aen
    "Gives information about states defined internally for EthSM Networks (ETHSM_STATE_OFFLINE - EthSM is initialized in this state, ETHSM_STATE_WAIT_TRCVLINK - ComM requests COMM_FULL_COMMUNICATION in this state, Ctrl and Trcv will be initialized and set to ACTIVE. EthSM waits for transceiver link state (ACTIVE),ETHSM_STATE_WAIT_ONLINE - Transceiver link state is ACTIVE. EthSM waits for IP communication (TcpIP state = ONLINE), ETHSM_STATE_ONLINE - IP communication is availabe ComM state COMM_FULL_COMMUNICATION is reached, ETHSM_STATE_ONHOLD - EthSM lost active transceiver link state, TcpIP state is still online, ETHSM_STATE_WAIT_OFFLINE - ComM requests COMM_NO_COMMUNICATION in this state)"
    UBYTE
    AUTOSAR_EthSM_CompuMethods_EthSM_Enum_NetworkModeStateType
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x70007895
    MATRIX_DIM 1 


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].ChannelStateFlag_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121FC


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].ChannelStatusFlags_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121FD


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].DelayCount_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121FE


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].CurrentScheduleTable_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x600121FF


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].CurrentIndex_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012201


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].SavedScheduleTable_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012202


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].SavedIndex_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012203


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].Temp_SpoFrmCount_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
    0.0
    255.
    FORMAT "%5.0"
    ECU_ADDRESS 0x60012204


/end MEASUREMENT




/begin MEASUREMENT

    LinIf_ChnlVar_as[0].SpoETIndex_u8
    "Lin Interface channel status structure[0]/"
    UBYTE
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    1
    100
