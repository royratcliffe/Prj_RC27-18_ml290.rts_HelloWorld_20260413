    ECU_ADDRESS 0x600370CA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK43SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK43SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370CB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK43SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK43SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370CC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370CD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370CE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370CF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK44ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK44ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK45ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK45ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK52OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK52OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370D9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK52SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK52SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK52SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK52SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK53OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK53OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK53SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK53SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK53SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK53SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370DF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK54ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK54ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370E9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK55ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK55ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370EA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK56OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK56OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370EB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK56SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK56SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370EC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK56SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK56SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370ED

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK57OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK57OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370EE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK57SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK57SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370EF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK57SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK57SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK58OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK58OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK58SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK58SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK58SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK58SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK59OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK59OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK59SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK59SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK59SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK59SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK60OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK60OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK60SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK60SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK60SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK60SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370F9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK61ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK61ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600370FF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK62OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK62OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037100

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK62SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK62SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037101

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK62SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK62SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037102

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037103

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037104

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037105

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037106

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037107

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK63ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK63ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037108

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037109

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK64ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK64ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65AicSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65AicSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003710F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65AicSCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65AicSCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037110

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037111

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037112

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037113

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK65ShuntSCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK65ShuntSCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037114

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK74OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK74OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037115

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK74SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK74SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037116

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK74SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK74SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037117

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK75OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK75OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037118

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK75SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK75SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037119

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK75SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK75SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK76OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK76OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK76SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK76SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK76SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK76SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK77OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK77OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK77SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK77SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003711F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK77SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK77SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037120

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK78OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK78OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037121

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK78SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK78SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037122

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inK78SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inK78SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037123

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_DvUBAT_FWs
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_DvUBAT_FWs"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037124

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OVErr_VPR6
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OVErr_VPR6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037125

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OVWarn_VPR6
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OVWarn_VPR6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037126

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037127

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037128

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_UBAT_MON
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_UBAT_MON"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037129

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_UBRM24_FLEXIN
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_UBRM24_LOADS
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_UBRM24_LOADS"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_UBRM24_MON
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_UBRM24_MON"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VDD5
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VDD5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VDD5_IN
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VDD5_IN"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VPR6
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VPR6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003712F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VSS3
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VSS3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037130

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VSS4
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VSS4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037131

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_Temp1_HTErr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_Temp1_HTErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037132

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_Temp1_HTWarn
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_Temp1_HTWarn"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037133

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_Temp2_HTErr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_Temp2_HTErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037134

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_Temp2_HTWarn
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_Temp2_HTWarn"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037135

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037136

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037137

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VDD5
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VDD5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037138

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VDD5_IN
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VDD5_IN"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037139

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VPR6
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VPR6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VSS3
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VSS3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VSS4
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VSS4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA01OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA01OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA01OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA01OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA01SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA01SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003713F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA01SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA01SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037140

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037141

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037142

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037143

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037144

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037145

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037146

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037147

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037148

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037149

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003714F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037150

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037151

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037152

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA06OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA06OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037153

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA06OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA06OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037154

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA06OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA06OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037155

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA06SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA06SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037156

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA06SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA06SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037157

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037158

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037159

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003715F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037160

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037161

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037162

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037163

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037164

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037165

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037166

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037167

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037168

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA11OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA11OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037169

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA11OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA11OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA11SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA11SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA11SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA11SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA12OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA12OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA12SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA12SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA12SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA12SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003716F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA16OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA16OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037170

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA16OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA16OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037171

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA16SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA16SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037172

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA16SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA16SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037173

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037174

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037175

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037176

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037177

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037178

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037179

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003717F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037180

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037181

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037182

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037183

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037184

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037185

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037186

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037187

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037188

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037189

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003718F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037190

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037191

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037192

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037193

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037194

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037195

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037196

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037197

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037198

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037199

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003719F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371A9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA49OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA49OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371AF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA49OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA49OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA49SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA49SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA49SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA49SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA50OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA50OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA50OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA50OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA50SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA50SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA50SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA50SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371B9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371BF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371C9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA55OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA55OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA55OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA55OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA55SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA55SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA55SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA55SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA56OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA56OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371CF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA56OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA56OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA56SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA56SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA56SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA56SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA58OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA58OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA58OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA58OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA58SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA58SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA58SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA58SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371D9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371DF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371E9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371EA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371EB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371EC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371ED

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371EE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371EF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371F9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600371FF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037200

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037201

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK25OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK25OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037202

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK25SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK25SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037203

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK25SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK25SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037204

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037205

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037206

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037207

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037208

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037209

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK62OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK62OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK62SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK62SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003720F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK62SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK62SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037210

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037211

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037212

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037213

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037214

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037215

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK80OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK80OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037216

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK80OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK80OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037217

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK80SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK80SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037218

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK80SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK80SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037219

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK81OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK81OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK81OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK81OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK81SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK81SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK81SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK81SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK82OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK82OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK82OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK82OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003721F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK82SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK82SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037220

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK82SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK82SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037221

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK83OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK83OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037222

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK83OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK83OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037223

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK83SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK83SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037224

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK83SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK83SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037225

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK84OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK84OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037226

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK84OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK84OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037227

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK84SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK84SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037228

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK84SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK84SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037229

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK85OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK85OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK85OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK85OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK85SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK85SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK85SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK85SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK86OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK86OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK86OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK86OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003722F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK86SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK86SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037230

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK86SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK86SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037231

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK87OL
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK87OL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037232

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK87OT
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK87OT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037233

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK87SCB
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK87SCB"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037234

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK87SCG
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK87SCG"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037235

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_DSMDummy
    "Status of DFC / Status of diagnostic fault check DFC_DSMDummy"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037236

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8000
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8000"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037237

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8001
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8001"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037238

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8002
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8002"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037239

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8003
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8003"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8004
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8004"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8005
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8005"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8006
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8006"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8007
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8007"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8008
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8008"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003723F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8009
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8009"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037240

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x800a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x800a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037241

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x800b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x800b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037242

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x800c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x800c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037243

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x800d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x800d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037244

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x800e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x800e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037245

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x800f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x800f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037246

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8010
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8010"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037247

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8011
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8011"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037248

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8012
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8012"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037249

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8013
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8013"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8014
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8014"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8015
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8015"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8016
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8016"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8017
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8017"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8018
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8018"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003724F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8019
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8019"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037250

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x801a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x801a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037251

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x801b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x801b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037252

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x801c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x801c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037253

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x801d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x801d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037254

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x801e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x801e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037255

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x801f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x801f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037256

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8020
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8020"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037257

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8021
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8021"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037258

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8022
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8022"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037259

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8023
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8023"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8024
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8024"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8025
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8025"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8026
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8026"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8027
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8027"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8028
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8028"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003725F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8029
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8029"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037260

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x802a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x802a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037261

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x802b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x802b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037262

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x802c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x802c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037263

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x802d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x802d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037264

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x802e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x802e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037265

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x802f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x802f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037266

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8030
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8030"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037267

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8031
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8031"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037268

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8032
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8032"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037269

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8033
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8033"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8034
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8034"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8035
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8035"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8036
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8036"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8037
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8037"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8038
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8038"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003726F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8039
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8039"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037270

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x803a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x803a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037271

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x803b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x803b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037272

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x803c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x803c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037273

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x803d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x803d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037274

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x803e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x803e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037275

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x803f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x803f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037276

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8040
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8040"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037277

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8041
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8041"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037278

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8042
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8042"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037279

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8043
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8043"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8044
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8044"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8045
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8045"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8046
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8046"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8047
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8047"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8048
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8048"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003727F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8049
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8049"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037280

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x804a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x804a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037281

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x804b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x804b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037282

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x804c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x804c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037283

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x804d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x804d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037284

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x804e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x804e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037285

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x804f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x804f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037286

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8050
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8050"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037287

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8051
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8051"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037288

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8052
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8052"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037289

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8053
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8053"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8054
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8054"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8055
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8055"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8056
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8056"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8057
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8057"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8058
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8058"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003728F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8059
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8059"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037290

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x805a
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x805a"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037291

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x805b
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x805b"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037292

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x805c
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x805c"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037293

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x805d
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x805d"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037294

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x805e
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x805e"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037295

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x805f
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x805f"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037296

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8060
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8060"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037297

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8061
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8061"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037298

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8062
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8062"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037299

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8C01
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8C01"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8C02
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8C02"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_bds_NoDeb0x8C03
    "Status of DFC / Status of diagnostic fault check DFC_bds_NoDeb0x8C03"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetDataNoBuf
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetDataNoBuf"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetDataParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetDataParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetDataboxNoInit
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetDataboxNoInit"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003729F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetRxBufStatusParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetRxBufStatusParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetStatusParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetStatusParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canGetTxBufStatusParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canGetTxBufStatusParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canInitParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canInitParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canInitRxDataboxOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canInitRxDataboxOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canInitRxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canInitRxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canInitTxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canInitTxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canIpduGroupControl
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canIpduGroupControl"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canIsDataboxFreeNoInit
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canIsDataboxFreeNoInit"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372A9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canIsDataboxFreeParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canIsDataboxFreeParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canIsTxEmptyParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canIsTxEmptyParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegBusOffCallbInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegBusOffCallbInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegBusOffCallbParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegBusOffCallbParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxBufInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxBufInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxBufOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxBufOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372AF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxBufParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxBufParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxCallbInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxCallbInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxCallbParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxCallbParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxDataboxInvNumb
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxDataboxInvNumb"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxDataboxInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxDataboxInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxDataboxOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxDataboxOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegRxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegRxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxBufInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxBufInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxBufOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxBufOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxBufParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxBufParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372B9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxDataboxInvNumb
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxDataboxInvNumb"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxDataboxInvState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxDataboxInvState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxDataboxOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxDataboxOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canRegTxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canRegTxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canResetTxBufParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canResetTxBufParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canSendDataBufOvfl
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canSendDataBufOvfl"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372BF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canSendDataParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canSendDataParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canSendDataboxNoInit
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canSendDataboxNoInit"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canSendDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canSendDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canSetTxCycleParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canSetTxCycleParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canStartParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canStartParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_canStopParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_canStopParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_can_ClearIpduGroup
    "Status of DFC / Status of diagnostic fault check DFC_rbr_can_ClearIpduGroup"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_can_ReceiveSignal
    "Status of DFC / Status of diagnostic fault check DFC_rbr_can_ReceiveSignal"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_can_SendSignal
    "Status of DFC / Status of diagnostic fault check DFC_rbr_can_SendSignal"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_can_SetIpduGroup
    "Status of DFC / Status of diagnostic fault check DFC_rbr_can_SetIpduGroup"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372C9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmDTCJ1939
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmDTCJ1939"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmDelDTCJ1939
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmDelDTCJ1939"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmDelErrors
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmDelErrors"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmGetDFES
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmGetDFES"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmGetDTCJ1939
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmGetDTCJ1939"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmGetErrors
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmGetErrors"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372CF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmGetNumErrors
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmGetNumErrors"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmInitQueueOverflow
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmInitQueueOverflow"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmNumDTCJ1939
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmNumDTCJ1939"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmTesterror
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmTesterror"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmUpdateDebError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmUpdateDebError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmUpdateError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmUpdateError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmgetDFCStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmgetDFCStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_dsmtestErrorDFC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_dsmtestErrorDFC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAi
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAic
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAic"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372D9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAicCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAicCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAicGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAicGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAid
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAid"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAidCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAidCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAiv
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAiv"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAivCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAivCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372DF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inAivGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inAivGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inDi
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inDi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inFi
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inFi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inFiCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inFiCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inFiGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inFiGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inFi_Buffered
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inFi_Buffered"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inPhase
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inPhase"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inPhaseGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inPhaseGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inPhaseResetCounter
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inPhaseResetCounter"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inRi
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inRi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372E9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inRiCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inRiCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372EA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inRiCfgTemp
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inRiCfgTemp"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372EB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inRiGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inRiGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372EC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inRiGetTemp
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inRiGetTemp"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372ED

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentCopyFDFifo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentCopyFDFifo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372EE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentDisable
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentDisable"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372EF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentEnable
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentEnable"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentGetErrorStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentGetErrorStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentGetFD
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentGetFD"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentGetSD
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentGetSD"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentGetSDDatabox
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentGetSDDatabox"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentInitSDDatabox
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentInitSDDatabox"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentRegisterCopyFDFifo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentRegisterCopyFDFifo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentRegisterFDFifo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentRegisterFDFifo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_inSentRegisterSDDataboxes
    "Status of DFC / Status of diagnostic fault check DFC_rbr_inSentRegisterSDDataboxes"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372F9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusCanRxBufferOverflow
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusCanRxBufferOverflow"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusGetCaAddrParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusGetCaAddrParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusGetDiagnosticParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusGetDiagnosticParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusGetRxDataboxStatusParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusGetRxDataboxStatusParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusGetStatusParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusGetStatusParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitCommCaMissing
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitCommCaMissing"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600372FF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitCommParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitCommParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037300

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitCommState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitCommState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037301

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitDiagnosticParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitDiagnosticParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037302

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitFailureListParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitFailureListParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037303

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitRxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitRxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037304

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusInitTxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusInitTxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037305

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegRxDataboxOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegRxDataboxOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037306

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegRxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegRxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037307

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegRxDataboxState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegRxDataboxState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037308

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegTxDataboxOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegTxDataboxOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037309

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegTxDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegTxDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003730A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegTxDataboxState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegTxDataboxState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003730B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegisterErrClrCallbackParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegisterErrClrCallbackParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003730C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegisterInstancesOverlap
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegisterInstancesOverlap"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003730D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegisterInstancesParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegisterInstancesParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003730E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusRegisterInstancesState
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusRegisterInstancesState"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003730F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSendDataboxParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSendDataboxParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037310

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSendRequestPGNParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSendRequestPGNParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037311

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaAddrCaUsed
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaAddrCaUsed"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037312

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaAddrComm
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaAddrComm"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037313

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaAddrInvCan
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaAddrInvCan"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037314

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaAddrParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaAddrParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037315

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaInfoParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaInfoParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037316

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSetCaNameParam
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSetCaNameParam"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037317

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_isobusSftyCanTxErr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_isobusSftyCanTxErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037318

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_ReceiveSignal
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_ReceiveSignal"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037319

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_SendSignal
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_SendSignal"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003731A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_getStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_getStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003731B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_gotoSleep
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_gotoSleep"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003731C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_scheduleRequest
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_scheduleRequest"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003731D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_lin_wakeUp
    "Status of DFC / Status of diagnostic fault check DFC_rbr_lin_wakeUp"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003731E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memFlsCfgShr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memFlsCfgShr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003731F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037320

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memMarkBlock
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memMarkBlock"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037321

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadApi1Error
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadApi1Error"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037322

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadApi2Error
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadApi2Error"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037323

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadBlock
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadBlock"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037324

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadCalibInputError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadCalibInputError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037325

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadCalibOuputError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadCalibOuputError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037326

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memReadSystemError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memReadSystemError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037327

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_memWriteBlock
    "Status of DFC / Status of diagnostic fault check DFC_rbr_memWriteBlock"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037328

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_moOV_FirstConstADC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_moOV_FirstConstADC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037329

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_moOV_SecondConstADC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_moOV_SecondConstADC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003732A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_moUV_FirstConstADC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_moUV_FirstConstADC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003732B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_moUV_SecondConstADC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_moUV_SecondConstADC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003732C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_INH
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_INH"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003732D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_INHLatch
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_INHLatch"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003732E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_adcPDD_fail
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_adcPDD_fail"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003732F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_memoryProtection_err
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_memoryProtection_err"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037330

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037331

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA02Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA02Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037332

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037333

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA03Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA03Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037334

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037335

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA04Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA04Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037336

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037337

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA05Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA05Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037338

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037339

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA07Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA07Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003733A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003733B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA08Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA08Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003733C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003733D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA09Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA09Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003733E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003733F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA10Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA10Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037340

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037341

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA17Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA17Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037342

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037343

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA18Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA18Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037344

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037345

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA19Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA19Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037346

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037347

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA20Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA20Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037348

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037349

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA31Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA31Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003734A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003734B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA32Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA32Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003734C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003734D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA33Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA33Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003734E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003734F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA34Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA34Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037350

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037351

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA35Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA35Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037352

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037353

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA46Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA46Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037354

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037355

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA47Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA47Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037356

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037357

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA48Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA48Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037358

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037359

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA51Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA51Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003735A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003735B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA52Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA52Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003735C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003735D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA53Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA53Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003735E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003735F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outA54Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outA54Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037360

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAov
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAov"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037361

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAovCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAovCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037362

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAovCfgPI
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAovCfgPI"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037363

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAovGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAovGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037364

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAovGetVoltage
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAovGetVoltage"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037365

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outAovResetError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outAovResetError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037366

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037367

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDoCfgPwrLs
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDoCfgPwrLs"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037368

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDoDisable
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDoDisable"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037369

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDoGetCurrent
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDoGetCurrent"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003736A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDoGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDoGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003736B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outDoResetError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outDoResetError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003736C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003736D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK07Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK07Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003736E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003736F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK08Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK08Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037370

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037371

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK09Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK09Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037372

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037373

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK12Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK12Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037374

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037375

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK13Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK13Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037376

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037377

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK14Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK14Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037378

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037379

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK15Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK15Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003737A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003737B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK16Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK16Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003737C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003737D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK17Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK17Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003737E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003737F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK29Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK29Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037380

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037381

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK51Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK51Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037382

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73OC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73OC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037383

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outK73Unintended
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outK73Unintended"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037384

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037385

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037386

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoCfgPeriod
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoCfgPeriod"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037387

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoCfgPwrLs
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoCfgPwrLs"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037388

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoDisable
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoDisable"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037389

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoGetCurrent
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoGetCurrent"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003738A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003738B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoResetError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoResetError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003738C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPoc
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPoc"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003738D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPocCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPocCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003738E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPocCfgDither
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPocCfgDither"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003738F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPocCfgPI
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPocCfgPI"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037390

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPod
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPod"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037391

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPodCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPodCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037392

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_outPodCfgPeriod
    "Status of DFC / Status of diagnostic fault check DFC_rbr_outPodCfgPeriod"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037393

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_rsmFfiApiCallErr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_rsmFfiApiCallErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037394

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safout
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safout"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037395

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutCfg
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037396

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl1
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037397

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl10
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037398

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl10Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl10Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037399

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl10OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl10OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003739A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl11
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003739B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl11Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl11Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003739C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl11OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl11OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003739D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl12
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl12"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003739E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl12Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl12Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003739F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl12OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl12OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373A0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl13
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373A1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl13Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl13Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373A2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl13OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl13OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373A3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl14
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373A4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl14Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl14Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373A5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl14OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl14OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373A6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl15
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl15"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373A7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl15Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl15Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373A8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl15OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl15OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373A9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl16
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl16"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373AA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl16Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl16Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373AB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl16OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl16OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373AC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl17
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl17"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373AD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl17Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl17Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373AE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl17OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl17OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373AF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl18
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl18"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373B0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl18Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl18Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373B1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl18OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl18OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373B2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl1Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl1Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373B3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl1OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl1OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373B4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl2
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373B5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl2Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl2Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373B6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl2OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl2OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373B7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl3
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373B8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl3Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl3Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373B9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl3OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl3OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373BA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl4
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373BB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl4Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl4Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373BC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl4OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl4OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373BD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl5
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373BE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl5Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl5Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373BF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl5OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl5OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373C0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl6
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl6"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373C1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl6Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl6Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373C2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl6OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl6OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373C3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl7
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373C4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl7Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl7Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373C5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl7OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl7OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373C6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl8
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373C7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl8Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl8Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373C8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl8OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl8OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373C9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl9
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl9"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373CA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl9Dev
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl9Dev"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373CB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutChnl9OR
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutChnl9OR"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373CC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutDevError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutDevError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373CD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutGetStatus
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutGetStatus"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373CE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutIgnoreError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutIgnoreError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373CF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutResetError
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutResetError"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373D0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safoutUnlock
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safoutUnlock"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373D1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_safout_cfgDiag
    "Status of DFC / Status of diagnostic fault check DFC_rbr_safout_cfgDiag"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373D2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secAccessDenied_RC
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secAccessDenied_RC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373D3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secAccessDenied_WDBI
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secAccessDenied_WDBI"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373D4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secEvalRespKey
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secEvalRespKey"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373D5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secFlashingFailure
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secFlashingFailure"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373D6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secGetLevel
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secGetLevel"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373D7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secGetRnd
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secGetRnd"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373D8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secGetSeed
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secGetSeed"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373D9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secInvalidPassword
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secInvalidPassword"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373DA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secIsRequestAllowed
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secIsRequestAllowed"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373DB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secResetLevel
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secResetLevel"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373DC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secSaveSecret
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secSaveSecret"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373DD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_secSetLevel
    "Status of DFC / Status of diagnostic fault check DFC_rbr_secSetLevel"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373DE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysAit
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysAit"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373DF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysAiv
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysAiv"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373E0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysDi
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysDi"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373E1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysDo
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysDo"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373E2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysGetVss
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysGetVss"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373E3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysInit
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysInit"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373E4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysOperHrIntegrityErr
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysOperHrIntegrityErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373E5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysOperHrsSaturated
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysOperHrsSaturated"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373E6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sysSetVss
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sysSetVss"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373E7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sys_coreload
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sys_coreload"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373E8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_sys_taskload
    "Status of DFC / Status of diagnostic fault check DFC_rbr_sys_taskload"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373E9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VSS1
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VSS1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373EA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_OV_VSS2
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_OV_VSS2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373EB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VSS1
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VSS1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373EC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rbr_mo_UV_VSS2
    "Status of DFC / Status of diagnostic fault check DFC_rbr_mo_UV_VSS2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373ED

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CANSM_E_BUS_OFF_NETWORK_0
    "Status of DFC / Status of diagnostic fault check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373EE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CANSM_E_BUS_OFF_NETWORK_1
    "Status of DFC / Status of diagnostic fault check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373EF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CANSM_E_BUS_OFF_NETWORK_2
    "Status of DFC / Status of diagnostic fault check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373F0

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CANSM_E_BUS_OFF_NETWORK_3
    "Status of DFC / Status of diagnostic fault check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373F1

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CANTRCV_E_NO_TRCV_CONTROL_0
    "Status of DFC / Status of diagnostic fault check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373F2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_CAN_E_TIMEOUT
    "Status of DFC / Status of diagnostic fault check DFC_CAN_E_TIMEOUT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373F3

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_0
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373F4

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_1
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373F5

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_2
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373F6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_3
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373F7

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_4
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373F8

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_COMM_E_NET_START_IND_CHANNEL_5
    "Status of DFC / Status of diagnostic fault check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373F9

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_LIN_E_TIMEOUT
    "Status of DFC / Status of diagnostic fault check DFC_LIN_E_TIMEOUT"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373FA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_MultiStackTrace_Threshold
    "Status of DFC / Status of diagnostic fault check DFC_rba_MultiStackTrace_Threshold"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373FB

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_ETH_E_ACCESS_0
    "Status of DFC / Status of diagnostic fault check DFC_ETH_E_ACCESS_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373FC

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV
    "Status of DFC / Status of diagnostic fault check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373FD

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_RBA_IOEXTLIB_KEEPALIVE_INI
    "Status of DFC / Status of diagnostic fault check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373FE

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_MRly_Diag_Stk_Event
    "Status of DFC / Status of diagnostic fault check DFC_rba_MRly_Diag_Stk_Event"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x600373FF

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_MemDiagExtd_MemReadSngErr
    "Status of DFC / Status of diagnostic fault check DFC_rba_MemDiagExtd_MemReadSngErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037400

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_MemDiag_MemReadErr
    "Status of DFC / Status of diagnostic fault check DFC_rba_MemDiag_MemReadErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037401

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_MemDiag_MemWrErr
    "Status of DFC / Status of diagnostic fault check DFC_rba_MemDiag_MemWrErr"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037402

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_SyC_IrrSwOffTrigEngRun_Event
    "Status of DFC / Status of diagnostic fault check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037403

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_T15_Diag_ComInVld_Event
    "Status of DFC / Status of diagnostic fault check DFC_rba_T15_Diag_ComInVld_Event"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037404

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_T15_Diag_ComOff_HwOn_Event
    "Status of DFC / Status of diagnostic fault check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037405

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_rba_T15_Diag_ComOn_HwOff_Event
    "Status of DFC / Status of diagnostic fault check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037406

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037407

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037408

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_10
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037409

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003740A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003740B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003740C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003740D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_22
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_22"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003740E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_23
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_23"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003740F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037410

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037411

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_7
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037412

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM0_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM0_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037413

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM10_16
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM10_16"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037414

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM10_17
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM10_17"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037415

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM10_21
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM10_21"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037416

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037417

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037418

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037419

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_3
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003741A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003741B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003741C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003741D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM11_9
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM11_9"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003741E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003741F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037420

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_10
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037421

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037422

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037423

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037424

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037425

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_22
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_22"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037426

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_23
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_23"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037427

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037428

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037429

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_7
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003742A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM1_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM1_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003742B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM21_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM21_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003742C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM21_16
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM21_16"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003742D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM21_3
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM21_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003742E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003742F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_10
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037430

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037431

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037432

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037433

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037434

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_22
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_22"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037435

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_23
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_23"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037436

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037437

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037438

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_7
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037439

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM2_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM2_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003743A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003743B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_10
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003743C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003743D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003743E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003743F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037440

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_22
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_22"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037441

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_23
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_23"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037442

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037443

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037444

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_7
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037445

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM3_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM3_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037446

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037447

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037448

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_12
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_12"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037449

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003744A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_15
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_15"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003744B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_17
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_17"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003744C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_18
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_18"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003744D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003744E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_20
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_20"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003744F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_21
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_21"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037450

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_25
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_25"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037451

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037452

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_5
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_5"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037453

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_7
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_7"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037454

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM6_8
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM6_8"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037455

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037456

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_12
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_12"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037457

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037458

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_14
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_14"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037459

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_15
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_15"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003745A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_16
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_16"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003745B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_17
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_17"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003745C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003745D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_20
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_20"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003745E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_25
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_25"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003745F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_26
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_26"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037460

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_28
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_28"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037461

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_29
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_29"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037462

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_30
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_30"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037463

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM7_31
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM7_31"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037464

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037465

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037466

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_10
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_10"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037467

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_11
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_11"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037468

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_12
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_12"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037469

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_13
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_13"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003746A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_16
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_16"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003746B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_18
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_18"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003746C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_2
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003746D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_3
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003746E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_30
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_30"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003746F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_31
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_31"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037470

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM8_4
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM8_4"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037471

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM9_0
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM9_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037472

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM9_1
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM9_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037473

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM9_15
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM9_15"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037474

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MOXEMM_SMU_ALM9_3
    "Status of DFC / Status of diagnostic fault check DFC_MOXEMM_SMU_ALM9_3"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037475

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoCSOPICO
    "Status of DFC / Status of diagnostic fault check DFC_MoCSOPICO"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037476

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoFVarPostBldSel
    "Status of DFC / Status of diagnostic fault check DFC_MoFVarPostBldSel"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037477

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoSysCtrlReIni
    "Status of DFC / Status of diagnostic fault check DFC_MoSysCtrlReIni"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037478

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTMCUFW
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTMCUFW"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037479

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTMonBIST
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTMonBIST"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003747A

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTRegMonTest
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTRegMonTest"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003747B

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTStbySMUAlvTest
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTStbySMUAlvTest"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003747C

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTTempSens
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTTempSens"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003747D

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_MoXEMMHwLTUCBCfg
    "Status of DFC / Status of diagnostic fault check DFC_MoXEMMHwLTUCBCfg"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003747E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_OCWDAABEActv
    "Status of DFC / Status of diagnostic fault check DFC_OCWDAABEActv"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6003747F

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_OCWDACom
    "Status of DFC / Status of diagnostic fault check DFC_OCWDACom"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037480

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_OCWDAErrPin
    "Status of DFC / Status of diagnostic fault check DFC_OCWDAErrPin"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037481

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_SWReset_0
    "Status of DFC / Status of diagnostic fault check DFC_SWReset_0"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037482

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_SWReset_1
    "Status of DFC / Status of diagnostic fault check DFC_SWReset_1"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037483

/end MEASUREMENT

/begin MEASUREMENT

    DFC_st.DFC_SWReset_2
    "Status of DFC / Status of diagnostic fault check DFC_SWReset_2"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037484

/end MEASUREMENT

/begin MEASUREMENT

    DFC_stClctFault_mp
    "Collected error states of all fault checks"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 82  
    ECU_ADDRESS 0x7003028E

/end MEASUREMENT

/begin MEASUREMENT

    DFC_stClctTst_mp
    "Collected tested states of all fault checks"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 82  
    ECU_ADDRESS 0x700301EA

/end MEASUREMENT

/begin MEASUREMENT

    DFC_stFinal
    "Disable (or check finished) status of all DFCs (for PID$41 calculation)"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 82  
    ECU_ADDRESS 0x6000B6F6

/end MEASUREMENT

/begin MEASUREMENT

    DFC_stMem
    "Fault entry exists - per DFC"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 82  
    ECU_ADDRESS 0x60036EC2

/end MEASUREMENT

/begin MEASUREMENT

    DFC_stRdy
    "Ready state due to ""OK"" per DFC"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 82  
    ECU_ADDRESS 0x60036E1E

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ChkLstDltDemExCond_mp
    "Exit condition of last delete demand check during initialisation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303EB

/end MEASUREMENT

/begin MEASUREMENT

    DFES_chkSt
    "Check state of all DFCs stored in the error memory"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037B38

/end MEASUREMENT

/begin MEASUREMENT

    DFES_cnfSequence
    "DSM internal sequence counter to obtain confirmed entry sorting of all error memory entries"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x6003792C

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctDef
    "Fault counters (FLC) of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037A58

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctDel
    "Delete counters (DLC) of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x600379D8

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctEntry
    "Number of occupied DFES Entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE52

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctFrq
    "Frequency counters of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x6003750C

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctManuDef
    "Manufacturer fault counters of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037A18

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctManuOk
    "Manufacturer healing counters of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x600379F8

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctMIL
    "Number of DFES Entries illuminating the MIL(Only continuous illumination, no blinking counted)"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE54

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctOBD
    "Number of DFES Entries visible in OBD Mode 3"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE56

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctOBDPend
    "Number of DFES Entries visible in OBD Mode 7 (pending)"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE55

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctOk
    "Healing counters (HLC) of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037A38

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctPDTC
    "Number of DFES Entries visible in OBD Mode A (PDTC)"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE4F

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctSrv
    "Number of DFES Entries visible for Service tester"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE53

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ctSrvDef
    ""
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE50

/end MEASUREMENT

/begin MEASUREMENT

    DFES_entrySt
    "Entry state of all DFCs stored in the error memory"
    UBYTE
    DFES_Entry_Verb
    1
    100
    0.00
    30.0000000000

    
    FORMAT "%13.10"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037B18

/end MEASUREMENT

/begin MEASUREMENT

    DFES_entryStPdtcStrd
    "Current EEPROM storage state of PDTC DFES entries"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 5  
    ECU_ADDRESS 0x60034006

/end MEASUREMENT

/begin MEASUREMENT

    DFES_EnvBlock
    "Environmental data of all fault entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 896  
    ECU_ADDRESS 0x6003752C

/end MEASUREMENT

/begin MEASUREMENT

    DFES_FrzFrVal
    "Freeze frame values of all fault entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 128  
    ECU_ADDRESS 0x600378AC

/end MEASUREMENT

/begin MEASUREMENT

    DFES_idxSequence
    "Sequence in which DFES entries were allocated (became Service$03 or Service$07 visible)"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x6003794D

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ISOFrstCnfDFC
    "DFC matching to criteria of first confirmed DTC"
    UWORD
    DFCDFP_Verb
    1
    100
    0.00
    1312.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6003750A

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ISOFrstFailDFC
    "DFC matching to criteria of first failed DTC"
    UWORD
    DFCDFP_Verb
    1
    100
    0.00
    1312.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x60037BBA

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ISORcntCnfDFC
    "DFC matching to criteria of most recent confirmed DTC"
    UWORD
    DFCDFP_Verb
    1
    100
    0.00
    1312.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x60037508

/end MEASUREMENT

/begin MEASUREMENT

    DFES_ISORcntFailDFC
    "DFC matching to criteria of most recent failed DTC"
    UWORD
    DFCDFP_Verb
    1
    100
    0.00
    1312.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x60037B78

/end MEASUREMENT

/begin MEASUREMENT

    DFES_lenLstAllwdDst_mp
    ""
    SLONG
    Length
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030174

/end MEASUREMENT

/begin MEASUREMENT

    DFES_MonEvnt
    "DFES monitoring - Event Id"
    UWORD
    DFES_Mon_Verb
    1
    100
    0.00
    32786.0000000

    
    FORMAT "%13.7"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x60037C86

/end MEASUREMENT

/begin MEASUREMENT

    DFES_MonObjt
    "DFES monitoring - Object Id"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x60037C82

/end MEASUREMENT

/begin MEASUREMENT

    DFES_MonParm
    "DFES monitoring - Parameter"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x60037C7E

/end MEASUREMENT

/begin MEASUREMENT

    DFES_MonPtr
    "DSM internal pointer for DFES monitoring"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C8A

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numDFC
    "Names of stored fault checks in the error memory"
    UWORD
    DFC_Verb
    1
    100
    0.00
    1310.

    
    FORMAT "%2.0"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037AD8

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numDFCAck
    "acknowledged ID of fault entry (scanned and handled)"
    UWORD
    DFC_Verb
    1
    100
    0.00
    1310.

    
    FORMAT "%2.0"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037998

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numDFCImdt
    "Names of immediately stored fault checks in the error memory"
    UWORD
    DFC_Verb
    1
    100
    0.00
    1310.

    
    FORMAT "%2.0"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037C3C

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numEntryAvl
    "Number of possible DFES Entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE4E

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numEnvSize
    "Number of bytes in one environment block"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE4B

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numExtdFrzFrmSize
    "Number of bytes for environmental conditions contained in one freeze frame extension set"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE4C

/end MEASUREMENT

/begin MEASUREMENT

    DFES_numFrzFrmSize
    "Number of bytes in one freeze frame"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE4D

/end MEASUREMENT

/begin MEASUREMENT

    DFES_OutLamps
    "Error lamp status of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x6000CDDF

/end MEASUREMENT

/begin MEASUREMENT

    DFES_OutMILMod
    ""
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x6000CDFF

/end MEASUREMENT

/begin MEASUREMENT

    DFES_PDTCStore
    "indication to store permanent DTCs at beginning of postdrive"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE44

/end MEASUREMENT

/begin MEASUREMENT

    DFES_prioEntryImdt
    "Priority of error memory entries"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037C1C

/end MEASUREMENT

/begin MEASUREMENT

    DFES_StateVisibility
    "Tester visibility of error memory entries"
    UWORD
    DFES_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x6000B79E

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stChk
    "Legacy check state of all DFCs stored in the error memory"
    UBYTE
    DFES_stCheck_Verb
    1
    100
    0.00
    7.00000000000

    
    FORMAT "%13.11"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037AB8

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stCounters
    "Counter state of all DFCs stored in the error memory"
    UBYTE
    DFES_stCnt_Verb
    1
    100
    0.00
    85.0000000000

    
    FORMAT "%13.10"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037A78

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stCtlSetting
    "internal and central disable request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE41

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stDataImdt
    "Environment data state of error memory entries"
    UBYTE
    DFES_stDataImdt_Verb
    1
    100
    0.00
    21.0000000000

    
    FORMAT "%13.10"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037BBC

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stDataImdtTrans
    "Alternative environment data state of error memory entries during transition."
    UBYTE
    DFES_stDataImdt_Verb
    1
    100
    0.00
    21.0000000000

    
    FORMAT "%13.10"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x6000CE1F

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stDTCRecUpdt
    "state of disable DTC record update, AUTOSAR feature"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE40

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stDTCStorage
    "state of disable DTC storage AUTOSAR feature"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE3F

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stEepWrReq
    "request for an EEPROM storage"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE48

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stEntry
    "Legacy entry state of all DFCs stored in the error memory"
    UBYTE
    DFES_stEntry_Verb
    1
    100
    0.00
    252.000000000

    
    FORMAT "%13.9"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037A98

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stErrDia
    "DSM internal status of all tester visibilities"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE5A

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stErrLamp
    "DFES error lamp demands"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE5C

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stInh
    "Inhibit (FIM) relevant state of fault entry"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037978

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stMILDsplStgy
    ""
    UBYTE
    DFES_DsplStgy
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000CE57

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stMILMod
    ""
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE58

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stOrdImdt
    "Order state of error memory entries"
    UWORD
    DFES_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037BDC

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stOutstate
    "DSM Flag status to check whether error counter is valid or not."
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE59

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stPrgEvt
    "ECU programming event detected (reset of all diagnostic informations including IUMPR and permanent DTCs)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE43

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stPrgEvt_msg
    "Interface that gives information about ECU programming event."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C723

/end MEASUREMENT

/begin MEASUREMENT

    DFES_stRepClrAftPwrFail
    "Repeated DSM clear after powerfail necessary"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C6DC

/end MEASUREMENT

/begin MEASUREMENT

    DFES_SvsLampIllumn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE5B

/end MEASUREMENT

/begin MEASUREMENT

    DFES_tiDefCntr
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 32  
    ECU_ADDRESS 0x60037488

/end MEASUREMENT

/begin MEASUREMENT

    DFES_xAsgnEnvAllDataSize
    "Memory usage of common calibrated environment data"
    UBYTE
    DFES_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CD3A

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_cntTestPlsTsk_mp
    "L-1 L=enNumber of testpulses in current driving cycleL-1"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x700301E6

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_nrDiagErr_mp
    "Number of supported errors of the diagnosis signal"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303E0

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_nrTestPls_mp
    "Number of testpulses in current driving cycle"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x7003015C

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stAttribOL_mp
    "Current DSM attribute (Tested detection) of the open load error when reporting open load error to DSM module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030158

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stAttribOT_mp
    "Current DSM attribute (Tested detection) of the overtemperature error when reporting overtemperature error to DSM module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030154

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stAttribSCB_mp
    "Current DSM attribute (Tested detection) of the short circuit to battery error when reporting short circuit to battery error to DSM module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030150

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stAttribSCG_mp
    "Current DSM attribute (Tested detection) of the short circuit to ground error when reporting short circuit to ground error to DSM module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x7003014C

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stDsmDebOpenLoad_mp
    "Debounce status of OL error"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030148

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stDsmDebOverT_mp
    "Debounce status of OT error"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030144

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stDsmDebScb_mp
    "Debounce status of SCB error"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030140

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stDsmDebScg_mp
    "Debounce status of SCG error"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x7003013C

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stErrCfgOpenLoad_mp
    "Configuration of behaviour for OL error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303DF

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stErrCfgOverT_mp
    "Configuration of behaviour for OT error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303DE

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stErrCfgScb_mp
    "Configuration of behaviour for SCB error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303DD

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stErrCfgScg_mp
    "Configuration of behaviour for SCG error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303DC

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stPrvTstRslt_mp
    "The latest result of test impulse"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030138

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stSigCfg_mp
    "Configuration of the diagnosis signal"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303DB

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stSigErrInfo_mp
    "The last error information of HWE read from the chip"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030134

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stSig_mp
    "Actual state of the diagnosis signal: INVALID, NOTEST, NOFAULT, FAULT, PREFAULT, HEALFAULT, WAITSTATE"
    UBYTE
    DiaActrElecPsDiag_stSig_COMPU_VERB
    1
    100
    0.00
    6.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700303DA

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stTestPls_mp
    "L-1 L=enThe actual state of the testpulse state machine: NO, REQUESTED, RUN, FINISHED, RE-TRIGGEREDL-1"
    UBYTE
    DiaActrElecPsDiag_stTestPls_COMPU_VERB
    1
    100
    1.00000000000
    5.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700303D9

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_stTmngTestPls_mp
    "The current time to wait between two testpulses"
    UBYTE
    DiaActrElecPsDiag_stTmngTestPls_COMPU_VERB
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700303D8

/end MEASUREMENT

/begin MEASUREMENT

    DiaActrElecPsDiag_tiTstPls_mp
    "Current status of timer for the time between testpulses during permanent fault"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x700301E4

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_HBrDiagInfo_mp
    "Diagnosis information from HWE - HBr."
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030170

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_HlfBrDiagInfo_mp
    "Diagnosis information from IoSrv - HlfBr"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x70030168

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_nrDiagErr_mp
    "Number of diagnostic errors Size of error object array."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303EA

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_OLSigErrInfo_mp
    "Signal error information during open load diagnosis."
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030164

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_ReasOLAbort_mp
    "Measuring point indicating reason for open load diagnosis abort. [Relevant only if open load is configured in switchoff or disable mode]."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303E9

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_SigErrInfo_mp
    "Signal error information during normal diagnosis."
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030160

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stAddOLDiag_mp
    "Additional open load diagnosis status."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303E8

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stDiagCtrl_mp
    "Status of diagnosis software (DiaActr_ElecHBrdgDiag) controlling H-Bridge output."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303E7

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stDiagDi_mp
    "Diagnosis disable status."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303E6

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stOLAbortReq_mp
    "Open load abort request status."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303E5

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stOLDiagMode_mp
    "Open load diagnosis mode."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303E4

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stOLDiag_mp
    "Open load diagnosis status."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303E3

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_stSigQly_mp
    "Signal quality returned."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303E2

/end MEASUREMENT

/begin MEASUREMENT

    DiaActr_ElecHBrdgDiag_TestPlsReq_mp
    "Test pulse request status."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303E1

/end MEASUREMENT

/begin MEASUREMENT

    DINH_ctMonCorr
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B7F2

/end MEASUREMENT

/begin MEASUREMENT

    DINH_DSQSrv7Vis
    "Service 0x07 visibility of DSQs"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6000C352

/end MEASUREMENT

/begin MEASUREMENT

    DINH_FIdSrv7Vis
    "Service 0x07 visibility of FIds"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x6000C354

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_InhibitAlways
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_InhibitAlways"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C35E

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_ComCILAddCond0
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_ComCILAddCond0"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C360

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_ComCILAddCond1
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_ComCILAddCond1"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C362

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_ComCILAddCond2
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_ComCILAddCond2"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C364

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_ComCILAddCond3
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_ComCILAddCond3"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C366

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_ComNEngNPL
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_ComNEngNPL"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C368

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DELibEnvP
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DELibEnvP"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C36A

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DELibEnvT
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DELibEnvT"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C36C

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DELibPRelPfilDs
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DELibPRelPfilDs"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C36E

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DIUMPRGenDenom1
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DIUMPRGenDenom1"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C370

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DIUMPRGenDenom1PDTC
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DIUMPRGenDenom1PDTC"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C372

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DIUMPRGenDenom2
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DIUMPRGenDenom2"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C374

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DIUMPRGenDenom3
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DIUMPRGenDenom3"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C376

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DIUMPRIgn
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DIUMPRIgn"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C378

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_DSMWarmUpCycle
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_DSMWarmUpCycle"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C37A

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_I15031_srv9_VT_Freeze
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_I15031_srv9_VT_Freeze"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C37C

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_InhibitNever
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_InhibitNever"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C37E

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_MILLmpPwrStg
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_MILLmpPwrStg"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C380

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_SVSLmpPwrStg
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_SVSLmpPwrStg"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C382

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_StopLmpPwrStg
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_StopLmpPwrStg"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C384

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.FId_WrnLmpPwrStg
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for FId_WrnLmpPwrStg"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C386

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.Function_Id_1
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for Function_Id_1"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C388

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.Function_Id_2
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for Function_Id_2"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C38A

/end MEASUREMENT

/begin MEASUREMENT

    DINH_nrActvInhReas.Function_Id_3
    "Number of active inhibit reasons for the FIds / Number of active inhibit reasons for Function_Id_3"
    UWORD
    DINH_ct_Compu
    1
    100
    -4095.000
    4096.000

    BIT_MASK 0x1fff
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000C38C

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stClctFId_mp
    "Collected states of all function identifiers, if the bit is 1 the FId is inhibited"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 2  
    ECU_ADDRESS 0x700301E0

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_Unused
    "Inhibit Status of FIds / "
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C35C

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_InhibitAlways
    "Inhibit Status of FIds / Status of function identifier FId_InhibitAlways"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C35E

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_ComCILAddCond0
    "Inhibit Status of FIds / Status of function identifier FId_ComCILAddCond0"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C360

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_ComCILAddCond1
    "Inhibit Status of FIds / Status of function identifier FId_ComCILAddCond1"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C362

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_ComCILAddCond2
    "Inhibit Status of FIds / Status of function identifier FId_ComCILAddCond2"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C364

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_ComCILAddCond3
    "Inhibit Status of FIds / Status of function identifier FId_ComCILAddCond3"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C366

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_ComNEngNPL
    "Inhibit Status of FIds / Status of function identifier FId_ComNEngNPL"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C368

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DELibEnvP
    "Inhibit Status of FIds / Status of function identifier FId_DELibEnvP"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C36A

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DELibEnvT
    "Inhibit Status of FIds / Status of function identifier FId_DELibEnvT"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C36C

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DELibPRelPfilDs
    "Inhibit Status of FIds / Status of function identifier FId_DELibPRelPfilDs"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C36E

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DIUMPRGenDenom1
    "Inhibit Status of FIds / Status of function identifier FId_DIUMPRGenDenom1"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C370

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DIUMPRGenDenom1PDTC
    "Inhibit Status of FIds / Status of function identifier FId_DIUMPRGenDenom1PDTC"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C372

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DIUMPRGenDenom2
    "Inhibit Status of FIds / Status of function identifier FId_DIUMPRGenDenom2"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C374

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DIUMPRGenDenom3
    "Inhibit Status of FIds / Status of function identifier FId_DIUMPRGenDenom3"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C376

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DIUMPRIgn
    "Inhibit Status of FIds / Status of function identifier FId_DIUMPRIgn"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C378

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_DSMWarmUpCycle
    "Inhibit Status of FIds / Status of function identifier FId_DSMWarmUpCycle"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C37A

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_I15031_srv9_VT_Freeze
    "Inhibit Status of FIds / Status of function identifier FId_I15031_srv9_VT_Freeze"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C37C

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_InhibitNever
    "Inhibit Status of FIds / Status of function identifier FId_InhibitNever"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C37E

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_MILLmpPwrStg
    "Inhibit Status of FIds / Status of function identifier FId_MILLmpPwrStg"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C380

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_SVSLmpPwrStg
    "Inhibit Status of FIds / Status of function identifier FId_SVSLmpPwrStg"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C382

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_StopLmpPwrStg
    "Inhibit Status of FIds / Status of function identifier FId_StopLmpPwrStg"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C384

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.FId_WrnLmpPwrStg
    "Inhibit Status of FIds / Status of function identifier FId_WrnLmpPwrStg"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C386

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.Function_Id_1
    "Inhibit Status of FIds / Status of function identifier Function_Id_1"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C388

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.Function_Id_2
    "Inhibit Status of FIds / Status of function identifier Function_Id_2"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C38A

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stFId.Function_Id_3
    "Inhibit Status of FIds / Status of function identifier Function_Id_3"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C38C

/end MEASUREMENT

/begin MEASUREMENT

    DINH_stMod7VisyCmpl
    "status of the first completed calculation of mode7 visibility"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000D171

/end MEASUREMENT

/begin MEASUREMENT

    DINH_xFIDObsvInh_mp
    "DFCs and DSQs which inhibit the FId currently"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    MATRIX_DIM 10  
    ECU_ADDRESS 0x700301CC

/end MEASUREMENT

/begin MEASUREMENT

    DINH_xFIDObsvRls_mp
    "DFCs and DSQs which don't inhibit the FId currently"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    MATRIX_DIM 10  
    ECU_ADDRESS 0x700301B8

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_ctDenom
    "Calculated denominators of IUMPR relevant diagnostics (variant 1)"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 40  
    ECU_ADDRESS 0x60037CFA

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_ctGenDenom
    "General denominator"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037CF8

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_ctIgn
    "Ignition cycle counter"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037CF6

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_ctNum
    "Calculated numerators of IUMPR relevant diagnostics (variant 1)"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 40  
    ECU_ADDRESS 0x60037D4A

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_numIndGrp
    "IUMPR record with smallest ratio within the component group"
    UBYTE
    CfgRatio_Verb
    1
    100
    0.00
    39.

    
    FORMAT "%2.0"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000D1AC

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_rValRatMin
    "Smallest ratio within component group"
    UWORD
    Fact
    1
    100
    0.00
    7.999878

    
    FORMAT "%8.6"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000C408

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_state
    "Status bytes of IUMPR relevant diagnostics (variant 1)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 40  
    ECU_ADDRESS 0x60037CCE

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_stEnaDenom
    "enable status for general denominator and ignition cycle counter"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60034088

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_stEnaPDTC
    "status of PDTC driving cycle condition"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60034078

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_stFIdGenDenom_mp
    "collected FId status (mode 7 visibility) of general denominator"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303D7

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_stProtdRamVld
    "DIUMPR protected ram content is valid"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60034104

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_0
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 0"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003408C

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_1
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 1"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003408D

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_2
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 2"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003408E

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_3
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 3"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003408F

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_4
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 4"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034090

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_5
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 5"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034091

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_6
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 6"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034092

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_7
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 7"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034093

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_8
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 8"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034094

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_9
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 9"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034095

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_10
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 10"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034096

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_11
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 11"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034097

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_12
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 12"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034098

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_13
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 13"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x60034099

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_14
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 14"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409A

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_15
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 15"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409B

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_16
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 16"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409C

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_17
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 17"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409D

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_18
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 18"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409E

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_19
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 19"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6003409F

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_20
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 20"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A0

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_21
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 21"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A1

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_22
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 22"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A2

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_23
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 23"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A3

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_24
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 24"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A4

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_25
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 25"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A5

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_26
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 26"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A6

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_27
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 27"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A7

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_28
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 28"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A8

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_29
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 29"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340A9

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_30
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 30"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AA

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_31
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 31"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AB

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_32
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 32"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AC

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_33
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 33"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AD

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_34
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 34"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AE

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_35
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 35"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340AF

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_36
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 36"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340B0

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_37
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 37"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340B1

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_38
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 38"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340B2

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiCont.SigActv_39
    "IUMPR activation timer / Continuous signal activity time for IUMPR record 39"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    3.100

    BIT_MASK 0x1f
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x600340B3

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiEngOpCum
    "cumulative time since engine start (for general denominator condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x60034082

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiEngOpCumPDTC
    "cumulative time since engine start (for PDTC condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6003407C

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiIdl
    "continuous vehicle operation at idle (for general denominator condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x60034080

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiIdlPDTC
    "continuous vehicle operation at idle (for PDTC driving cycle condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6003407A

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiSigActv
    "Accumulated activation time"
    UBYTE
    DIUMPR_ti100ms
    1
    100
    0.00
    25.50

    
    FORMAT "%5.2"
    MATRIX_DIM 40  
    ECU_ADDRESS 0x600340DC

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiVehSpdCum
    "cumulative vehicle operation at or above 25 miles per hour (for general denominator condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x60034084

/end MEASUREMENT

/begin MEASUREMENT

    DIUMPR_tiVehSpdCumPDTC
    "cumulative vehicle operation at or above 25 miles per hour (for PDTC cycle condition)"
    UWORD
    DIUMPR_ti100ms
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6003407E

/end MEASUREMENT

/begin MEASUREMENT

    dps_error
    "last read Pmd_GetErr() content of state OBSERVING"
    UWORD
    dez
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70002B56

/end MEASUREMENT

/begin MEASUREMENT

    dps_errStat
    "read Pmd_GetErr() content in state VERIFY or RECOVERY; this content is compared to dps_error"
    UWORD
    dez
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70002B54

/end MEASUREMENT

/begin MEASUREMENT

    dps_errStat_sum_rec
    "contains dps_errStat read during RECOVERY state"
    UWORD
    dez
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70002B52

/end MEASUREMENT

/begin MEASUREMENT

    dps_errStat_sum_ver
    "contains dps_errStat read during VERIFY state"
    UWORD
    dez
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x70002B50

/end MEASUREMENT

/begin MEASUREMENT

    dps_index
    "Indicates which powerstage is being observed"
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70002B5B

/end MEASUREMENT

/begin MEASUREMENT

    dps_recoveryTime
    "Timer Recovery"
    UBYTE
    t_q0p1
    1
    100
    0.00
    25.50

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0x70002B5A

/end MEASUREMENT

/begin MEASUREMENT

    dps_state
    "Index Statemachine"
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70002B59

/end MEASUREMENT

/begin MEASUREMENT

    dps_verifyTime
    "Timer Verify"
    UBYTE
    t_q0p1
    1
    100
    0.00
    25.50

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0x70002B58

/end MEASUREMENT

/begin MEASUREMENT

    DrvPrgSwt_numCurrCAN
    "Value of the driving program that is sent on the CAN"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7BF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DrvPrgSwt_st
    "State of the driving program"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7BE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DrvPrgSwt_stEffModReqd
    "Status efficiency mode is requested"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7BD

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_Unused
    "dynamic priority / "
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B80C

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_DynPrio.FId_InhibitAlways
    "dynamic priority / Dynamic priority of scheduled function identifier FId_InhibitAlways"
    SWORD
    DFC_OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B80E

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_Unused
    "physical priority / "
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE6D

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_PhysPrio.FId_InhibitAlways
    "physical priority / Physical priority of scheduled function identifier FId_InhibitAlways"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE6E

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_Unused
    "Ramp priority / "
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B804

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_RmpPrio.FId_InhibitAlways
    "Ramp priority / Ramp priority of scheduled function identifier FId_InhibitAlways"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B806

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_Unused
    "Scheduler Status / "
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000CE6F

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_St.FId_InhibitAlways
    "Scheduler Status / Scheduler status of function identifier FId_InhibitAlways"
    UBYTE
    DSCHED_StVerb
    1
    100
    0.00
    238.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0x6000CE70

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_stDrvMode
    "Status of current operation mode"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C44E

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_stOpMode
    "Current system-mode as provided by system-mode-manager"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000B20C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_Unused
    "exclusion reason / "
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000B808

/end MEASUREMENT

/begin MEASUREMENT

    DSCHED_WhyExcl.FId_InhibitAlways
    "exclusion reason / Exclusion cause of scheduled function identifier FId_InhibitAlways"
    UWORD
    DSCHED_FIdExcCauseVerb
    1
    100
    0.00
    255.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000B80A

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_ctObdDCy
    "Number of OBD driving cycle since diagnostic trouble codes cleared"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037C9A

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_ctObdDCy_msg
    "Number of OBD driving cycle since diagnostic trouble codes cleared"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B430

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_ctWUC
    "Number of warm-ups since diagnostic trouble codes cleared"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60036E1C

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_ctWUC_msg
    "Number of warm-ups since diagnostic trouble codes cleared"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C702

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_Time200ms
    "Trigger state / Trigger DTRG_Time200ms"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C8C

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_SimilarCondHLC
    "Trigger state / Trigger DTRG_SimilarCondHLC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C8D

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_DrivingCycleFLC
    "Trigger state / Trigger DTRG_DrivingCycleFLC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C8E

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_AlwaysTrue
    "Trigger state / Trigger DTRG_AlwaysTrue"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C8F

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_WarmUpCycleTime
    "Trigger state / Trigger DTRG_WarmUpCycleTime"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C90

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_WarmUpCycle
    "Trigger state / Trigger DTRG_WarmUpCycle"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C91

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_DrivingCycleSpeed
    "Trigger state / Trigger DTRG_DrivingCycleSpeed"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C92

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_DrivingCycleHLC
    "Trigger state / Trigger DTRG_DrivingCycleHLC"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C93

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_NoTrigger
    "Trigger state / Trigger DTRG_NoTrigger"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C94

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_Distance100m
    "Trigger state / Trigger DTRG_Distance100m"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C95

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_DTRG.DTRG_TimeFLCOFFROAD
    "Trigger state / Trigger DTRG_TimeFLCOFFROAD"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037C96

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stClrProc
    "Statemachine for clear requests"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE7C

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stClrTaskFin
    "End flag for OS_DSM_Clear_Task run"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE7B

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stDCy
    "Status OBD driving cycle"
    UBYTE
    DSMAUX_stDCyVerb
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x60037C98

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stDCy_msg
    "Status OBD driving cycle"
    UBYTE
    DSMAUX_stDCyVerb
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C701

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stDsmClrActv
    "Indicator of a running DSM clear procedure"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C81B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stStrtEnd
    "Condition normal engine operation was attained"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE74

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stTranGlbJob
    "Current transition job"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE7E

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stTranGlbRun
    "Transition job is running"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE7D

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_stTranReq
    "Queue of transition request"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 4  
    ECU_ADDRESS 0x60034070

/end MEASUREMENT

/begin MEASUREMENT

    DSMAUX_tClntStrt
    "coolant temperature at start"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B81E

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_ctGlb
    "Global duration counters (32 bit values)"
    ULONG
    DFES_OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 4  
    ECU_ADDRESS 0x60037CAC

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_ctPID21h
    "counter for distance travelled while MIL is activated"
    ULONG
    DSMDUR_10m_Counter
    1
    100
    0.00
    42949672.9500

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0x60036E14

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_ctPID31h
    "counter for distance since diagnostic trouble codes cleared"
    ULONG
    DSMDUR_10m_Counter
    1
    100
    0.00
    42949672.9500

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0x60036E10

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_lRef
    "distance when the next DSMDur increment will be counted"
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BC4

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_lRef10m
    "distance where next 10m increment will be counted"
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BC0

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_stGlb
    "Global duration counter states"
    UBYTE
    DSMDur_StDispl_Verb
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    MATRIX_DIM 4  
    ECU_ADDRESS 0x60037CA8

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_stPID21h
    "state of the counter for distance travelled while MIL is activated"
    UBYTE
    DSMDur_StDispl_Verb
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x60037CA7

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_stWUCLst
    "warm up cycle reached"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60034074

/end MEASUREMENT

/begin MEASUREMENT

    DSMDur_tiRef
    "time when next DSMDur increment will be counted"
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BBC

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_stGrpRdy
    "Readiness calculation, ready status"
    UWORD
    DSMRdy_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037CCC

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_stGrpRdyDFES
    "Readiness calculation, ready status from DFES status"
    UWORD
    DSMRdy_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B824

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_stGrpRdyScan
    "Readiness calculation, ready status from check scanning"
    UWORD
    DSMRdy_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B826

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_stGrpSup
    "Readiness calculation, supported status"
    UWORD
    DSMRdy_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B822

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyMisf_mp
    "Reason (name of fault check) / DFC for group Misf not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C394

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyFlSys_mp
    "Reason (name of fault check) / DFC for group FlSys not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C396

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyComprCmpnt_mp
    "Reason (name of fault check) / DFC for group ComprCmpnt not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C398

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyHCCat_mp
    "Reason (name of fault check) / DFC for group HCCat not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C39A

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyNOxCat_mp
    "Reason (name of fault check) / DFC for group NOxCat not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C39C

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyResv_mp
    "Reason (name of fault check) / DFC for group Resv not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C39E

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyBP_mp
    "Reason (name of fault check) / DFC for group BP not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3A0

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyAC_mp
    "Reason (name of fault check) / DFC for group AC not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3A2

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyEGSens_mp
    "Reason (name of fault check) / DFC for group EGSens not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3A4

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyPMFlt_mp
    "Reason (name of fault check) / DFC for group PMFlt not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3A6

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.RdyEGR_mp
    "Reason (name of fault check) / DFC for group EGR not tested since clear"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3A8

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplMisf_mp
    "Reason (name of fault check) / DFC for group Misf not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3AA

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplFlSys_mp
    "Reason (name of fault check) / DFC for group FlSys not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3AC

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplComprCmpnt_mp
    "Reason (name of fault check) / DFC for group ComprCmpnt not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3AE

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplHCCat_mp
    "Reason (name of fault check) / DFC for group HCCat not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3B0

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplNOxCat_mp
    "Reason (name of fault check) / DFC for group NOxCat not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3B2

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplResv_mp
    "Reason (name of fault check) / DFC for group Resv not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3B4

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplBP_mp
    "Reason (name of fault check) / DFC for group BP not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3B6

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplAC_mp
    "Reason (name of fault check) / DFC for group AC not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3B8

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplEGSens_mp
    "Reason (name of fault check) / DFC for group EGSens not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3BA

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplPMFlt_mp
    "Reason (name of fault check) / DFC for group PMFlt not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3BC

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.CyclCmplEGR_mp
    "Reason (name of fault check) / DFC for group EGR not tested in this cycle"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3BE

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockMisf_mp
    "Reason (name of fault check) / Disabled DFC for group Misf"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3C0

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockFlSys_mp
    "Reason (name of fault check) / Disabled DFC for group FlSys"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3C2

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockComprCmpnt_mp
    "Reason (name of fault check) / Disabled DFC for group ComprCmpnt"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3C4

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockHCCat_mp
    "Reason (name of fault check) / Disabled DFC for group HCCat"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3C6

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockNOxCat_mp
    "Reason (name of fault check) / Disabled DFC for group NOxCat"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3C8

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockResv_mp
    "Reason (name of fault check) / Disabled DFC for group Resv"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3CA

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockBP_mp
    "Reason (name of fault check) / Disabled DFC for group BP"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3CC

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockAC_mp
    "Reason (name of fault check) / Disabled DFC for group AC"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3CE

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockEGSens_mp
    "Reason (name of fault check) / Disabled DFC for group EGSens"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3D0

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockPMFlt_mp
    "Reason (name of fault check) / Disabled DFC for group PMFlt"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3D2

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_Why.LockEGR_mp
    "Reason (name of fault check) / Disabled DFC for group EGR"
    UWORD
    DFCDSQ_Verb
    1
    100
    0.00
    65535.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C3D4

/end MEASUREMENT

/begin MEASUREMENT

    DSMRdy_xPId1
    "Readiness calculation, result for PID01"
    ULONG
    DSMRdy_OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003328

/end MEASUREMENT

/begin MEASUREMENT

    DSM_CoEngtiNormalOBD
    "DSM internal variable to store the copy of the Engine running time - for OBD requirement"
    ULONG
    Time_sec_q1_COMPU
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BA8

/end MEASUREMENT

/begin MEASUREMENT

    DSM_CoEOMstOpModeActTSync
    "DSM internal variable to store the copy of the Diesel Particulate Filter Active Regeneration Status."
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BA0

/end MEASUREMENT

/begin MEASUREMENT

    DSM_CoEOMstOpModePos
    "DSM internal variable to store the copy of the Bit mask of the possible operation modes for the DSM-Scheduler"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B81A

/end MEASUREMENT

/begin MEASUREMENT

    DSM_CoEOMstTransActv
    "DSM internal variable to store the copy of the Status if an operation mode change is active"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE72

/end MEASUREMENT

/begin MEASUREMENT

    DSM_DisblMode_mp
    "Actual disable mode to prevent error memory entries (provided by DSM configuration)"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x700301B6

/end MEASUREMENT

/begin MEASUREMENT

    DSM_ECUId_mp
    "ECU identifier (e.g. master/slave systems), provided by DSM configuration"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303D6

/end MEASUREMENT

/begin MEASUREMENT

    DSM_GlbDalTotDst
    "DSM internal variable to store the copy of the total distance since first start"
    SLONG
    Length
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60004BA4

/end MEASUREMENT

/begin MEASUREMENT

    DSM_nEng
    ""
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B81C

/end MEASUREMENT

/begin MEASUREMENT

    DSM_PDTCDisbl_mp
    "Disable state of permanent DTC storage, as long as the value is not zero no permanent DTC will be stored."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303D5

/end MEASUREMENT

/begin MEASUREMENT

    DSM_pEnv
    "DSM internal variable to store the copy of the Environment pressure"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B814

/end MEASUREMENT

/begin MEASUREMENT

    DSM_PthSetstOvrRunCoord
    "DSM internal variable to store the copy of the State of overrun detection of the overrun coordinator (0: no overrun; 1:overrun)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE71

/end MEASUREMENT

/begin MEASUREMENT

    DSM_rAPP
    "DSM internal variable to store the copy of the Standardized accelerator pedal position"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B818

/end MEASUREMENT

/begin MEASUREMENT

    DSM_stFadeOut
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B444

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSM_stMILReqd
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C722

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSM_stPostDrive
    "Status of DSM postdrive control"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE79

/end MEASUREMENT

/begin MEASUREMENT

    DSM_stProtdRamVld
    "DFES protected ram content is valid"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60034050

/end MEASUREMENT

/begin MEASUREMENT

    DSM_stReInit
    "Status of reinitialization in DSM after cancelled postdrive"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE7A

/end MEASUREMENT

/begin MEASUREMENT

    DSM_stStrEnd
    "DSM internal variable to store the copy of the engine start finished (provided by DSM configuration)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE73

/end MEASUREMENT

/begin MEASUREMENT

    DSM_stWiggle_mp
    "wiggle test requested by ext. tester (provided by DSM configuration)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303D4

/end MEASUREMENT

/begin MEASUREMENT

    DSM_tEngDS
    "DSM internal variable to store the copy of the Coolant temperature at engine output"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B810

/end MEASUREMENT

/begin MEASUREMENT

    DSM_tEnv
    "DSM internal variable to store the copy of the Temperature of environment air"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B812

/end MEASUREMENT

/begin MEASUREMENT

    DSM_TripChgAndClrFinshd
    "Message to indicate completion of clear triggered by DSM after initialization"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C818

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSM_TripChgFinshd
    "Trip change of DSM finished"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C817

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    DSM_vVeh
    "DSM internal variable to store the copy of the Vehicle speed"
    SWORD
    Vel
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B816

/end MEASUREMENT

/begin MEASUREMENT

    DSM_xTabVersion
    "DSM version indentification signature"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000C448

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_DSMInhibitAlways
    "Status signal quality / Status of signal quality DSQ_DSMInhibitAlways"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE81

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_ErrLmpActrMIL
    "Status signal quality / Status of signal quality DSQ_ErrLmpActrMIL"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE82

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_ErrLmpActrSVS
    "Status signal quality / Status of signal quality DSQ_ErrLmpActrSVS"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE83

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_StopLmp
    "Status signal quality / Status of signal quality DSQ_StopLmp"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE84

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_T15TurnOfDly
    "Status signal quality / Status of signal quality DSQ_T15TurnOfDly"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE85

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_st.DSQ_WrnLmp
    "Status signal quality / Status of signal quality DSQ_WrnLmp"
    UBYTE
    DFC_OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000CE86

/end MEASUREMENT

/begin MEASUREMENT

    DSQ_stClct_mp
    "Collected states of all signal qualities (set if signal quality > 0)"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x700301E8

/end MEASUREMENT

/begin MEASUREMENT

    DTR_valLoLim.DTR_Dummy
    "lower limits (Mode06) / lower limit of diagnostic test result DTR_Dummy"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037CC4

/end MEASUREMENT

/begin MEASUREMENT

    DTR_valTst.DTR_Dummy
    "last test value (Mode06) / last test result of DTR_Dummy"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037CC8

/end MEASUREMENT

/begin MEASUREMENT

    DTR_valUpLim.DTR_Dummy
    "upper limits (Mode06) / upper limit of diagnostic test result DTR_Dummy"
    UWORD
    DFC_OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60037CC6

/end MEASUREMENT

/begin MEASUREMENT

    EcuTemp_dataDigSens
    ""
    SLONG
    TempDiff_1Deg
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6000338C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Eep_ctAbsCallWrFkt
    "16-bit-counter which counts the function calls to Eep_Write and Eep_Init over all driving cycles"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60036E18

/end MEASUREMENT

/begin MEASUREMENT

    Eep_ctCallWrFkt
    "Counter which counts the function calls to Eep_Write and Eep_Init during one driving cycle"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6003681C

/end MEASUREMENT

/begin MEASUREMENT

    Eep_ctMaxCallWrFkt
    "Maximum value of Eep_ctCallWrFkt"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x60036E1A

/end MEASUREMENT

/begin MEASUREMENT

    Eep_EnvRamHist
    "History state ENVRAM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C999

/end MEASUREMENT

/begin MEASUREMENT

    Eep_EnvRamInvld
    "Invalidity state ENVRAM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C99A

/end MEASUREMENT

/begin MEASUREMENT

    Eep_PostdrvBlkIdx_s16
    "Block Index of currently stored block"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B5CE

/end MEASUREMENT

/begin MEASUREMENT

    Eep_stBlk
    "Status array with status of each EEP block"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    MATRIX_DIM 14  
    ECU_ADDRESS 0x6000B5D0

/end MEASUREMENT

/begin MEASUREMENT

    Eep_stMain
    "Main state of EEP"
    SLONG
    Eep_MainStates_Verb
    1
    100
    0.00
    14.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0x600033E4

/end MEASUREMENT

/begin MEASUREMENT

    Eep_stPostDrv
    "Status of EEP process in PostDrive / PreDrive"
    UBYTE
    Eep_PostDrvState_Verb
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6000C997

/end MEASUREMENT

/begin MEASUREMENT

    EngDa_tEng
    "Engine temperature"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B492

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EngDa_tFld
    "Engine temperature field"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6000B490

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EngDem_stErr
    "Engine speed in case of a system error of the engine"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7BC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvP_p
    "env. pressure, measured or modelled"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B48E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvP_p_f
    "Actual physical value"
    FLOAT32_IEEE
    RBPtCel_p_1p0_1
    1
    100
    -1.00000000E+037
    1.00000000E+037

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x6000339C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvT_t
    "Enviroment temperature signal (with replacement reaction in case of sensor error)"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B48C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvT_t_f
    "envt"
    FLOAT32_IEEE
    RBPtCel_t_1p0_3
    1
    100
    -1.00000000E+037
    1.00000000E+037

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x60003398

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvT_t_f_Sq
    ""
    UBYTE
    SigQly_COMPU_VERB
    1
    100
    0.00
    15.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0x6000C713

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvT_t_Sq
    ""
    UBYTE
    SigQly_COMPU_VERB
    1
    100
    0.00
    15.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0x6000C714

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EnvT_uRaw
    "Sensor signal raw voltage"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0x6000B48A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    EpmCrS_tiIncPer
    "current tooth-time on crankshaft"
    SLONG
    GptaClc6_ti_COMPU
    1
    100
    -858993459.200
    858993458.800

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x600033C0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEng
    "Average engine speed of one cylinder segment"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B488

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Epm_nEngLRes
    "engine speed with low resolution"
    UBYTE
    EngN_LRes
    1
    100
    0.00
    10200.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0x6000C7BB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Epm_numCyl
    "Real number of cylinder"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7BA

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Epm_stSpd
    "Selection of engine speed"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B9

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Epm_tiSpd2Zero
    "Timeout timer until engine speed will set to zero"
    UWORD
    Time_ms
    1
    100
    0.00
    655350.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0x6000B38E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stExtReqRdy
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037D9A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMIL
    "MIL status indicator"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMILDigOut
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B7

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMILDigOut_mp
    "Measuring point for output value for mil-test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303D3

/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMILReq
    "MIL request status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B6

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMilReqBlink
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037D9D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMilReqContns
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037D9E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMilReqOnDem
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037D9B

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMilReqSho
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037D9C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stMIL_b6
    "MIL status indicator bit6"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B5

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stOrdGlwLmp
    "Status of order to glowlamp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B4

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stSVS
    "SVS Lamp status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B3

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stSVSDigOut
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stSVSDigOut_mp
    "Measuring point for output value for svs-test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x700303D2

/end MEASUREMENT

/begin MEASUREMENT

    ErrLmp_stSVSReq
    "SVS request status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B1

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ESC_stStackErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C6DB

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Etc_ctCurRunTst
    "Stores the number of actual running engine tests"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7B0

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ExhMod_pRelPfilDs
    "Modelled relative pressure downstream of particulate filter"
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B486

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    ExhMod_pRelPfilDs_f
    "Modelled relative pressure downstream of particulate filter"
    FLOAT32_IEEE
    RBPtCel_p_1p0_1
    1
    100
    -1.00000000E+037
    1.00000000E+037

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0x60003394

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Exh_tFld
    "message array for exhaust gas temperature sensor"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    MATRIX_DIM 1  
    ECU_ADDRESS 0x6000B484

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    FanCtl_stHotLmp
    "FanCtl_Spd"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7AF

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    FanCtl_stOk
    "Status defect-free control of KMTR"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    BIT_MASK 0x1
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C721

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Fan_r1Ps
    ""
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B482

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Fan_r2Ps
    ""
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B480

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    Fan_rPs
    "PWM output ratio for fan actuator 1"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B47E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    FlSys_volFlConsDspl
    "display of the total fuel consumption [ul]"
    SLONG
    FlConsum_ul
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003388

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    GEVCtl_flgReqRefAdpnIntk
    "Request of condition: edge adaption camshaft intake"
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x700000D2

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    GlbDa_lTotDst
    "total distance since first start"
    SLONG
    Length
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003384

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    GlbSrvGovrOutpRamp_I.FirstIniFlag
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x1
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x70002AC0

/end MEASUREMENT

/begin MEASUREMENT

    HLSDem_nMaxDspl
    "Maximum engine speed limit for display"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B47C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    HLSDem_nSetPLo
    "Effective steady-state idle speed"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B47A

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    HLSDem_stNMaxWarnDspl
    "Status active engine speed limitation warning for display"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7AE

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    I15031_FILLSIG1
    "Fillsignal for not supported signals with the size of 1 Byte"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7AD

/end MEASUREMENT

/begin MEASUREMENT

    I15031_FILLSIG2
    "Fillsignal for not supported signals with the size of 2 Bytes"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6000B440

/end MEASUREMENT

/begin MEASUREMENT

    I15031_FILLSIG4
    "Fillsignal for not supported signals with the size of 4 Bytes"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x60003374

/end MEASUREMENT

/begin MEASUREMENT

    I15031_ITIDSuppSrv9
    "To store support infotype bits in mode9"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000B2C4

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID13
    "Location of oxigen sensor"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7AC

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID1C
    "OBD requirements to which vehicle is designed"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7AB

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID1D
    "Location of oxygen sensors"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7AA

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID4FA
    "External Test Equipment Configuration Information. Maximum value for Equivalence Ratio."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A9

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID4FB
    "External Test Equipment Configuration Information. Maximum value for Oxygen Sensor Voltage."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A8

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID4FC
    "External Test Equipment Configuration Information. Maximum value for Oxygen Sensor Current."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A7

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID4FD
    "External Test Equipment Configuration Information. Maximum value for Intake Manifold Absolute Pressure."
    UBYTE
    OneToTenCarb
    1
    100
    0.00
    2550.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0x6000C7A6

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID50A
    "External Test Equipment Configuration Information. Maximum value for Air Flow Rate from Mass Air Flow Sensor"
    UBYTE
    OneToTenCarb
    1
    100
    0.00
    2550.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0x6000C7A5

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID50B
    "External Test Equipment Configuration Information. Demanded manifold Pressure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A4

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID50C
    "External Test Equipment Configuration Information. Engine Oil Level"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A3

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID50D
    "External Test Equipment Configuration Information. Fuel Rail pressure control"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A2

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID5F
    "Emission requirements to which vehicle is designed"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A1

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID65A
    "Shows which Auxiliary Inputs / Outputs are supported in PID65"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C7A0

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID66A
    "Shows which Mass Air Flow Sensor data are supported in PID66"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C79F

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID67A
    "Shows which Engine Coolant Temperature data are supported in PID67"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C79E

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID68A
    "Shows which Intake Air Temperature Sensor data are supported in PID68"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C79D

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID69A
    "Shows which Commanded EGR System data are supported in PID69"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C79C

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6AA
    "Shows which Commanded Diesel Intake Air Flow Control and Relative Intake Air Flow Position data are supported in PID6A"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C79B

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6BA
    "Shows which Exhaust Gas Recirculation Temperature data are supported in PID6B"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C79A

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6CA
    "Shows which Commanded Throttle Actuator Control and Relative Throttle Position data are supported in PID6C"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C799

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6DA
    "Shows which Fuel Pressure Control System data are supported in PID6D"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C798

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6EA
    "Shows which Injection Pressure Control System data are supported in PID6E"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C797

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID6FA
    "Shows which Turbocharger Compressor Inlet Pressure data are supported in PID6F"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C796

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID70A
    "Shows which Boost Pressure Control data are supported in PID70"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C795

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID71A
    "Shows which Variable Geometry Turbo (VGT) Control data are supported in PID71"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C794

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID72A
    "Shows which Wastegate Control data are supported in PID72"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C793

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID73A
    "Shows which Exhaust Pressure data are supported in PID73"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C792

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID74A
    "Shows which Turbocharger RPM data are supported in PID74"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C791

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID75A
    "Shows which Turbocharger A Temperature data are supported in PID75"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C790

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID76A
    "Shows which Turbocharger B Temperature data are supported in PID76"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78F

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID77A
    "Shows which Charge Air Cooler Temperature (CACT) data are supported in PID77"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78E

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID78A
    "Shows which Exhaust Gas Temperature (EGT) Bank 1 data are supported in PID78"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78D

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID79A
    "Shows which Exhaust Gas Temperature (EGT) Bank 2 data are supported in PID79"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78C

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID7AA
    "Shows which Particulate Filter (PF) Bank 1 data are supported in PID7A"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78B

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID7BA
    "Shows which Particulate Filter (PF) Bank 2 data are supported in PID7B"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C78A

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID7CA
    "Shows which Particulate Filter (PF) Temperature data are supported in PID7C"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C789

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID7FA
    "Shows which Engine Run Time is supported in PID7F"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C788

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID81A
    "Shows which Engine Run Time for AECD #1 - #5 is supported in PID81"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C787

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID82A
    "Shows which Engine Run Time for AECD #6 - #10 is supported in PID82"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C786

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID83A
    "Shows which NOx Sensor data are supported in PID83"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C785

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID85A
    "Shows which NOx Control System data are supported in PID85"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C784

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID86A
    "Shows which Particulate Matter (PM) Sensor data are supported in PID86"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C783

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID87A
    "Shows which Intake Manifold Absolute Pressure data are supported in PID87"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C782

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID89A
    "Shows which Engine Run Time for AECD #11 - #15 is supported in PID89"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C781

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID8AA
    "Shows which Engine Run Time for AECD #16 - #20 is supported in PID8A"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C780

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID8BA
    "Shows which Aftertreatment Status is supported in PID8B ByteB."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77F

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID8CA
    "Calibration for O2 Sensor Data support information(Sensor 1, Sensor 2)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77E

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID8FA
    "Shows which PM (Particulate Matter) Sensor Output is supported in PID8F"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77D

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID92A
    "Fuel System Status support information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77C

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID93A
    "WWH B1 counter support information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77B

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID94A
    "Inducement Counters support information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C77A

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID97A
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C779

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID98A
    "Exhaust Gas Temperature Sensor Data support information(Bank 1)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C778

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID99A
    "Exhaust Gas Temperature Sensor Data support information"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C777

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID9AA
    "Shows if HybridEV Vehicle State is supported in PID9A"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C776

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID9BA
    "Diesel exhaust fluid sensor output"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C775

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID9CA
    "O2 Sensor Data support information(Sensor 3, Sensor 4)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C774

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PID9FA
    "Fuel system percentage use"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C773

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA1A
    "Displays the NOx Sensor Corrected Data supported in PIDA1"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C772

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA3A
    "Evap System Vapor Pressure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C771

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA4A
    "Transmission Actual Gear"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C770

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA5A
    "message to update byte A ini PIDA5 for Diesel Exhaust Fluid Dosing"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76F

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA7A
    "Support of NOx Sensor Data"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76E

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA8A
    "NOx Sensor Corrected"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76D

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDA9A
    "Motorcycle InputOutput Status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76C

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDACA
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76B

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDSuppSrv1
    "PIDs supported in Service 1 are indicated in 32 bit measurement array"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000B2A4

/end MEASUREMENT

/begin MEASUREMENT

    I15031_PIDSuppSrv2
    "PIDs supported in Service 2 are indicated in 32 bit measurement array"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000B284

/end MEASUREMENT

/begin MEASUREMENT

    I15031_Srv12_Ext_DisablPIDSupp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 8  
    ECU_ADDRESS 0x6000B264

/end MEASUREMENT

/begin MEASUREMENT

    i15031_srv9_CVN_Calc_ui
    "State of CVN calculation"
    UBYTE
    I15031_srv9_CVN_CalcVerb
    1
    100
    0.00
    6.

    
    FORMAT "%2.0"
    
    ECU_ADDRESS 0x6000C73B

/end MEASUREMENT

/begin MEASUREMENT

    I15031_srv9_stCVNRecalc
    "Recalculation of CVN"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C769

/end MEASUREMENT

/begin MEASUREMENT

    I15031_srv9_ValidCVN
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C76A

/end MEASUREMENT

/begin MEASUREMENT

    i15031_srv9_vt_ASWFrzStatus
    "Storage of freeze status in envram"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x60037DFC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    I15301_srv9_vt_stStorgFlsgPers_msg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C819

/end MEASUREMENT

/begin MEASUREMENT

    InjCtl_qSetUnBal
    "current injection quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0x6000B478

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 3 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    LLim_stMaxActvLvlECU
    "demand from Lvl ECU for speed limiting"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6000C768

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_bPFCNew
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x2
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001C9D8

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_bSwShrNew
    ""
    UBYTE
    B_TRUE
    1
    100
    0.00
    1.00000000000

    BIT_MASK 0x10
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001C9D8

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_cntrInCorrRespTime
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBA8

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_cntrSyncMonModl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBA7

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_cntrWDAErrThd
    ""
    UBYTE
    OneToOne
    1
    100
    3.000
    4.000

    
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x6001CB96

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_cntrWDAErrThdCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBA6

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_cntrWDAErrThdMsg
    ""
    UBYTE
    dez
    1
    100
    3.000
    4.000

    
    FORMAT "%5.3"
    
    ECU_ADDRESS 0x70002AE6

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctBusErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBA5

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctBusErrCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBA4

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrFC
    "error counter for failure in function controller"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB95

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrFCCpl
    "RAM data redundancy for MoCCom_ctErrFC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBA3

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrMM
    "error counter of monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB94

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrMMMsg
    "info for level 1: error counter of monitoring module"
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x70002AE5

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrMMOld
    "old value of the error count got from the monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBA2

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrOSTimeout
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBA1

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_Query
    "Enlarged query from monitoring module"
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB8C

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_Response
    "Response to the query from monitoring module"
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB90

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_Response_mp
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70030130

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stBusErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CBA0

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stCheckState
    ""
    UBYTE
    MoCCom_stCheckState_Compu
    1
    100
    0.00
    7.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CB9F

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stCheckStateCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB9E

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stComActvOld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB9D

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stComActvOldCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB9C

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stComState
    ""
    UBYTE
    MoCCom_stComState_Compu
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0x6001CB9B

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stErrEna
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB9A

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stErrEnaCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB99

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stQueryNew
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001C9D8

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stWdgThdErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB98

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stWdgTiWinErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB97

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_SwShrPtlResp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB88

/end MEASUREMENT

/begin MEASUREMENT

    MoCCPU_PartResp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB84

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_idxNumCurrErr
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0x6001C9D6

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmAlrms
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 22  
    ECU_ADDRESS 0x6001CD40

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmAlrmsCpl
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 22  
    ECU_ADDRESS 0x6001CB28

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmAlrmsMsg
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 22  
    ECU_ADDRESS 0x70002AEC

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmAlrmsNv
    ""
    ULONG
    dez
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 22  
    ECU_ADDRESS 0x60037DA4

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmErrorPin
    ""
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD98

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmErrorPinCpl
    ""
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB83

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stEmmGPIO
    ""
    UBYTE
    dez
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB82

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stPwrOnRstHdl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD9A

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stPwrOnRstHdlCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB81

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stPwrOnRstReq
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD99

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stPwrOnRstReqCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB80

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structCurrReq.MoCEMM_cntrInfo
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002C10

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structCurrReq.MoCEMM_blkInfo
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 17  
    ECU_ADDRESS 0x70002C14

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structCurrReq.MoCEMM_cntrInfoCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002CB8

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structFlash.MoCEMM_cntrInfo
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002B64

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structFlash.MoCEMM_blkInfo
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 41  
    ECU_ADDRESS 0x70002B68

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_structFlash.MoCEMM_cntrInfoCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70002C0C

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stSWErrorPinReqAry
    ""
    ULONG
    MoExe_Co_PFC_ID_Compu
    1
    100
    0.00
    16777471.0000

    
    FORMAT "%13.4"
    MATRIX_DIM 10  
    ECU_ADDRESS 0x70039BD4

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_stSWErrorPinReqAryCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    MATRIX_DIM 10  
    ECU_ADDRESS 0x70039BAC

/end MEASUREMENT

/begin MEASUREMENT

    MoCEMM_wdgTout
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x70039BA8

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_aryCMPErrBit
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 4  
    ECU_ADDRESS 0x6001CD39

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_aryCMPErrBitCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    MATRIX_DIM 4  
    ECU_ADDRESS 0x6001CB23

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_bbOut1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD2C

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_bbOut1Cpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB22

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cmpErrAryIdx
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD38

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cmpErrAryIdxCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB21

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrBadcase
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CD28

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrCMPErrbit
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CD24

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrCMPErrbitCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB18

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrCMPErrbitHeal
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD37

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrCMPErrbitHealCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB20

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrDebErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD36

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrDebErrCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB1F

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrDebErrMax
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB1E

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS1
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CD20

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS1Old
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CD1C

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS1OldCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB14

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS2
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CD18

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS2Old
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CD14

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMCS2OldCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB10

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrMsmCMPErrBit
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD35

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrRouteSigErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD34

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_cntrRouteSigErrCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CB1D

    /begin IF_DATA ETK_XETK DEFAULT_RASTERS 2 /end IF_DATA
    /begin IF_DATA XCPplus 0x0102 /begin DAQ_EVENT VARIABLE /end DAQ_EVENT /end IF_DATA
/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_currChksVal
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CD10

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_currChksValCpl
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0x6001CB0C

/end MEASUREMENT

/begin MEASUREMENT

    MoCGTM_currMCSModlAryIdx
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0x6001CD33

/end MEASUREMENT

