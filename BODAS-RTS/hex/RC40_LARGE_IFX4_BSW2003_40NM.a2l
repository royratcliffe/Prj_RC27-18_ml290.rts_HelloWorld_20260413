    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x808036A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x808036AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x808036AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_LIN_E_TIMEOUT_C
    "disable mask / Disable masks of check DFC_LIN_E_TIMEOUT"
    VALUE
    0x808036AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_MultiStackTrace_Threshold_C
    "disable mask / Disable masks of check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x808036AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_ETH_E_ACCESS_0_C
    "disable mask / Disable masks of check DFC_ETH_E_ACCESS_0"
    VALUE
    0x808036AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "disable mask / Disable masks of check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x808036AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "disable mask / Disable masks of check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x808036B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_MRly_Diag_Stk_Event_C
    "disable mask / Disable masks of check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x808036B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "disable mask / Disable masks of check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x808036B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_MemDiag_MemReadErr_C
    "disable mask / Disable masks of check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x808036B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_MemDiag_MemWrErr_C
    "disable mask / Disable masks of check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x808036B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "disable mask / Disable masks of check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x808036B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_T15_Diag_ComInVld_Event_C
    "disable mask / Disable masks of check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x808036B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "disable mask / Disable masks of check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x808036B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "disable mask / Disable masks of check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x808036B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x808036B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x808036BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_10_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x808036BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x808036BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x808036BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x808036BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x808036BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_22_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x808036C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_23_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x808036C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x808036C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x808036C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_7_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x808036C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM0_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x808036C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM10_16_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x808036C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM10_17_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x808036C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM10_21_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x808036C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x808036C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x808036CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x808036CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_3_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x808036CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x808036CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x808036CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x808036CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM11_9_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x808036D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x808036D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x808036D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_10_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x808036D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x808036D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x808036D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x808036D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x808036D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_22_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x808036D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_23_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x808036D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x808036DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x808036DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_7_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x808036DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM1_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x808036DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM21_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x808036DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM21_16_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x808036DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM21_3_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x808036E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x808036E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_10_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x808036E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x808036E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x808036E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x808036E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x808036E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_22_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x808036E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_23_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x808036E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x808036E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x808036EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_7_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x808036EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM2_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x808036EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x808036ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_10_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x808036EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x808036EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x808036F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x808036F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x808036F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_22_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x808036F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_23_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x808036F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x808036F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x808036F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_7_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x808036F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM3_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x808036F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x808036F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x808036FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_12_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x808036FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x808036FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_15_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x808036FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_17_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x808036FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_18_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x808036FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80803700
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_20_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80803701
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_21_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80803702
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_25_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80803703
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80803704
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_5_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80803705
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_7_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80803706
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM6_8_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80803707
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80803708
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_12_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80803709
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x8080370A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_14_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x8080370B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_15_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x8080370C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_16_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x8080370D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_17_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x8080370E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x8080370F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_20_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80803710
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_25_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80803711
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_26_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80803712
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_28_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80803713
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_29_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80803714
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_30_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80803715
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM7_31_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80803716
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80803717
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80803718
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_10_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80803719
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_11_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x8080371A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_12_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x8080371B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_13_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x8080371C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_16_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x8080371D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_18_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x8080371E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_2_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x8080371F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_3_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80803720
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_30_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80803721
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_31_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80803722
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM8_4_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80803723
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM9_0_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80803724
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM9_1_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80803725
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM9_15_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80803726
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MOXEMM_SMU_ALM9_3_C
    "disable mask / Disable masks of check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80803727
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoCSOPICO_C
    "disable mask / Disable masks of check DFC_MoCSOPICO"
    VALUE
    0x80803728
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoFVarPostBldSel_C
    "disable mask / Disable masks of check DFC_MoFVarPostBldSel"
    VALUE
    0x80803729
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoSysCtrlReIni_C
    "disable mask / Disable masks of check DFC_MoSysCtrlReIni"
    VALUE
    0x8080372A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTMCUFW_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x8080372B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTMonBIST_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x8080372C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTRegMonTest_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x8080372D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x8080372E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTTempSens_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x8080372F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_MoXEMMHwLTUCBCfg_C
    "disable mask / Disable masks of check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80803730
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_OCWDAABEActv_C
    "disable mask / Disable masks of check DFC_OCWDAABEActv"
    VALUE
    0x80803731
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_OCWDACom_C
    "disable mask / Disable masks of check DFC_OCWDACom"
    VALUE
    0x80803732
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_OCWDAErrPin_C
    "disable mask / Disable masks of check DFC_OCWDAErrPin"
    VALUE
    0x80803733
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_SWReset_0_C
    "disable mask / Disable masks of check DFC_SWReset_0"
    VALUE
    0x80803734
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_SWReset_1_C
    "disable mask / Disable masks of check DFC_SWReset_1"
    VALUE
    0x80803735
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_SWReset_2_C
    "disable mask / Disable masks of check DFC_SWReset_2"
    VALUE
    0x80803736
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_Unused_C
    "AUTOSAR: Functional unit of DTC / Check DFC_Unused"
    VALUE
    0x80808534
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80c7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80808535
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80c8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80c8"
    VALUE
    0x80808536
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80c9_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80c9"
    VALUE
    0x80808537
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ca_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ca"
    VALUE
    0x80808538
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80cb_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80cb"
    VALUE
    0x80808539
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80cc_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80cc"
    VALUE
    0x8080853A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80cd_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80cd"
    VALUE
    0x8080853B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ce_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ce"
    VALUE
    0x8080853C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80cf_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80cf"
    VALUE
    0x8080853D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80d0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80d0"
    VALUE
    0x8080853E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80d1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80d1"
    VALUE
    0x8080853F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80d2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80808540
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80d3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80808541
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80d4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80808542
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80d5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80808543
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80d6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80808544
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80d7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80d7"
    VALUE
    0x80808545
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80d8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80d8"
    VALUE
    0x80808546
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80d9_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80d9"
    VALUE
    0x80808547
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80da_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80da"
    VALUE
    0x80808548
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80db_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80db"
    VALUE
    0x80808549
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80dc_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80dc"
    VALUE
    0x8080854A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80dd_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80dd"
    VALUE
    0x8080854B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80de_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80de"
    VALUE
    0x8080854C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80df_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80df"
    VALUE
    0x8080854D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80e0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80e0"
    VALUE
    0x8080854E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80e1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80e1"
    VALUE
    0x8080854F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80e2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80808550
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80e3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80808551
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80e4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80808552
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80e5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80808553
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80e6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80808554
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80e7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80e7"
    VALUE
    0x80808555
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80e8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80e8"
    VALUE
    0x80808556
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80e9_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80e9"
    VALUE
    0x80808557
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ea_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ea"
    VALUE
    0x80808558
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80eb_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80eb"
    VALUE
    0x80808559
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ec_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ec"
    VALUE
    0x8080855A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ed_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ed"
    VALUE
    0x8080855B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ee_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ee"
    VALUE
    0x8080855C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ef_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ef"
    VALUE
    0x8080855D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80f0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80f0"
    VALUE
    0x8080855E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80f1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80f1"
    VALUE
    0x8080855F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80f2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80808560
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80f3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80808561
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80f4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80808562
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80f5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80808563
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80f6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80f6"
    VALUE
    0x80808564
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80f7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80f7"
    VALUE
    0x80808565
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80f8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80f8"
    VALUE
    0x80808566
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80f9_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80f9"
    VALUE
    0x80808567
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80fa_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80fa"
    VALUE
    0x80808568
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80fb_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80fb"
    VALUE
    0x80808569
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80fc_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80fc"
    VALUE
    0x8080856A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80fd_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80fd"
    VALUE
    0x8080856B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80fe_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80fe"
    VALUE
    0x8080856C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ff_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ff"
    VALUE
    0x8080856D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8100_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8100"
    VALUE
    0x8080856E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8101_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8101"
    VALUE
    0x8080856F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8102_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8102"
    VALUE
    0x80808570
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8103_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8103"
    VALUE
    0x80808571
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8104_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8104"
    VALUE
    0x80808572
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8105_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8105"
    VALUE
    0x80808573
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8106_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8106"
    VALUE
    0x80808574
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8107_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8107"
    VALUE
    0x80808575
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8108_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8108"
    VALUE
    0x80808576
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8109_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8109"
    VALUE
    0x80808577
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x810a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x810a"
    VALUE
    0x80808578
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x810b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x810b"
    VALUE
    0x80808579
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x810c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x810c"
    VALUE
    0x8080857A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x810d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x810d"
    VALUE
    0x8080857B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x810e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x810e"
    VALUE
    0x8080857C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x810f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x810f"
    VALUE
    0x8080857D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8110_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8110"
    VALUE
    0x8080857E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8111_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8111"
    VALUE
    0x8080857F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8112_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8112"
    VALUE
    0x80808580
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8113_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8113"
    VALUE
    0x80808581
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8114_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8114"
    VALUE
    0x80808582
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8115_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8115"
    VALUE
    0x80808583
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8116_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8116"
    VALUE
    0x80808584
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8117_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8117"
    VALUE
    0x80808585
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8118_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8118"
    VALUE
    0x80808586
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8119_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8119"
    VALUE
    0x80808587
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x811a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x811a"
    VALUE
    0x80808588
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x811b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x811b"
    VALUE
    0x80808589
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x811c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x811c"
    VALUE
    0x8080858A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x811d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x811d"
    VALUE
    0x8080858B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x811e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x811e"
    VALUE
    0x8080858C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x811f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x811f"
    VALUE
    0x8080858D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8120_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8120"
    VALUE
    0x8080858E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8121_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8121"
    VALUE
    0x8080858F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8122_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8122"
    VALUE
    0x80808590
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8123_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8123"
    VALUE
    0x80808591
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8124_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8124"
    VALUE
    0x80808592
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8125_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8125"
    VALUE
    0x80808593
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8126_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8126"
    VALUE
    0x80808594
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8127_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8127"
    VALUE
    0x80808595
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8128_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8128"
    VALUE
    0x80808596
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8129_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8129"
    VALUE
    0x80808597
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x812a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x812a"
    VALUE
    0x80808598
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_TiInRow0x8B01_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_TiInRow0x8B01"
    VALUE
    0x80808599
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_TiInRow0x8B02_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_TiInRow0x8B02"
    VALUE
    0x8080859A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_TiInRow0x8B03_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_TiInRow0x8B03"
    VALUE
    0x8080859B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_DevLibBattUHi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_DevLibBattUHi"
    VALUE
    0x8080859C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_DevLibBattULo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_DevLibBattULo"
    VALUE
    0x8080859D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8063_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8063"
    VALUE
    0x8080859E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8064_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8064"
    VALUE
    0x8080859F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8065_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8065"
    VALUE
    0x808085A0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8066_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8066"
    VALUE
    0x808085A1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8067_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8067"
    VALUE
    0x808085A2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8068_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8068"
    VALUE
    0x808085A3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8069_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8069"
    VALUE
    0x808085A4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x806a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x806a"
    VALUE
    0x808085A5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x806b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x806b"
    VALUE
    0x808085A6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x806c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x806c"
    VALUE
    0x808085A7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x806d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x806d"
    VALUE
    0x808085A8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x806e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x806e"
    VALUE
    0x808085A9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x806f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x806f"
    VALUE
    0x808085AA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8070_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8070"
    VALUE
    0x808085AB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8071_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8071"
    VALUE
    0x808085AC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8072_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8072"
    VALUE
    0x808085AD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8073_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8073"
    VALUE
    0x808085AE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8074_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8074"
    VALUE
    0x808085AF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8075_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8075"
    VALUE
    0x808085B0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8076_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8076"
    VALUE
    0x808085B1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8077_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8077"
    VALUE
    0x808085B2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8078_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8078"
    VALUE
    0x808085B3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8079_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8079"
    VALUE
    0x808085B4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x807a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x807a"
    VALUE
    0x808085B5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x807b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x807b"
    VALUE
    0x808085B6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x807c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x807c"
    VALUE
    0x808085B7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x807d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x807d"
    VALUE
    0x808085B8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x807e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x807e"
    VALUE
    0x808085B9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x807f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x807f"
    VALUE
    0x808085BA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8080_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8080"
    VALUE
    0x808085BB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8081_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8081"
    VALUE
    0x808085BC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8082_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8082"
    VALUE
    0x808085BD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8083_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8083"
    VALUE
    0x808085BE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8084_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8084"
    VALUE
    0x808085BF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8085_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8085"
    VALUE
    0x808085C0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8086_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8086"
    VALUE
    0x808085C1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8087_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8087"
    VALUE
    0x808085C2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8088_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8088"
    VALUE
    0x808085C3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8089_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8089"
    VALUE
    0x808085C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x808a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x808a"
    VALUE
    0x808085C5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x808b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x808b"
    VALUE
    0x808085C6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x808c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x808c"
    VALUE
    0x808085C7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x808d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x808d"
    VALUE
    0x808085C8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x808e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x808e"
    VALUE
    0x808085C9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x808f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x808f"
    VALUE
    0x808085CA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8090_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8090"
    VALUE
    0x808085CB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8091_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8091"
    VALUE
    0x808085CC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8092_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8092"
    VALUE
    0x808085CD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8093_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8093"
    VALUE
    0x808085CE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8094_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8094"
    VALUE
    0x808085CF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8095_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8095"
    VALUE
    0x808085D0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8096_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8096"
    VALUE
    0x808085D1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8097_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8097"
    VALUE
    0x808085D2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8098_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8098"
    VALUE
    0x808085D3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8099_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8099"
    VALUE
    0x808085D4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x809a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x809a"
    VALUE
    0x808085D5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x809b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x809b"
    VALUE
    0x808085D6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x809c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x809c"
    VALUE
    0x808085D7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x809d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x809d"
    VALUE
    0x808085D8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x809e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x809e"
    VALUE
    0x808085D9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x809f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x809f"
    VALUE
    0x808085DA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80a0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80a0"
    VALUE
    0x808085DB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80a1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80a1"
    VALUE
    0x808085DC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80a2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80a2"
    VALUE
    0x808085DD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80a3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80a3"
    VALUE
    0x808085DE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80a4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80a4"
    VALUE
    0x808085DF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80a5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80a5"
    VALUE
    0x808085E0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80a6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80a6"
    VALUE
    0x808085E1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80a7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80a7"
    VALUE
    0x808085E2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80a8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80a8"
    VALUE
    0x808085E3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80a9_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80a9"
    VALUE
    0x808085E4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80aa_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80aa"
    VALUE
    0x808085E5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ab_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ab"
    VALUE
    0x808085E6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ac_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ac"
    VALUE
    0x808085E7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ad_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ad"
    VALUE
    0x808085E8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ae_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ae"
    VALUE
    0x808085E9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80af_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80af"
    VALUE
    0x808085EA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80b0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80b0"
    VALUE
    0x808085EB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80b1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80b1"
    VALUE
    0x808085EC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80b2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80b2"
    VALUE
    0x808085ED
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80b3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80b3"
    VALUE
    0x808085EE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80b4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80b4"
    VALUE
    0x808085EF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80b5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80b5"
    VALUE
    0x808085F0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80b6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80b6"
    VALUE
    0x808085F1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80b7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80b7"
    VALUE
    0x808085F2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80b8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80b8"
    VALUE
    0x808085F3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80b9_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80b9"
    VALUE
    0x808085F4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80ba_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80ba"
    VALUE
    0x808085F5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80bb_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80bb"
    VALUE
    0x808085F6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80bc_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80bc"
    VALUE
    0x808085F7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80bd_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80bd"
    VALUE
    0x808085F8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80be_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80be"
    VALUE
    0x808085F9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80bf_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80bf"
    VALUE
    0x808085FA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80c0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80c0"
    VALUE
    0x808085FB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80c1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80c1"
    VALUE
    0x808085FC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80c2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80c2"
    VALUE
    0x808085FD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80c3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80c3"
    VALUE
    0x808085FE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80c4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80c4"
    VALUE
    0x808085FF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80c5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80c5"
    VALUE
    0x80808600
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x80c6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x80c6"
    VALUE
    0x80808601
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_TiUpDwn0x8A01_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x80808602
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_TiUpDwn0x8A02_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x80808603
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_TiUpDwn0x8A03_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x80808604
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA13OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA13OR"
    VALUE
    0x80808605
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA13SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA13SCB"
    VALUE
    0x80808606
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA13SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA13SCG"
    VALUE
    0x80808607
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA14OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA14OR"
    VALUE
    0x80808608
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA14SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA14SCB"
    VALUE
    0x80808609
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA14SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA14SCG"
    VALUE
    0x8080860A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA21OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA21OR"
    VALUE
    0x8080860B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA21SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA21SCB"
    VALUE
    0x8080860C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA21SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA21SCG"
    VALUE
    0x8080860D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA22OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA22OR"
    VALUE
    0x8080860E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA22SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA22SCB"
    VALUE
    0x8080860F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA22SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA22SCG"
    VALUE
    0x80808610
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA23OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA23OR"
    VALUE
    0x80808611
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA23SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA23SCB"
    VALUE
    0x80808612
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA23SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA23SCG"
    VALUE
    0x80808613
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA24OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA24OR"
    VALUE
    0x80808614
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA24SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA24SCB"
    VALUE
    0x80808615
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA24SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA24SCG"
    VALUE
    0x80808616
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA25OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA25OR"
    VALUE
    0x80808617
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA25SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA25SCB"
    VALUE
    0x80808618
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA25SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA25SCG"
    VALUE
    0x80808619
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA26OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA26OR"
    VALUE
    0x8080861A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA26SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA26SCB"
    VALUE
    0x8080861B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA26SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA26SCG"
    VALUE
    0x8080861C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA27OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA27OR"
    VALUE
    0x8080861D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA27SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA27SCB"
    VALUE
    0x8080861E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA27SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA27SCG"
    VALUE
    0x8080861F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA28OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA28OR"
    VALUE
    0x80808620
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA28SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA28SCB"
    VALUE
    0x80808621
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA28SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA28SCG"
    VALUE
    0x80808622
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA29OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA29OR"
    VALUE
    0x80808623
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA29SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA29SCB"
    VALUE
    0x80808624
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA29SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA29SCG"
    VALUE
    0x80808625
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36AicSCB"
    VALUE
    0x80808626
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36AicSCG"
    VALUE
    0x80808627
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36OR"
    VALUE
    0x80808628
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36SCB"
    VALUE
    0x80808629
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36SCG"
    VALUE
    0x8080862A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA36ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x8080862B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37AicSCB"
    VALUE
    0x8080862C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37AicSCG"
    VALUE
    0x8080862D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37OR"
    VALUE
    0x8080862E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37SCB"
    VALUE
    0x8080862F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37SCG"
    VALUE
    0x80808630
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA37ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80808631
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38AicSCB"
    VALUE
    0x80808632
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38AicSCG"
    VALUE
    0x80808633
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38OR"
    VALUE
    0x80808634
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38SCB"
    VALUE
    0x80808635
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38SCG"
    VALUE
    0x80808636
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA38ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80808637
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39AicSCB"
    VALUE
    0x80808638
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39AicSCG"
    VALUE
    0x80808639
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39OR"
    VALUE
    0x8080863A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39SCB"
    VALUE
    0x8080863B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39SCG"
    VALUE
    0x8080863C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA39ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x8080863D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA40OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA40OR"
    VALUE
    0x8080863E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA40SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA40SCB"
    VALUE
    0x8080863F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA40SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA40SCG"
    VALUE
    0x80808640
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA41OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA41OR"
    VALUE
    0x80808641
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA41SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA41SCB"
    VALUE
    0x80808642
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA41SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA41SCG"
    VALUE
    0x80808643
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA42OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA42OR"
    VALUE
    0x80808644
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA42SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA42SCB"
    VALUE
    0x80808645
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA42SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA42SCG"
    VALUE
    0x80808646
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43AicSCB"
    VALUE
    0x80808647
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43AicSCG"
    VALUE
    0x80808648
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43OR"
    VALUE
    0x80808649
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43SCB"
    VALUE
    0x8080864A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43SCG"
    VALUE
    0x8080864B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA43ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x8080864C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA44OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA44OL"
    VALUE
    0x8080864D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA44SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA44SCB"
    VALUE
    0x8080864E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA44SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA44SCG"
    VALUE
    0x8080864F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA57OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA57OR"
    VALUE
    0x80808650
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA57SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA57SCB"
    VALUE
    0x80808651
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA57SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA57SCG"
    VALUE
    0x80808652
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA59OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA59OL"
    VALUE
    0x80808653
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA59SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA59SCB"
    VALUE
    0x80808654
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inA59SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inA59SCG"
    VALUE
    0x80808655
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK10OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK10OR"
    VALUE
    0x80808656
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK10SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK10SCB"
    VALUE
    0x80808657
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK10SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK10SCG"
    VALUE
    0x80808658
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK11OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK11OR"
    VALUE
    0x80808659
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK11SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK11SCB"
    VALUE
    0x8080865A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK11SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK11SCG"
    VALUE
    0x8080865B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30AicSCB"
    VALUE
    0x8080865C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30AicSCG"
    VALUE
    0x8080865D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30OR"
    VALUE
    0x8080865E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30SCB"
    VALUE
    0x8080865F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30SCG"
    VALUE
    0x80808660
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK30ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80808661
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK31OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK31OR"
    VALUE
    0x80808662
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK31SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK31SCB"
    VALUE
    0x80808663
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK31SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK31SCG"
    VALUE
    0x80808664
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK32OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK32OR"
    VALUE
    0x80808665
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK32SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK32SCB"
    VALUE
    0x80808666
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK32SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK32SCG"
    VALUE
    0x80808667
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK33OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK33OR"
    VALUE
    0x80808668
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK33SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK33SCB"
    VALUE
    0x80808669
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK33SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK33SCG"
    VALUE
    0x8080866A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK34OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK34OR"
    VALUE
    0x8080866B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK34SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK34SCB"
    VALUE
    0x8080866C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK34SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK34SCG"
    VALUE
    0x8080866D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK35OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK35OR"
    VALUE
    0x8080866E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK35SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK35SCB"
    VALUE
    0x8080866F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK35SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK35SCG"
    VALUE
    0x80808670
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK36OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK36OR"
    VALUE
    0x80808671
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK36SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK36SCB"
    VALUE
    0x80808672
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK36SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK36SCG"
    VALUE
    0x80808673
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37AicSCB"
    VALUE
    0x80808674
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37AicSCG"
    VALUE
    0x80808675
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37OR"
    VALUE
    0x80808676
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37SCB"
    VALUE
    0x80808677
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37SCG"
    VALUE
    0x80808678
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK37ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80808679
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38AicSCB"
    VALUE
    0x8080867A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38AicSCG"
    VALUE
    0x8080867B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38OR"
    VALUE
    0x8080867C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38SCB"
    VALUE
    0x8080867D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38SCG"
    VALUE
    0x8080867E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK38ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x8080867F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39AicSCB"
    VALUE
    0x80808680
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39AicSCG"
    VALUE
    0x80808681
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39OR"
    VALUE
    0x80808682
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39SCB"
    VALUE
    0x80808683
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39SCG"
    VALUE
    0x80808684
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK39ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80808685
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40AicSCB"
    VALUE
    0x80808686
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40AicSCG"
    VALUE
    0x80808687
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40OR"
    VALUE
    0x80808688
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40SCB"
    VALUE
    0x80808689
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40SCG"
    VALUE
    0x8080868A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK40ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x8080868B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41AicSCB"
    VALUE
    0x8080868C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41AicSCG"
    VALUE
    0x8080868D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41OR"
    VALUE
    0x8080868E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41SCB"
    VALUE
    0x8080868F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41SCG"
    VALUE
    0x80808690
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK41ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80808691
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42AicSCB"
    VALUE
    0x80808692
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42AicSCG"
    VALUE
    0x80808693
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42OR"
    VALUE
    0x80808694
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42SCB"
    VALUE
    0x80808695
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42SCG"
    VALUE
    0x80808696
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK42ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80808697
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK43OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK43OR"
    VALUE
    0x80808698
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK43SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK43SCB"
    VALUE
    0x80808699
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK43SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK43SCG"
    VALUE
    0x8080869A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44AicSCB"
    VALUE
    0x8080869B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44AicSCG"
    VALUE
    0x8080869C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44OR"
    VALUE
    0x8080869D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44SCB"
    VALUE
    0x8080869E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44SCG"
    VALUE
    0x8080869F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK44ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x808086A0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45AicSCB"
    VALUE
    0x808086A1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45AicSCG"
    VALUE
    0x808086A2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45OR"
    VALUE
    0x808086A3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45SCB"
    VALUE
    0x808086A4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45SCG"
    VALUE
    0x808086A5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK45ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x808086A6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK52OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK52OR"
    VALUE
    0x808086A7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK52SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK52SCB"
    VALUE
    0x808086A8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK52SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK52SCG"
    VALUE
    0x808086A9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK53OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK53OR"
    VALUE
    0x808086AA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK53SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK53SCB"
    VALUE
    0x808086AB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK53SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK53SCG"
    VALUE
    0x808086AC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54AicSCB"
    VALUE
    0x808086AD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54AicSCG"
    VALUE
    0x808086AE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54OR"
    VALUE
    0x808086AF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54SCB"
    VALUE
    0x808086B0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54SCG"
    VALUE
    0x808086B1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK54ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x808086B2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55AicSCB"
    VALUE
    0x808086B3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55AicSCG"
    VALUE
    0x808086B4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55OR"
    VALUE
    0x808086B5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55SCB"
    VALUE
    0x808086B6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55SCG"
    VALUE
    0x808086B7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK55ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x808086B8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK56OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK56OR"
    VALUE
    0x808086B9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK56SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK56SCB"
    VALUE
    0x808086BA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK56SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK56SCG"
    VALUE
    0x808086BB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK57OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK57OR"
    VALUE
    0x808086BC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK57SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK57SCB"
    VALUE
    0x808086BD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK57SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK57SCG"
    VALUE
    0x808086BE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK58OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK58OR"
    VALUE
    0x808086BF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK58SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK58SCB"
    VALUE
    0x808086C0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK58SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK58SCG"
    VALUE
    0x808086C1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK59OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK59OR"
    VALUE
    0x808086C2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK59SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK59SCB"
    VALUE
    0x808086C3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK59SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK59SCG"
    VALUE
    0x808086C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK60OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK60OR"
    VALUE
    0x808086C5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK60SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK60SCB"
    VALUE
    0x808086C6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK60SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK60SCG"
    VALUE
    0x808086C7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61AicSCB"
    VALUE
    0x808086C8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61AicSCG"
    VALUE
    0x808086C9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61OR"
    VALUE
    0x808086CA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61SCB"
    VALUE
    0x808086CB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61SCG"
    VALUE
    0x808086CC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK61ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x808086CD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK62OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK62OR"
    VALUE
    0x808086CE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK62SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK62SCB"
    VALUE
    0x808086CF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK62SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK62SCG"
    VALUE
    0x808086D0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63AicSCB"
    VALUE
    0x808086D1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63AicSCG"
    VALUE
    0x808086D2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63OR"
    VALUE
    0x808086D3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63SCB"
    VALUE
    0x808086D4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63SCG"
    VALUE
    0x808086D5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK63ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x808086D6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64AicSCB"
    VALUE
    0x808086D7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64AicSCG"
    VALUE
    0x808086D8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64OR"
    VALUE
    0x808086D9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64SCB"
    VALUE
    0x808086DA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64SCG"
    VALUE
    0x808086DB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK64ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x808086DC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65AicSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65AicSCB"
    VALUE
    0x808086DD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65AicSCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65AicSCG"
    VALUE
    0x808086DE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65OR"
    VALUE
    0x808086DF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65SCB"
    VALUE
    0x808086E0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65SCG"
    VALUE
    0x808086E1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK65ShuntSCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x808086E2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK74OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK74OR"
    VALUE
    0x808086E3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK74SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK74SCB"
    VALUE
    0x808086E4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK74SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK74SCG"
    VALUE
    0x808086E5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK75OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK75OR"
    VALUE
    0x808086E6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK75SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK75SCB"
    VALUE
    0x808086E7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK75SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK75SCG"
    VALUE
    0x808086E8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK76OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK76OR"
    VALUE
    0x808086E9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK76SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK76SCB"
    VALUE
    0x808086EA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK76SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK76SCG"
    VALUE
    0x808086EB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK77OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK77OR"
    VALUE
    0x808086EC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK77SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK77SCB"
    VALUE
    0x808086ED
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK77SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK77SCG"
    VALUE
    0x808086EE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK78OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK78OR"
    VALUE
    0x808086EF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK78SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK78SCB"
    VALUE
    0x808086F0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inK78SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inK78SCG"
    VALUE
    0x808086F1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_DvUBAT_FWs_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x808086F2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OVErr_VPR6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x808086F3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OVWarn_VPR6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x808086F4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808086F5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x808086F6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_UBAT_MON_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x808086F7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x808086F8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x808086F9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_UBRM24_MON_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x808086FA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VDD5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x808086FB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VDD5_IN_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x808086FC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VPR6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x808086FD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VSS3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x808086FE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VSS4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x808086FF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_Temp1_HTErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80808700
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_Temp1_HTWarn_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80808701
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_Temp2_HTErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80808702
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_Temp2_HTWarn_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80808703
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80808704
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80808705
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VDD5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80808706
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VDD5_IN_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80808707
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VPR6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80808708
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VSS3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80808709
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VSS4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x8080870A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA01OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA01OL"
    VALUE
    0x8080870B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA01OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA01OT"
    VALUE
    0x8080870C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA01SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA01SCB"
    VALUE
    0x8080870D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA01SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA01SCG"
    VALUE
    0x8080870E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02OL"
    VALUE
    0x8080870F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02OR"
    VALUE
    0x80808710
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02OT"
    VALUE
    0x80808711
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02SCB"
    VALUE
    0x80808712
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02SCG"
    VALUE
    0x80808713
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03OL"
    VALUE
    0x80808714
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03OT"
    VALUE
    0x80808715
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03SCB"
    VALUE
    0x80808716
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03SCG"
    VALUE
    0x80808717
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04OL"
    VALUE
    0x80808718
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04OT"
    VALUE
    0x80808719
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04SCB"
    VALUE
    0x8080871A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04SCG"
    VALUE
    0x8080871B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05OL"
    VALUE
    0x8080871C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05OR"
    VALUE
    0x8080871D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05OT"
    VALUE
    0x8080871E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05SCB"
    VALUE
    0x8080871F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05SCG"
    VALUE
    0x80808720
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA06OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA06OL"
    VALUE
    0x80808721
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA06OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA06OR"
    VALUE
    0x80808722
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA06OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA06OT"
    VALUE
    0x80808723
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA06SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA06SCB"
    VALUE
    0x80808724
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA06SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA06SCG"
    VALUE
    0x80808725
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07OL"
    VALUE
    0x80808726
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07OT"
    VALUE
    0x80808727
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07SCB"
    VALUE
    0x80808728
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07SCG"
    VALUE
    0x80808729
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08OL"
    VALUE
    0x8080872A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08OT"
    VALUE
    0x8080872B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08SCB"
    VALUE
    0x8080872C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08SCG"
    VALUE
    0x8080872D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09OL"
    VALUE
    0x8080872E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09OR"
    VALUE
    0x8080872F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09OT"
    VALUE
    0x80808730
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09SCB"
    VALUE
    0x80808731
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09SCG"
    VALUE
    0x80808732
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10OL"
    VALUE
    0x80808733
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10OT"
    VALUE
    0x80808734
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10SCB"
    VALUE
    0x80808735
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10SCG"
    VALUE
    0x80808736
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA11OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA11OL"
    VALUE
    0x80808737
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA11OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA11OT"
    VALUE
    0x80808738
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA11SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA11SCB"
    VALUE
    0x80808739
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA11SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA11SCG"
    VALUE
    0x8080873A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA12OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA12OR"
    VALUE
    0x8080873B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA12SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA12SCB"
    VALUE
    0x8080873C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA12SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA12SCG"
    VALUE
    0x8080873D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA16OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA16OL"
    VALUE
    0x8080873E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA16OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA16OT"
    VALUE
    0x8080873F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA16SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA16SCB"
    VALUE
    0x80808740
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA16SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA16SCG"
    VALUE
    0x80808741
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17OL"
    VALUE
    0x80808742
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17OR"
    VALUE
    0x80808743
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17OT"
    VALUE
    0x80808744
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17SCB"
    VALUE
    0x80808745
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17SCG"
    VALUE
    0x80808746
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18OL"
    VALUE
    0x80808747
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18OT"
    VALUE
    0x80808748
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18SCB"
    VALUE
    0x80808749
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18SCG"
    VALUE
    0x8080874A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19OL"
    VALUE
    0x8080874B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19OR"
    VALUE
    0x8080874C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19OT"
    VALUE
    0x8080874D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19SCB"
    VALUE
    0x8080874E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19SCG"
    VALUE
    0x8080874F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20OL"
    VALUE
    0x80808750
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20OR"
    VALUE
    0x80808751
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20OT"
    VALUE
    0x80808752
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20SCB"
    VALUE
    0x80808753
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20SCG"
    VALUE
    0x80808754
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31OL"
    VALUE
    0x80808755
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31OR"
    VALUE
    0x80808756
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31OT"
    VALUE
    0x80808757
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31SCB"
    VALUE
    0x80808758
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31SCG"
    VALUE
    0x80808759
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32OL"
    VALUE
    0x8080875A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32OR"
    VALUE
    0x8080875B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32OT"
    VALUE
    0x8080875C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32SCB"
    VALUE
    0x8080875D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32SCG"
    VALUE
    0x8080875E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33OL"
    VALUE
    0x8080875F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33OR"
    VALUE
    0x80808760
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33OT"
    VALUE
    0x80808761
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33SCB"
    VALUE
    0x80808762
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33SCG"
    VALUE
    0x80808763
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34OL"
    VALUE
    0x80808764
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34OR"
    VALUE
    0x80808765
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34OT"
    VALUE
    0x80808766
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34SCB"
    VALUE
    0x80808767
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34SCG"
    VALUE
    0x80808768
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35OL"
    VALUE
    0x80808769
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35OR"
    VALUE
    0x8080876A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35OT"
    VALUE
    0x8080876B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35SCB"
    VALUE
    0x8080876C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35SCG"
    VALUE
    0x8080876D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46OL"
    VALUE
    0x8080876E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46OR"
    VALUE
    0x8080876F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46OT"
    VALUE
    0x80808770
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46SCB"
    VALUE
    0x80808771
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46SCG"
    VALUE
    0x80808772
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47OL"
    VALUE
    0x80808773
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47OR"
    VALUE
    0x80808774
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47OT"
    VALUE
    0x80808775
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47SCB"
    VALUE
    0x80808776
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47SCG"
    VALUE
    0x80808777
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48OL"
    VALUE
    0x80808778
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48OR"
    VALUE
    0x80808779
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48OT"
    VALUE
    0x8080877A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48SCB"
    VALUE
    0x8080877B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48SCG"
    VALUE
    0x8080877C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA49OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA49OL"
    VALUE
    0x8080877D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA49OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA49OT"
    VALUE
    0x8080877E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA49SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA49SCB"
    VALUE
    0x8080877F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA49SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA49SCG"
    VALUE
    0x80808780
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA50OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA50OL"
    VALUE
    0x80808781
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA50OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA50OT"
    VALUE
    0x80808782
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA50SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA50SCB"
    VALUE
    0x80808783
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA50SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA50SCG"
    VALUE
    0x80808784
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51OL"
    VALUE
    0x80808785
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51OR"
    VALUE
    0x80808786
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51OT"
    VALUE
    0x80808787
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51SCB"
    VALUE
    0x80808788
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51SCG"
    VALUE
    0x80808789
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52OL"
    VALUE
    0x8080878A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52OR"
    VALUE
    0x8080878B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52OT"
    VALUE
    0x8080878C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52SCB"
    VALUE
    0x8080878D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52SCG"
    VALUE
    0x8080878E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53OL"
    VALUE
    0x8080878F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53OR"
    VALUE
    0x80808790
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53OT"
    VALUE
    0x80808791
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53SCB"
    VALUE
    0x80808792
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53SCG"
    VALUE
    0x80808793
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54OL"
    VALUE
    0x80808794
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54OR"
    VALUE
    0x80808795
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54OT"
    VALUE
    0x80808796
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54SCB"
    VALUE
    0x80808797
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54SCG"
    VALUE
    0x80808798
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA55OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA55OL"
    VALUE
    0x80808799
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA55OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA55OT"
    VALUE
    0x8080879A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA55SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA55SCB"
    VALUE
    0x8080879B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA55SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA55SCG"
    VALUE
    0x8080879C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA56OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA56OL"
    VALUE
    0x8080879D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA56OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA56OT"
    VALUE
    0x8080879E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA56SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA56SCB"
    VALUE
    0x8080879F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA56SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA56SCG"
    VALUE
    0x808087A0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA58OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA58OL"
    VALUE
    0x808087A1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA58OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA58OT"
    VALUE
    0x808087A2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA58SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA58SCB"
    VALUE
    0x808087A3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA58SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA58SCG"
    VALUE
    0x808087A4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07OL"
    VALUE
    0x808087A5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07OR"
    VALUE
    0x808087A6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07OT"
    VALUE
    0x808087A7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07SCB"
    VALUE
    0x808087A8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07SCG"
    VALUE
    0x808087A9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08OL"
    VALUE
    0x808087AA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08OR"
    VALUE
    0x808087AB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08OT"
    VALUE
    0x808087AC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08SCB"
    VALUE
    0x808087AD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08SCG"
    VALUE
    0x808087AE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09OL"
    VALUE
    0x808087AF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09OR"
    VALUE
    0x808087B0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09OT"
    VALUE
    0x808087B1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09SCB"
    VALUE
    0x808087B2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09SCG"
    VALUE
    0x808087B3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12OL"
    VALUE
    0x808087B4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12OT"
    VALUE
    0x808087B5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12SCB"
    VALUE
    0x808087B6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12SCG"
    VALUE
    0x808087B7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13OL"
    VALUE
    0x808087B8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13OT"
    VALUE
    0x808087B9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13SCB"
    VALUE
    0x808087BA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13SCG"
    VALUE
    0x808087BB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14OL"
    VALUE
    0x808087BC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14OR"
    VALUE
    0x808087BD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14OT"
    VALUE
    0x808087BE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14SCB"
    VALUE
    0x808087BF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14SCG"
    VALUE
    0x808087C0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15OL"
    VALUE
    0x808087C1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15OR"
    VALUE
    0x808087C2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15OT"
    VALUE
    0x808087C3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15SCB"
    VALUE
    0x808087C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15SCG"
    VALUE
    0x808087C5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16OL"
    VALUE
    0x808087C6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16OR"
    VALUE
    0x808087C7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16OT"
    VALUE
    0x808087C8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16SCB"
    VALUE
    0x808087C9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16SCG"
    VALUE
    0x808087CA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17OL"
    VALUE
    0x808087CB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17OR"
    VALUE
    0x808087CC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17OT"
    VALUE
    0x808087CD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17SCB"
    VALUE
    0x808087CE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17SCG"
    VALUE
    0x808087CF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK25OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK25OR"
    VALUE
    0x808087D0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK25SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK25SCB"
    VALUE
    0x808087D1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK25SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK25SCG"
    VALUE
    0x808087D2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29OL"
    VALUE
    0x808087D3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29OR"
    VALUE
    0x808087D4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29OT"
    VALUE
    0x808087D5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29SCB"
    VALUE
    0x808087D6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29SCG"
    VALUE
    0x808087D7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51OL"
    VALUE
    0x808087D8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51OT"
    VALUE
    0x808087D9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51SCB"
    VALUE
    0x808087DA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51SCG"
    VALUE
    0x808087DB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK62OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK62OR"
    VALUE
    0x808087DC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK62SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK62SCB"
    VALUE
    0x808087DD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK62SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK62SCG"
    VALUE
    0x808087DE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73OL"
    VALUE
    0x808087DF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73OR"
    VALUE
    0x808087E0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73OT"
    VALUE
    0x808087E1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73SCB"
    VALUE
    0x808087E2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73SCG"
    VALUE
    0x808087E3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK80OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK80OL"
    VALUE
    0x808087E4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK80OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK80OT"
    VALUE
    0x808087E5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK80SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK80SCB"
    VALUE
    0x808087E6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK80SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK80SCG"
    VALUE
    0x808087E7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK81OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK81OL"
    VALUE
    0x808087E8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK81OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK81OT"
    VALUE
    0x808087E9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK81SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK81SCB"
    VALUE
    0x808087EA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK81SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK81SCG"
    VALUE
    0x808087EB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK82OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK82OL"
    VALUE
    0x808087EC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK82OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK82OT"
    VALUE
    0x808087ED
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK82SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK82SCB"
    VALUE
    0x808087EE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK82SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK82SCG"
    VALUE
    0x808087EF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK83OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK83OL"
    VALUE
    0x808087F0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK83OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK83OT"
    VALUE
    0x808087F1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK83SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK83SCB"
    VALUE
    0x808087F2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK83SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK83SCG"
    VALUE
    0x808087F3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK84OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK84OL"
    VALUE
    0x808087F4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK84OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK84OT"
    VALUE
    0x808087F5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK84SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK84SCB"
    VALUE
    0x808087F6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK84SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK84SCG"
    VALUE
    0x808087F7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK85OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK85OL"
    VALUE
    0x808087F8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK85OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK85OT"
    VALUE
    0x808087F9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK85SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK85SCB"
    VALUE
    0x808087FA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK85SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK85SCG"
    VALUE
    0x808087FB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK86OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK86OL"
    VALUE
    0x808087FC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK86OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK86OT"
    VALUE
    0x808087FD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK86SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK86SCB"
    VALUE
    0x808087FE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK86SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK86SCG"
    VALUE
    0x808087FF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK87OL_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK87OL"
    VALUE
    0x80808800
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK87OT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK87OT"
    VALUE
    0x80808801
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK87SCB_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK87SCB"
    VALUE
    0x80808802
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK87SCG_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK87SCG"
    VALUE
    0x80808803
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_DSMDummy_C
    "AUTOSAR: Functional unit of DTC / Check DFC_DSMDummy"
    VALUE
    0x80808804
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8000_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8000"
    VALUE
    0x80808805
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8001_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8001"
    VALUE
    0x80808806
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8002_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8002"
    VALUE
    0x80808807
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8003_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8003"
    VALUE
    0x80808808
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8004_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8004"
    VALUE
    0x80808809
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8005_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8005"
    VALUE
    0x8080880A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8006_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8006"
    VALUE
    0x8080880B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8007_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8007"
    VALUE
    0x8080880C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8008_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8008"
    VALUE
    0x8080880D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8009_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8009"
    VALUE
    0x8080880E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x800a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x800a"
    VALUE
    0x8080880F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x800b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x800b"
    VALUE
    0x80808810
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x800c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x800c"
    VALUE
    0x80808811
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x800d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x800d"
    VALUE
    0x80808812
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x800e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x800e"
    VALUE
    0x80808813
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x800f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x800f"
    VALUE
    0x80808814
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8010_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8010"
    VALUE
    0x80808815
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8011_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8011"
    VALUE
    0x80808816
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8012_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8012"
    VALUE
    0x80808817
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8013_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8013"
    VALUE
    0x80808818
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8014_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8014"
    VALUE
    0x80808819
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8015_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8015"
    VALUE
    0x8080881A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8016_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8016"
    VALUE
    0x8080881B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8017_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8017"
    VALUE
    0x8080881C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8018_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8018"
    VALUE
    0x8080881D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8019_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8019"
    VALUE
    0x8080881E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x801a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x801a"
    VALUE
    0x8080881F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x801b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x801b"
    VALUE
    0x80808820
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x801c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x801c"
    VALUE
    0x80808821
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x801d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x801d"
    VALUE
    0x80808822
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x801e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x801e"
    VALUE
    0x80808823
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x801f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x801f"
    VALUE
    0x80808824
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8020_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8020"
    VALUE
    0x80808825
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8021_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8021"
    VALUE
    0x80808826
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8022_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8022"
    VALUE
    0x80808827
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8023_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8023"
    VALUE
    0x80808828
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8024_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8024"
    VALUE
    0x80808829
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8025_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8025"
    VALUE
    0x8080882A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8026_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8026"
    VALUE
    0x8080882B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8027_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8027"
    VALUE
    0x8080882C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8028_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8028"
    VALUE
    0x8080882D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8029_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8029"
    VALUE
    0x8080882E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x802a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x802a"
    VALUE
    0x8080882F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x802b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x802b"
    VALUE
    0x80808830
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x802c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x802c"
    VALUE
    0x80808831
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x802d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x802d"
    VALUE
    0x80808832
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x802e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x802e"
    VALUE
    0x80808833
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x802f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x802f"
    VALUE
    0x80808834
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8030_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8030"
    VALUE
    0x80808835
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8031_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8031"
    VALUE
    0x80808836
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8032_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8032"
    VALUE
    0x80808837
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8033_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8033"
    VALUE
    0x80808838
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8034_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8034"
    VALUE
    0x80808839
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8035_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8035"
    VALUE
    0x8080883A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8036_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8036"
    VALUE
    0x8080883B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8037_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8037"
    VALUE
    0x8080883C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8038_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8038"
    VALUE
    0x8080883D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8039_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8039"
    VALUE
    0x8080883E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x803a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x803a"
    VALUE
    0x8080883F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x803b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x803b"
    VALUE
    0x80808840
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x803c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x803c"
    VALUE
    0x80808841
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x803d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x803d"
    VALUE
    0x80808842
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x803e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x803e"
    VALUE
    0x80808843
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x803f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x803f"
    VALUE
    0x80808844
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8040_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8040"
    VALUE
    0x80808845
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8041_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8041"
    VALUE
    0x80808846
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8042_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8042"
    VALUE
    0x80808847
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8043_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8043"
    VALUE
    0x80808848
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8044_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8044"
    VALUE
    0x80808849
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8045_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8045"
    VALUE
    0x8080884A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8046_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8046"
    VALUE
    0x8080884B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8047_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8047"
    VALUE
    0x8080884C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8048_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8048"
    VALUE
    0x8080884D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8049_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8049"
    VALUE
    0x8080884E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x804a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x804a"
    VALUE
    0x8080884F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x804b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x804b"
    VALUE
    0x80808850
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x804c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x804c"
    VALUE
    0x80808851
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x804d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x804d"
    VALUE
    0x80808852
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x804e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x804e"
    VALUE
    0x80808853
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x804f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x804f"
    VALUE
    0x80808854
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8050_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8050"
    VALUE
    0x80808855
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8051_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8051"
    VALUE
    0x80808856
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8052_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8052"
    VALUE
    0x80808857
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8053_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8053"
    VALUE
    0x80808858
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8054_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8054"
    VALUE
    0x80808859
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8055_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8055"
    VALUE
    0x8080885A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8056_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8056"
    VALUE
    0x8080885B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8057_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8057"
    VALUE
    0x8080885C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8058_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8058"
    VALUE
    0x8080885D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8059_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8059"
    VALUE
    0x8080885E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x805a_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x805a"
    VALUE
    0x8080885F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x805b_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x805b"
    VALUE
    0x80808860
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x805c_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x805c"
    VALUE
    0x80808861
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x805d_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x805d"
    VALUE
    0x80808862
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x805e_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x805e"
    VALUE
    0x80808863
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x805f_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x805f"
    VALUE
    0x80808864
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8060_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8060"
    VALUE
    0x80808865
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8061_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8061"
    VALUE
    0x80808866
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8062_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8062"
    VALUE
    0x80808867
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8C01_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8C01"
    VALUE
    0x80808868
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8C02_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8C02"
    VALUE
    0x80808869
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_bds_NoDeb0x8C03_C
    "AUTOSAR: Functional unit of DTC / Check DFC_bds_NoDeb0x8C03"
    VALUE
    0x8080886A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetDataNoBuf_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x8080886B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetDataParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetDataParam"
    VALUE
    0x8080886C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetDataboxNoInit_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x8080886D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetDataboxParam"
    VALUE
    0x8080886E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetRxBufStatusParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x8080886F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetStatusParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetStatusParam"
    VALUE
    0x80808870
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canGetTxBufStatusParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80808871
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canInitParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canInitParam"
    VALUE
    0x80808872
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canInitRxDataboxOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80808873
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canInitRxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80808874
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canInitTxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80808875
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canIpduGroupControl_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80808876
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canIsDataboxFreeNoInit_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80808877
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canIsDataboxFreeParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80808878
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canIsTxEmptyParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80808879
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegBusOffCallbInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x8080887A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegBusOffCallbParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x8080887B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxBufInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x8080887C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxBufOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x8080887D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxBufParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxBufParam"
    VALUE
    0x8080887E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxCallbInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x8080887F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxCallbParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80808880
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxDataboxInvNumb_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80808881
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxDataboxInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80808882
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxDataboxOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80808883
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegRxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80808884
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxBufInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80808885
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxBufOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80808886
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxBufParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80808887
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxDataboxInvNumb_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80808888
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxDataboxInvState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80808889
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxDataboxOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x8080888A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canRegTxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x8080888B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canResetTxBufParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canResetTxBufParam"
    VALUE
    0x8080888C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canSendDataBufOvfl_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x8080888D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canSendDataParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canSendDataParam"
    VALUE
    0x8080888E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canSendDataboxNoInit_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x8080888F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canSendDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80808890
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canSetTxCycleParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80808891
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canStartParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canStartParam"
    VALUE
    0x80808892
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_canStopParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_canStopParam"
    VALUE
    0x80808893
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_can_ClearIpduGroup_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80808894
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_can_ReceiveSignal_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80808895
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_can_SendSignal_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_can_SendSignal"
    VALUE
    0x80808896
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_can_SetIpduGroup_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80808897
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmDTCJ1939_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80808898
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmDelDTCJ1939_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80808899
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmDelErrors_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmDelErrors"
    VALUE
    0x8080889A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmGetDFES_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmGetDFES"
    VALUE
    0x8080889B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmGetDTCJ1939_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x8080889C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmGetErrors_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmGetErrors"
    VALUE
    0x8080889D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmGetNumErrors_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x8080889E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmInitQueueOverflow_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x8080889F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmNumDTCJ1939_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x808088A0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmTesterror_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmTesterror"
    VALUE
    0x808088A1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmUpdateDebError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x808088A2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmUpdateError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmUpdateError"
    VALUE
    0x808088A3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmgetDFCStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x808088A4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_dsmtestErrorDFC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x808088A5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAi"
    VALUE
    0x808088A6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAic_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAic"
    VALUE
    0x808088A7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAicCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAicCfg"
    VALUE
    0x808088A8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAicGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAicGetStatus"
    VALUE
    0x808088A9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAid_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAid"
    VALUE
    0x808088AA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAidCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAidCfg"
    VALUE
    0x808088AB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAiv_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAiv"
    VALUE
    0x808088AC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAivCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAivCfg"
    VALUE
    0x808088AD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inAivGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inAivGetStatus"
    VALUE
    0x808088AE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inDi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inDi"
    VALUE
    0x808088AF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inFi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inFi"
    VALUE
    0x808088B0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inFiCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inFiCfg"
    VALUE
    0x808088B1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inFiGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inFiGetStatus"
    VALUE
    0x808088B2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inFi_Buffered_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inFi_Buffered"
    VALUE
    0x808088B3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inPhase_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inPhase"
    VALUE
    0x808088B4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inPhaseGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x808088B5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inPhaseResetCounter_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x808088B6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inRi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inRi"
    VALUE
    0x808088B7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inRiCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inRiCfg"
    VALUE
    0x808088B8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inRiCfgTemp_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inRiCfgTemp"
    VALUE
    0x808088B9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inRiGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inRiGetStatus"
    VALUE
    0x808088BA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inRiGetTemp_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inRiGetTemp"
    VALUE
    0x808088BB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentCopyFDFifo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x808088BC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentDisable_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentDisable"
    VALUE
    0x808088BD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentEnable_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentEnable"
    VALUE
    0x808088BE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentGetErrorStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x808088BF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentGetFD_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentGetFD"
    VALUE
    0x808088C0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentGetSD_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentGetSD"
    VALUE
    0x808088C1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentGetSDDatabox_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x808088C2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentGetStatus"
    VALUE
    0x808088C3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentInitSDDatabox_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x808088C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentRegisterCopyFDFifo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x808088C5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentRegisterFDFifo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x808088C6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_inSentRegisterSDDataboxes_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x808088C7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusCanRxBufferOverflow_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x808088C8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusGetCaAddrParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x808088C9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusGetDiagnosticParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x808088CA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x808088CB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusGetStatusParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x808088CC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitCommCaMissing_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x808088CD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitCommParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitCommParam"
    VALUE
    0x808088CE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitCommState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitCommState"
    VALUE
    0x808088CF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitDiagnosticParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x808088D0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitFailureListParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x808088D1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitRxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x808088D2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusInitTxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x808088D3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegRxDataboxOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x808088D4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegRxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x808088D5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegRxDataboxState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x808088D6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegTxDataboxOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x808088D7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegTxDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x808088D8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegTxDataboxState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x808088D9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x808088DA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegisterInstancesOverlap_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x808088DB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegisterInstancesParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x808088DC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusRegisterInstancesState_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x808088DD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSendDataboxParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x808088DE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSendRequestPGNParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x808088DF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaAddrCaUsed_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x808088E0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaAddrComm_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x808088E1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaAddrInvCan_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x808088E2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaAddrParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x808088E3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaInfoParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x808088E4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSetCaNameParam_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x808088E5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_isobusSftyCanTxErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x808088E6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_ReceiveSignal_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x808088E7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_SendSignal_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_SendSignal"
    VALUE
    0x808088E8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_getStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_getStatus"
    VALUE
    0x808088E9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_gotoSleep_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_gotoSleep"
    VALUE
    0x808088EA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_scheduleRequest_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x808088EB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_lin_wakeUp_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_lin_wakeUp"
    VALUE
    0x808088EC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memFlsCfgShr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memFlsCfgShr"
    VALUE
    0x808088ED
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memGetStatus"
    VALUE
    0x808088EE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memMarkBlock_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memMarkBlock"
    VALUE
    0x808088EF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadApi1Error_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadApi1Error"
    VALUE
    0x808088F0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadApi2Error_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadApi2Error"
    VALUE
    0x808088F1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadBlock_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadBlock"
    VALUE
    0x808088F2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadCalibInputError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadCalibInputError"
    VALUE
    0x808088F3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadCalibOuputError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x808088F4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memReadSystemError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memReadSystemError"
    VALUE
    0x808088F5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_memWriteBlock_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_memWriteBlock"
    VALUE
    0x808088F6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_moOV_FirstConstADC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x808088F7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_moOV_SecondConstADC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x808088F8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_moUV_FirstConstADC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x808088F9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_moUV_SecondConstADC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x808088FA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_INH_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_INH"
    VALUE
    0x808088FB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_INHLatch_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_INHLatch"
    VALUE
    0x808088FC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_adcPDD_fail_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x808088FD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_memoryProtection_err_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x808088FE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02OC"
    VALUE
    0x808088FF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA02Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA02Unintended"
    VALUE
    0x80808900
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03OC"
    VALUE
    0x80808901
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA03Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA03Unintended"
    VALUE
    0x80808902
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04OC"
    VALUE
    0x80808903
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA04Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA04Unintended"
    VALUE
    0x80808904
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05OC"
    VALUE
    0x80808905
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA05Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA05Unintended"
    VALUE
    0x80808906
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07OC"
    VALUE
    0x80808907
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA07Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA07Unintended"
    VALUE
    0x80808908
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08OC"
    VALUE
    0x80808909
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA08Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA08Unintended"
    VALUE
    0x8080890A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09OC"
    VALUE
    0x8080890B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA09Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA09Unintended"
    VALUE
    0x8080890C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10OC"
    VALUE
    0x8080890D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA10Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA10Unintended"
    VALUE
    0x8080890E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17OC"
    VALUE
    0x8080890F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA17Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA17Unintended"
    VALUE
    0x80808910
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18OC"
    VALUE
    0x80808911
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA18Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA18Unintended"
    VALUE
    0x80808912
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19OC"
    VALUE
    0x80808913
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA19Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA19Unintended"
    VALUE
    0x80808914
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20OC"
    VALUE
    0x80808915
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA20Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA20Unintended"
    VALUE
    0x80808916
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31OC"
    VALUE
    0x80808917
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA31Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA31Unintended"
    VALUE
    0x80808918
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32OC"
    VALUE
    0x80808919
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA32Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA32Unintended"
    VALUE
    0x8080891A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33OC"
    VALUE
    0x8080891B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA33Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA33Unintended"
    VALUE
    0x8080891C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34OC"
    VALUE
    0x8080891D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA34Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA34Unintended"
    VALUE
    0x8080891E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35OC"
    VALUE
    0x8080891F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA35Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA35Unintended"
    VALUE
    0x80808920
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46OC"
    VALUE
    0x80808921
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA46Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA46Unintended"
    VALUE
    0x80808922
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47OC"
    VALUE
    0x80808923
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA47Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA47Unintended"
    VALUE
    0x80808924
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48OC"
    VALUE
    0x80808925
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA48Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA48Unintended"
    VALUE
    0x80808926
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51OC"
    VALUE
    0x80808927
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA51Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA51Unintended"
    VALUE
    0x80808928
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52OC"
    VALUE
    0x80808929
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA52Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA52Unintended"
    VALUE
    0x8080892A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53OC"
    VALUE
    0x8080892B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA53Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA53Unintended"
    VALUE
    0x8080892C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54OC"
    VALUE
    0x8080892D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outA54Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outA54Unintended"
    VALUE
    0x8080892E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAov_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAov"
    VALUE
    0x8080892F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAovCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAovCfg"
    VALUE
    0x80808930
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAovCfgPI_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAovCfgPI"
    VALUE
    0x80808931
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAovGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAovGetStatus"
    VALUE
    0x80808932
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAovGetVoltage_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80808933
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outAovResetError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outAovResetError"
    VALUE
    0x80808934
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDo"
    VALUE
    0x80808935
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDoCfgPwrLs_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80808936
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDoDisable_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDoDisable"
    VALUE
    0x80808937
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDoGetCurrent_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80808938
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDoGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDoGetStatus"
    VALUE
    0x80808939
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outDoResetError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outDoResetError"
    VALUE
    0x8080893A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07OC"
    VALUE
    0x8080893B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK07Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK07Unintended"
    VALUE
    0x8080893C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08OC"
    VALUE
    0x8080893D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK08Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK08Unintended"
    VALUE
    0x8080893E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09OC"
    VALUE
    0x8080893F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK09Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK09Unintended"
    VALUE
    0x80808940
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12OC"
    VALUE
    0x80808941
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK12Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK12Unintended"
    VALUE
    0x80808942
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13OC"
    VALUE
    0x80808943
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK13Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK13Unintended"
    VALUE
    0x80808944
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14OC"
    VALUE
    0x80808945
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK14Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK14Unintended"
    VALUE
    0x80808946
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15OC"
    VALUE
    0x80808947
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK15Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK15Unintended"
    VALUE
    0x80808948
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16OC"
    VALUE
    0x80808949
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK16Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK16Unintended"
    VALUE
    0x8080894A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17OC"
    VALUE
    0x8080894B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK17Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK17Unintended"
    VALUE
    0x8080894C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29OC"
    VALUE
    0x8080894D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK29Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK29Unintended"
    VALUE
    0x8080894E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51OC"
    VALUE
    0x8080894F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK51Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK51Unintended"
    VALUE
    0x80808950
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73OC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73OC"
    VALUE
    0x80808951
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outK73Unintended_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outK73Unintended"
    VALUE
    0x80808952
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPo"
    VALUE
    0x80808953
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoCfg"
    VALUE
    0x80808954
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoCfgPeriod_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80808955
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoCfgPwrLs_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80808956
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoDisable_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoDisable"
    VALUE
    0x80808957
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoGetCurrent_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80808958
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoGetStatus"
    VALUE
    0x80808959
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoResetError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoResetError"
    VALUE
    0x8080895A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPoc_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPoc"
    VALUE
    0x8080895B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPocCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPocCfg"
    VALUE
    0x8080895C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPocCfgDither_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPocCfgDither"
    VALUE
    0x8080895D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPocCfgPI_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPocCfgPI"
    VALUE
    0x8080895E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPod_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPod"
    VALUE
    0x8080895F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPodCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPodCfg"
    VALUE
    0x80808960
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_outPodCfgPeriod_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80808961
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_rsmFfiApiCallErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80808962
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safout_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safout"
    VALUE
    0x80808963
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutCfg"
    VALUE
    0x80808964
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl1"
    VALUE
    0x80808965
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl10"
    VALUE
    0x80808966
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl10Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80808967
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl10OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80808968
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl11"
    VALUE
    0x80808969
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl11Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x8080896A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl11OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl11OR"
    VALUE
    0x8080896B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl12_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl12"
    VALUE
    0x8080896C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl12Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x8080896D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl12OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl12OR"
    VALUE
    0x8080896E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl13"
    VALUE
    0x8080896F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl13Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80808970
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl13OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80808971
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl14"
    VALUE
    0x80808972
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl14Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80808973
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl14OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80808974
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl15_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl15"
    VALUE
    0x80808975
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl15Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80808976
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl15OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80808977
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl16_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl16"
    VALUE
    0x80808978
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl16Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80808979
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl16OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl16OR"
    VALUE
    0x8080897A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl17_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl17"
    VALUE
    0x8080897B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl17Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x8080897C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl17OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl17OR"
    VALUE
    0x8080897D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl18_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl18"
    VALUE
    0x8080897E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl18Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x8080897F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl18OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80808980
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl1Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80808981
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl1OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80808982
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl2"
    VALUE
    0x80808983
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl2Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80808984
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl2OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80808985
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl3"
    VALUE
    0x80808986
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl3Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80808987
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl3OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80808988
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl4"
    VALUE
    0x80808989
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl4Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x8080898A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl4OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl4OR"
    VALUE
    0x8080898B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl5"
    VALUE
    0x8080898C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl5Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x8080898D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl5OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl5OR"
    VALUE
    0x8080898E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl6_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl6"
    VALUE
    0x8080898F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl6Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80808990
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl6OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80808991
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl7"
    VALUE
    0x80808992
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl7Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80808993
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl7OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80808994
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl8"
    VALUE
    0x80808995
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl8Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80808996
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl8OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80808997
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl9_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl9"
    VALUE
    0x80808998
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl9Dev_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80808999
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutChnl9OR_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutChnl9OR"
    VALUE
    0x8080899A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutDevError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutDevError"
    VALUE
    0x8080899B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutGetStatus_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutGetStatus"
    VALUE
    0x8080899C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutIgnoreError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutIgnoreError"
    VALUE
    0x8080899D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutResetError_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutResetError"
    VALUE
    0x8080899E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safoutUnlock_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safoutUnlock"
    VALUE
    0x8080899F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_safout_cfgDiag_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_safout_cfgDiag"
    VALUE
    0x808089A0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secAccessDenied_RC_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x808089A1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secAccessDenied_WDBI_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x808089A2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secEvalRespKey_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secEvalRespKey"
    VALUE
    0x808089A3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secFlashingFailure_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secFlashingFailure"
    VALUE
    0x808089A4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secGetLevel_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secGetLevel"
    VALUE
    0x808089A5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secGetRnd_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secGetRnd"
    VALUE
    0x808089A6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secGetSeed_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secGetSeed"
    VALUE
    0x808089A7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secInvalidPassword_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secInvalidPassword"
    VALUE
    0x808089A8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secIsRequestAllowed_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x808089A9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secResetLevel_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secResetLevel"
    VALUE
    0x808089AA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secSaveSecret_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secSaveSecret"
    VALUE
    0x808089AB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_secSetLevel_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_secSetLevel"
    VALUE
    0x808089AC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysAit_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysAit"
    VALUE
    0x808089AD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysAiv_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysAiv"
    VALUE
    0x808089AE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysDi_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysDi"
    VALUE
    0x808089AF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysDo_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysDo"
    VALUE
    0x808089B0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysGetVss_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysGetVss"
    VALUE
    0x808089B1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysInit_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysInit"
    VALUE
    0x808089B2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysOperHrIntegrityErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x808089B3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysOperHrsSaturated_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x808089B4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sysSetVss_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sysSetVss"
    VALUE
    0x808089B5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sys_coreload_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sys_coreload"
    VALUE
    0x808089B6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_sys_taskload_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_sys_taskload"
    VALUE
    0x808089B7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VSS1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x808089B8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_OV_VSS2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x808089B9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VSS1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x808089BA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rbr_mo_UV_VSS2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x808089BB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x808089BC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x808089BD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x808089BE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x808089BF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x808089C0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_CAN_E_TIMEOUT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_CAN_E_TIMEOUT"
    VALUE
    0x808089C1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x808089C2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x808089C3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x808089C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x808089C5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x808089C6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x808089C7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_LIN_E_TIMEOUT_C
    "AUTOSAR: Functional unit of DTC / Check DFC_LIN_E_TIMEOUT"
    VALUE
    0x808089C8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_MultiStackTrace_Threshold_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x808089C9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_ETH_E_ACCESS_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_ETH_E_ACCESS_0"
    VALUE
    0x808089CA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "AUTOSAR: Functional unit of DTC / Check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x808089CB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "AUTOSAR: Functional unit of DTC / Check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x808089CC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_MRly_Diag_Stk_Event_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x808089CD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x808089CE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_MemDiag_MemReadErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x808089CF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_MemDiag_MemWrErr_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x808089D0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x808089D1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_T15_Diag_ComInVld_Event_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x808089D2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x808089D3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "AUTOSAR: Functional unit of DTC / Check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x808089D4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x808089D5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x808089D6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x808089D7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x808089D8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x808089D9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x808089DA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x808089DB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_22_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x808089DC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_23_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x808089DD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x808089DE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x808089DF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x808089E0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM0_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x808089E1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM10_16_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x808089E2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM10_17_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x808089E3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM10_21_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x808089E4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x808089E5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x808089E6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x808089E7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x808089E8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x808089E9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x808089EA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x808089EB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM11_9_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x808089EC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x808089ED
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x808089EE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x808089EF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x808089F0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x808089F1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x808089F2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x808089F3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_22_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x808089F4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_23_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x808089F5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x808089F6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x808089F7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x808089F8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM1_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x808089F9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM21_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x808089FA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM21_16_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x808089FB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM21_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x808089FC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x808089FD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x808089FE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x808089FF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80808A00
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80808A01
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80808A02
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_22_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80808A03
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_23_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80808A04
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80808A05
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80808A06
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80808A07
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM2_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80808A08
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80808A09
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x80808A0A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x80808A0B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80808A0C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80808A0D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80808A0E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_22_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80808A0F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_23_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80808A10
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80808A11
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80808A12
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80808A13
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM3_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80808A14
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80808A15
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80808A16
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_12_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80808A17
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80808A18
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_15_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80808A19
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_17_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x80808A1A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_18_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x80808A1B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80808A1C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_20_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80808A1D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_21_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80808A1E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_25_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80808A1F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80808A20
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_5_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80808A21
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_7_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80808A22
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM6_8_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80808A23
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80808A24
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_12_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80808A25
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80808A26
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_14_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80808A27
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_15_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80808A28
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_16_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80808A29
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_17_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80808A2A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80808A2B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_20_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80808A2C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_25_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80808A2D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_26_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80808A2E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_28_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80808A2F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_29_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80808A30
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_30_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80808A31
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM7_31_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80808A32
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80808A33
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80808A34
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_10_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80808A35
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_11_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80808A36
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_12_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80808A37
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_13_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80808A38
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_16_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80808A39
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_18_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80808A3A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80808A3B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80808A3C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_30_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80808A3D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_31_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80808A3E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM8_4_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80808A3F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM9_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80808A40
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM9_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80808A41
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM9_15_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80808A42
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MOXEMM_SMU_ALM9_3_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80808A43
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoCSOPICO_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoCSOPICO"
    VALUE
    0x80808A44
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoFVarPostBldSel_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoFVarPostBldSel"
    VALUE
    0x80808A45
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoSysCtrlReIni_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoSysCtrlReIni"
    VALUE
    0x80808A46
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTMCUFW_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80808A47
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTMonBIST_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80808A48
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTRegMonTest_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80808A49
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80808A4A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTTempSens_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80808A4B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_MoXEMMHwLTUCBCfg_C
    "AUTOSAR: Functional unit of DTC / Check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80808A4C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_OCWDAABEActv_C
    "AUTOSAR: Functional unit of DTC / Check DFC_OCWDAABEActv"
    VALUE
    0x80808A4D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_OCWDACom_C
    "AUTOSAR: Functional unit of DTC / Check DFC_OCWDACom"
    VALUE
    0x80808A4E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_OCWDAErrPin_C
    "AUTOSAR: Functional unit of DTC / Check DFC_OCWDAErrPin"
    VALUE
    0x80808A4F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_SWReset_0_C
    "AUTOSAR: Functional unit of DTC / Check DFC_SWReset_0"
    VALUE
    0x80808A50
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_SWReset_1_C
    "AUTOSAR: Functional unit of DTC / Check DFC_SWReset_1"
    VALUE
    0x80808A51
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcFuncUnit.DFC_SWReset_2_C
    "AUTOSAR: Functional unit of DTC / Check DFC_SWReset_2"
    VALUE
    0x80808A52
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_Unused_C
    "AUTOSAR: Matching DTC group / Check DFC_Unused"
    VALUE
    0x80807FD8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80c7_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80807FD9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80c8_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80c8"
    VALUE
    0x80807FDA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80c9_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80c9"
    VALUE
    0x80807FDB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ca_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ca"
    VALUE
    0x80807FDC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80cb_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80cb"
    VALUE
    0x80807FDD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80cc_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80cc"
    VALUE
    0x80807FDE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80cd_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80cd"
    VALUE
    0x80807FDF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ce_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ce"
    VALUE
    0x80807FE0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80cf_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80cf"
    VALUE
    0x80807FE1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80d0_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80d0"
    VALUE
    0x80807FE2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80d1_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80d1"
    VALUE
    0x80807FE3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80d2_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80807FE4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80d3_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80807FE5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80d4_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80807FE6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80d5_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80807FE7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80d6_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80807FE8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80d7_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80d7"
    VALUE
    0x80807FE9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80d8_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80d8"
    VALUE
    0x80807FEA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80d9_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80d9"
    VALUE
    0x80807FEB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80da_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80da"
    VALUE
    0x80807FEC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80db_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80db"
    VALUE
    0x80807FED
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80dc_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80dc"
    VALUE
    0x80807FEE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80dd_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80dd"
    VALUE
    0x80807FEF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80de_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80de"
    VALUE
    0x80807FF0
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80df_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80df"
    VALUE
    0x80807FF1
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80e0_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80e0"
    VALUE
    0x80807FF2
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80e1_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80e1"
    VALUE
    0x80807FF3
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80e2_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80807FF4
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80e3_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80807FF5
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80e4_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80807FF6
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80e5_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80807FF7
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80e6_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80807FF8
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80e7_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80e7"
    VALUE
    0x80807FF9
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80e8_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80e8"
    VALUE
    0x80807FFA
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80e9_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80e9"
    VALUE
    0x80807FFB
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ea_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ea"
    VALUE
    0x80807FFC
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80eb_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80eb"
    VALUE
    0x80807FFD
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ec_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ec"
    VALUE
    0x80807FFE
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ed_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ed"
    VALUE
    0x80807FFF
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ee_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ee"
    VALUE
    0x80808000
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ef_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ef"
    VALUE
    0x80808001
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80f0_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80f0"
    VALUE
    0x80808002
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80f1_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80f1"
    VALUE
    0x80808003
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80f2_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80808004
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80f3_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80808005
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80f4_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80808006
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80f5_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80808007
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80f6_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80f6"
    VALUE
    0x80808008
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80f7_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80f7"
    VALUE
    0x80808009
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80f8_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80f8"
    VALUE
    0x8080800A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80f9_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80f9"
    VALUE
    0x8080800B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80fa_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80fa"
    VALUE
    0x8080800C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80fb_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80fb"
    VALUE
    0x8080800D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80fc_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80fc"
    VALUE
    0x8080800E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80fd_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80fd"
    VALUE
    0x8080800F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80fe_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80fe"
    VALUE
    0x80808010
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x80ff_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x80ff"
    VALUE
    0x80808011
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8100_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8100"
    VALUE
    0x80808012
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8101_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8101"
    VALUE
    0x80808013
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8102_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8102"
    VALUE
    0x80808014
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8103_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8103"
    VALUE
    0x80808015
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8104_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8104"
    VALUE
    0x80808016
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8105_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8105"
    VALUE
    0x80808017
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8106_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8106"
    VALUE
    0x80808018
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8107_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8107"
    VALUE
    0x80808019
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8108_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8108"
    VALUE
    0x8080801A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8109_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8109"
    VALUE
    0x8080801B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x810a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x810a"
    VALUE
    0x8080801C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x810b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x810b"
    VALUE
    0x8080801D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x810c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x810c"
    VALUE
    0x8080801E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x810d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x810d"
    VALUE
    0x8080801F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x810e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x810e"
    VALUE
    0x80808020
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x810f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x810f"
    VALUE
    0x80808021
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8110_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8110"
    VALUE
    0x80808022
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8111_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8111"
    VALUE
    0x80808023
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8112_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8112"
    VALUE
    0x80808024
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8113_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8113"
    VALUE
    0x80808025
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8114_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8114"
    VALUE
    0x80808026
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8115_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8115"
    VALUE
    0x80808027
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8116_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8116"
    VALUE
    0x80808028
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8117_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8117"
    VALUE
    0x80808029
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8118_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8118"
    VALUE
    0x8080802A
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8119_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8119"
    VALUE
    0x8080802B
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x811a_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x811a"
    VALUE
    0x8080802C
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x811b_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x811b"
    VALUE
    0x8080802D
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x811c_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x811c"
    VALUE
    0x8080802E
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x811d_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x811d"
    VALUE
    0x8080802F
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x811e_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x811e"
    VALUE
    0x80808030
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x811f_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x811f"
    VALUE
    0x80808031
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8120_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8120"
    VALUE
    0x80808032
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8121_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8121"
    VALUE
    0x80808033
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8122_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8122"
    VALUE
    0x80808034
    Val_Wu8
    16.0000000000
    Dem_DTCGroup_Verb
    0.00
    16.0000000000

    FORMAT "%13.10"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DtcGroup.DFC_bds_NoDeb0x8123_C
    "AUTOSAR: Matching DTC group / Check DFC_bds_NoDeb0x8123"
    VALUE
