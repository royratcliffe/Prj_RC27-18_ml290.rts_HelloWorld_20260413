    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05OR"
    VALUE
    0x80803B0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05OT"
    VALUE
    0x80803B0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05SCB"
    VALUE
    0x80803B0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05SCG"
    VALUE
    0x80803B10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA06OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA06OL"
    VALUE
    0x80803B12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA06OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA06OR"
    VALUE
    0x80803B14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA06OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA06OT"
    VALUE
    0x80803B16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA06SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA06SCB"
    VALUE
    0x80803B18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA06SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA06SCG"
    VALUE
    0x80803B1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07OL"
    VALUE
    0x80803B1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07OT"
    VALUE
    0x80803B1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07SCB"
    VALUE
    0x80803B20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07SCG"
    VALUE
    0x80803B22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08OL"
    VALUE
    0x80803B24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08OT"
    VALUE
    0x80803B26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08SCB"
    VALUE
    0x80803B28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08SCG"
    VALUE
    0x80803B2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09OL"
    VALUE
    0x80803B2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09OR"
    VALUE
    0x80803B2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09OT"
    VALUE
    0x80803B30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09SCB"
    VALUE
    0x80803B32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09SCG"
    VALUE
    0x80803B34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10OL"
    VALUE
    0x80803B36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10OT"
    VALUE
    0x80803B38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10SCB"
    VALUE
    0x80803B3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10SCG"
    VALUE
    0x80803B3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA11OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA11OL"
    VALUE
    0x80803B3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA11OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA11OT"
    VALUE
    0x80803B40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA11SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA11SCB"
    VALUE
    0x80803B42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA11SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA11SCG"
    VALUE
    0x80803B44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA12OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA12OR"
    VALUE
    0x80803B46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA12SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA12SCB"
    VALUE
    0x80803B48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA12SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA12SCG"
    VALUE
    0x80803B4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA16OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA16OL"
    VALUE
    0x80803B4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA16OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA16OT"
    VALUE
    0x80803B4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA16SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA16SCB"
    VALUE
    0x80803B50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA16SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA16SCG"
    VALUE
    0x80803B52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17OL"
    VALUE
    0x80803B54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17OR"
    VALUE
    0x80803B56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17OT"
    VALUE
    0x80803B58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17SCB"
    VALUE
    0x80803B5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17SCG"
    VALUE
    0x80803B5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18OL"
    VALUE
    0x80803B5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18OT"
    VALUE
    0x80803B60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18SCB"
    VALUE
    0x80803B62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18SCG"
    VALUE
    0x80803B64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19OL"
    VALUE
    0x80803B66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19OR"
    VALUE
    0x80803B68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19OT"
    VALUE
    0x80803B6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19SCB"
    VALUE
    0x80803B6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19SCG"
    VALUE
    0x80803B6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20OL"
    VALUE
    0x80803B70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20OR"
    VALUE
    0x80803B72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20OT"
    VALUE
    0x80803B74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20SCB"
    VALUE
    0x80803B76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20SCG"
    VALUE
    0x80803B78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31OL"
    VALUE
    0x80803B7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31OR"
    VALUE
    0x80803B7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31OT"
    VALUE
    0x80803B7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31SCB"
    VALUE
    0x80803B80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31SCG"
    VALUE
    0x80803B82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32OL"
    VALUE
    0x80803B84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32OR"
    VALUE
    0x80803B86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32OT"
    VALUE
    0x80803B88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32SCB"
    VALUE
    0x80803B8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32SCG"
    VALUE
    0x80803B8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33OL"
    VALUE
    0x80803B8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33OR"
    VALUE
    0x80803B90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33OT"
    VALUE
    0x80803B92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33SCB"
    VALUE
    0x80803B94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33SCG"
    VALUE
    0x80803B96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34OL"
    VALUE
    0x80803B98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34OR"
    VALUE
    0x80803B9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34OT"
    VALUE
    0x80803B9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34SCB"
    VALUE
    0x80803B9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34SCG"
    VALUE
    0x80803BA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35OL"
    VALUE
    0x80803BA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35OR"
    VALUE
    0x80803BA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35OT"
    VALUE
    0x80803BA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35SCB"
    VALUE
    0x80803BA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35SCG"
    VALUE
    0x80803BAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46OL"
    VALUE
    0x80803BAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46OR"
    VALUE
    0x80803BAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46OT"
    VALUE
    0x80803BB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46SCB"
    VALUE
    0x80803BB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46SCG"
    VALUE
    0x80803BB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47OL"
    VALUE
    0x80803BB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47OR"
    VALUE
    0x80803BB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47OT"
    VALUE
    0x80803BBA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47SCB"
    VALUE
    0x80803BBC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47SCG"
    VALUE
    0x80803BBE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48OL"
    VALUE
    0x80803BC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48OR"
    VALUE
    0x80803BC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48OT"
    VALUE
    0x80803BC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48SCB"
    VALUE
    0x80803BC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48SCG"
    VALUE
    0x80803BC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA49OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA49OL"
    VALUE
    0x80803BCA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA49OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA49OT"
    VALUE
    0x80803BCC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA49SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA49SCB"
    VALUE
    0x80803BCE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA49SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA49SCG"
    VALUE
    0x80803BD0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA50OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA50OL"
    VALUE
    0x80803BD2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA50OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA50OT"
    VALUE
    0x80803BD4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA50SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA50SCB"
    VALUE
    0x80803BD6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA50SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA50SCG"
    VALUE
    0x80803BD8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51OL"
    VALUE
    0x80803BDA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51OR"
    VALUE
    0x80803BDC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51OT"
    VALUE
    0x80803BDE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51SCB"
    VALUE
    0x80803BE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51SCG"
    VALUE
    0x80803BE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52OL"
    VALUE
    0x80803BE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52OR"
    VALUE
    0x80803BE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52OT"
    VALUE
    0x80803BE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52SCB"
    VALUE
    0x80803BEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52SCG"
    VALUE
    0x80803BEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53OL"
    VALUE
    0x80803BEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53OR"
    VALUE
    0x80803BF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53OT"
    VALUE
    0x80803BF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53SCB"
    VALUE
    0x80803BF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53SCG"
    VALUE
    0x80803BF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54OL"
    VALUE
    0x80803BF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54OR"
    VALUE
    0x80803BFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54OT"
    VALUE
    0x80803BFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54SCB"
    VALUE
    0x80803BFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54SCG"
    VALUE
    0x80803C00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA55OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA55OL"
    VALUE
    0x80803C02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA55OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA55OT"
    VALUE
    0x80803C04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA55SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA55SCB"
    VALUE
    0x80803C06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA55SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA55SCG"
    VALUE
    0x80803C08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA56OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA56OL"
    VALUE
    0x80803C0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA56OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA56OT"
    VALUE
    0x80803C0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA56SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA56SCB"
    VALUE
    0x80803C0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA56SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA56SCG"
    VALUE
    0x80803C10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA58OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA58OL"
    VALUE
    0x80803C12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA58OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA58OT"
    VALUE
    0x80803C14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA58SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA58SCB"
    VALUE
    0x80803C16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA58SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA58SCG"
    VALUE
    0x80803C18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07OL"
    VALUE
    0x80803C1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07OR"
    VALUE
    0x80803C1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07OT"
    VALUE
    0x80803C1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07SCB"
    VALUE
    0x80803C20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07SCG"
    VALUE
    0x80803C22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08OL"
    VALUE
    0x80803C24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08OR"
    VALUE
    0x80803C26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08OT"
    VALUE
    0x80803C28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08SCB"
    VALUE
    0x80803C2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08SCG"
    VALUE
    0x80803C2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09OL"
    VALUE
    0x80803C2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09OR"
    VALUE
    0x80803C30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09OT"
    VALUE
    0x80803C32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09SCB"
    VALUE
    0x80803C34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09SCG"
    VALUE
    0x80803C36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12OL"
    VALUE
    0x80803C38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12OT"
    VALUE
    0x80803C3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12SCB"
    VALUE
    0x80803C3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12SCG"
    VALUE
    0x80803C3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13OL"
    VALUE
    0x80803C40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13OT"
    VALUE
    0x80803C42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13SCB"
    VALUE
    0x80803C44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13SCG"
    VALUE
    0x80803C46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14OL"
    VALUE
    0x80803C48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14OR"
    VALUE
    0x80803C4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14OT"
    VALUE
    0x80803C4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14SCB"
    VALUE
    0x80803C4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14SCG"
    VALUE
    0x80803C50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15OL"
    VALUE
    0x80803C52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15OR"
    VALUE
    0x80803C54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15OT"
    VALUE
    0x80803C56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15SCB"
    VALUE
    0x80803C58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15SCG"
    VALUE
    0x80803C5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16OL"
    VALUE
    0x80803C5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16OR"
    VALUE
    0x80803C5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16OT"
    VALUE
    0x80803C60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16SCB"
    VALUE
    0x80803C62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16SCG"
    VALUE
    0x80803C64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17OL"
    VALUE
    0x80803C66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17OR"
    VALUE
    0x80803C68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17OT"
    VALUE
    0x80803C6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17SCB"
    VALUE
    0x80803C6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17SCG"
    VALUE
    0x80803C6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK25OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK25OR"
    VALUE
    0x80803C70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK25SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK25SCB"
    VALUE
    0x80803C72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK25SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK25SCG"
    VALUE
    0x80803C74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29OL"
    VALUE
    0x80803C76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29OR"
    VALUE
    0x80803C78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29OT"
    VALUE
    0x80803C7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29SCB"
    VALUE
    0x80803C7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29SCG"
    VALUE
    0x80803C7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51OL"
    VALUE
    0x80803C80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51OT"
    VALUE
    0x80803C82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51SCB"
    VALUE
    0x80803C84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51SCG"
    VALUE
    0x80803C86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK62OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK62OR"
    VALUE
    0x80803C88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK62SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK62SCB"
    VALUE
    0x80803C8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK62SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK62SCG"
    VALUE
    0x80803C8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73OL"
    VALUE
    0x80803C8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73OR"
    VALUE
    0x80803C90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73OT"
    VALUE
    0x80803C92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73SCB"
    VALUE
    0x80803C94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73SCG"
    VALUE
    0x80803C96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK80OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK80OL"
    VALUE
    0x80803C98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK80OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK80OT"
    VALUE
    0x80803C9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK80SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK80SCB"
    VALUE
    0x80803C9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK80SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK80SCG"
    VALUE
    0x80803C9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK81OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK81OL"
    VALUE
    0x80803CA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK81OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK81OT"
    VALUE
    0x80803CA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK81SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK81SCB"
    VALUE
    0x80803CA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK81SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK81SCG"
    VALUE
    0x80803CA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK82OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK82OL"
    VALUE
    0x80803CA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK82OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK82OT"
    VALUE
    0x80803CAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK82SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK82SCB"
    VALUE
    0x80803CAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK82SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK82SCG"
    VALUE
    0x80803CAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK83OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK83OL"
    VALUE
    0x80803CB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK83OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK83OT"
    VALUE
    0x80803CB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK83SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK83SCB"
    VALUE
    0x80803CB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK83SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK83SCG"
    VALUE
    0x80803CB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK84OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK84OL"
    VALUE
    0x80803CB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK84OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK84OT"
    VALUE
    0x80803CBA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK84SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK84SCB"
    VALUE
    0x80803CBC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK84SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK84SCG"
    VALUE
    0x80803CBE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK85OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK85OL"
    VALUE
    0x80803CC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK85OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK85OT"
    VALUE
    0x80803CC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK85SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK85SCB"
    VALUE
    0x80803CC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK85SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK85SCG"
    VALUE
    0x80803CC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK86OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK86OL"
    VALUE
    0x80803CC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK86OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK86OT"
    VALUE
    0x80803CCA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK86SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK86SCB"
    VALUE
    0x80803CCC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK86SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK86SCG"
    VALUE
    0x80803CCE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK87OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK87OL"
    VALUE
    0x80803CD0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK87OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK87OT"
    VALUE
    0x80803CD2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK87SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK87SCB"
    VALUE
    0x80803CD4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK87SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK87SCG"
    VALUE
    0x80803CD6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_DSMDummy_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_DSMDummy"
    VALUE
    0x80803CD8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8000_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8000"
    VALUE
    0x80803CDA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8001_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8001"
    VALUE
    0x80803CDC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8002_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8002"
    VALUE
    0x80803CDE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8003_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8003"
    VALUE
    0x80803CE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8004_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8004"
    VALUE
    0x80803CE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8005_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8005"
    VALUE
    0x80803CE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8006_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8006"
    VALUE
    0x80803CE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8007_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8007"
    VALUE
    0x80803CE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8008_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8008"
    VALUE
    0x80803CEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8009_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8009"
    VALUE
    0x80803CEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x800a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x800a"
    VALUE
    0x80803CEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x800b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x800b"
    VALUE
    0x80803CF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x800c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x800c"
    VALUE
    0x80803CF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x800d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x800d"
    VALUE
    0x80803CF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x800e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x800e"
    VALUE
    0x80803CF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x800f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x800f"
    VALUE
    0x80803CF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8010_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8010"
    VALUE
    0x80803CFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8011_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8011"
    VALUE
    0x80803CFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8012_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8012"
    VALUE
    0x80803CFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8013_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8013"
    VALUE
    0x80803D00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8014_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8014"
    VALUE
    0x80803D02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8015_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8015"
    VALUE
    0x80803D04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8016_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8016"
    VALUE
    0x80803D06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8017_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8017"
    VALUE
    0x80803D08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8018_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8018"
    VALUE
    0x80803D0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8019_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8019"
    VALUE
    0x80803D0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x801a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x801a"
    VALUE
    0x80803D0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x801b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x801b"
    VALUE
    0x80803D10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x801c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x801c"
    VALUE
    0x80803D12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x801d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x801d"
    VALUE
    0x80803D14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x801e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x801e"
    VALUE
    0x80803D16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x801f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x801f"
    VALUE
    0x80803D18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8020_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8020"
    VALUE
    0x80803D1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8021_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8021"
    VALUE
    0x80803D1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8022_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8022"
    VALUE
    0x80803D1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8023_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8023"
    VALUE
    0x80803D20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8024_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8024"
    VALUE
    0x80803D22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8025_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8025"
    VALUE
    0x80803D24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8026_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8026"
    VALUE
    0x80803D26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8027_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8027"
    VALUE
    0x80803D28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8028_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8028"
    VALUE
    0x80803D2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8029_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8029"
    VALUE
    0x80803D2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x802a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x802a"
    VALUE
    0x80803D2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x802b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x802b"
    VALUE
    0x80803D30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x802c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x802c"
    VALUE
    0x80803D32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x802d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x802d"
    VALUE
    0x80803D34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x802e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x802e"
    VALUE
    0x80803D36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x802f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x802f"
    VALUE
    0x80803D38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8030_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8030"
    VALUE
    0x80803D3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8031_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8031"
    VALUE
    0x80803D3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8032_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8032"
    VALUE
    0x80803D3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8033_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8033"
    VALUE
    0x80803D40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8034_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8034"
    VALUE
    0x80803D42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8035_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8035"
    VALUE
    0x80803D44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8036_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8036"
    VALUE
    0x80803D46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8037_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8037"
    VALUE
    0x80803D48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8038_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8038"
    VALUE
    0x80803D4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8039_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8039"
    VALUE
    0x80803D4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x803a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x803a"
    VALUE
    0x80803D4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x803b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x803b"
    VALUE
    0x80803D50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x803c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x803c"
    VALUE
    0x80803D52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x803d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x803d"
    VALUE
    0x80803D54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x803e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x803e"
    VALUE
    0x80803D56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x803f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x803f"
    VALUE
    0x80803D58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8040_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8040"
    VALUE
    0x80803D5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8041_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8041"
    VALUE
    0x80803D5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8042_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8042"
    VALUE
    0x80803D5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8043_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8043"
    VALUE
    0x80803D60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8044_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8044"
    VALUE
    0x80803D62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8045_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8045"
    VALUE
    0x80803D64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8046_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8046"
    VALUE
    0x80803D66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8047_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8047"
    VALUE
    0x80803D68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8048_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8048"
    VALUE
    0x80803D6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8049_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8049"
    VALUE
    0x80803D6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x804a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x804a"
    VALUE
    0x80803D6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x804b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x804b"
    VALUE
    0x80803D70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x804c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x804c"
    VALUE
    0x80803D72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x804d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x804d"
    VALUE
    0x80803D74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x804e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x804e"
    VALUE
    0x80803D76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x804f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x804f"
    VALUE
    0x80803D78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8050_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8050"
    VALUE
    0x80803D7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8051_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8051"
    VALUE
    0x80803D7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8052_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8052"
    VALUE
    0x80803D7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8053_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8053"
    VALUE
    0x80803D80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8054_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8054"
    VALUE
    0x80803D82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8055_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8055"
    VALUE
    0x80803D84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8056_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8056"
    VALUE
    0x80803D86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8057_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8057"
    VALUE
    0x80803D88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8058_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8058"
    VALUE
    0x80803D8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8059_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8059"
    VALUE
    0x80803D8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x805a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x805a"
    VALUE
    0x80803D8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x805b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x805b"
    VALUE
    0x80803D90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x805c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x805c"
    VALUE
    0x80803D92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x805d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x805d"
    VALUE
    0x80803D94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x805e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x805e"
    VALUE
    0x80803D96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x805f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x805f"
    VALUE
    0x80803D98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8060_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8060"
    VALUE
    0x80803D9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8061_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8061"
    VALUE
    0x80803D9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8062_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8062"
    VALUE
    0x80803D9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8C01_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8C01"
    VALUE
    0x80803DA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8C02_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8C02"
    VALUE
    0x80803DA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8C03_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8C03"
    VALUE
    0x80803DA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetDataNoBuf_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80803DA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetDataParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetDataParam"
    VALUE
    0x80803DA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetDataboxNoInit_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80803DAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80803DAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetRxBufStatusParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80803DAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetStatusParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetStatusParam"
    VALUE
    0x80803DB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canGetTxBufStatusParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80803DB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canInitParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canInitParam"
    VALUE
    0x80803DB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canInitRxDataboxOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80803DB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canInitRxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80803DB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canInitTxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80803DBA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canIpduGroupControl_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80803DBC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canIsDataboxFreeNoInit_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80803DBE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canIsDataboxFreeParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80803DC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canIsTxEmptyParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80803DC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegBusOffCallbInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80803DC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegBusOffCallbParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80803DC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxBufInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80803DC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxBufOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80803DCA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxBufParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80803DCC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxCallbInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80803DCE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxCallbParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80803DD0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxDataboxInvNumb_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80803DD2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxDataboxInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80803DD4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxDataboxOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80803DD6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegRxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80803DD8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxBufInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80803DDA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxBufOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80803DDC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxBufParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80803DDE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxDataboxInvNumb_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80803DE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxDataboxInvState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80803DE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxDataboxOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x80803DE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canRegTxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80803DE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canResetTxBufParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80803DE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canSendDataBufOvfl_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80803DEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canSendDataParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canSendDataParam"
    VALUE
    0x80803DEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canSendDataboxNoInit_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80803DEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canSendDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80803DF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canSetTxCycleParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80803DF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canStartParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canStartParam"
    VALUE
    0x80803DF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_canStopParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_canStopParam"
    VALUE
    0x80803DF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_can_ClearIpduGroup_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80803DF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_can_ReceiveSignal_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80803DFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_can_SendSignal_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_can_SendSignal"
    VALUE
    0x80803DFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_can_SetIpduGroup_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80803DFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmDTCJ1939_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80803E00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmDelDTCJ1939_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80803E02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmDelErrors_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmDelErrors"
    VALUE
    0x80803E04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmGetDFES_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmGetDFES"
    VALUE
    0x80803E06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmGetDTCJ1939_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80803E08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmGetErrors_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmGetErrors"
    VALUE
    0x80803E0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmGetNumErrors_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80803E0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmInitQueueOverflow_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80803E0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmNumDTCJ1939_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80803E10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmTesterror_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmTesterror"
    VALUE
    0x80803E12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmUpdateDebError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80803E14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmUpdateError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmUpdateError"
    VALUE
    0x80803E16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmgetDFCStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80803E18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_dsmtestErrorDFC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80803E1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAi"
    VALUE
    0x80803E1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAic_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAic"
    VALUE
    0x80803E1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAicCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAicCfg"
    VALUE
    0x80803E20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAicGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAicGetStatus"
    VALUE
    0x80803E22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAid_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAid"
    VALUE
    0x80803E24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAidCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAidCfg"
    VALUE
    0x80803E26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAiv_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAiv"
    VALUE
    0x80803E28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAivCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAivCfg"
    VALUE
    0x80803E2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inAivGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inAivGetStatus"
    VALUE
    0x80803E2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inDi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inDi"
    VALUE
    0x80803E2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inFi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inFi"
    VALUE
    0x80803E30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inFiCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inFiCfg"
    VALUE
    0x80803E32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inFiGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inFiGetStatus"
    VALUE
    0x80803E34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inFi_Buffered_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inFi_Buffered"
    VALUE
    0x80803E36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inPhase_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inPhase"
    VALUE
    0x80803E38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inPhaseGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80803E3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inPhaseResetCounter_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80803E3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inRi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inRi"
    VALUE
    0x80803E3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inRiCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inRiCfg"
    VALUE
    0x80803E40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inRiCfgTemp_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x80803E42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inRiGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inRiGetStatus"
    VALUE
    0x80803E44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inRiGetTemp_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inRiGetTemp"
    VALUE
    0x80803E46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentCopyFDFifo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80803E48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentDisable_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentDisable"
    VALUE
    0x80803E4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentEnable_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentEnable"
    VALUE
    0x80803E4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentGetErrorStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80803E4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentGetFD_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentGetFD"
    VALUE
    0x80803E50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentGetSD_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentGetSD"
    VALUE
    0x80803E52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentGetSDDatabox_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80803E54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentGetStatus"
    VALUE
    0x80803E56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentInitSDDatabox_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80803E58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentRegisterCopyFDFifo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80803E5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentRegisterFDFifo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x80803E5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inSentRegisterSDDataboxes_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x80803E5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusCanRxBufferOverflow_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x80803E60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusGetCaAddrParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x80803E62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusGetDiagnosticParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x80803E64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x80803E66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusGetStatusParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80803E68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitCommCaMissing_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80803E6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitCommParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80803E6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitCommState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitCommState"
    VALUE
    0x80803E6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitDiagnosticParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80803E70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitFailureListParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80803E72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitRxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80803E74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusInitTxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80803E76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegRxDataboxOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80803E78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegRxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80803E7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegRxDataboxState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80803E7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegTxDataboxOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80803E7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegTxDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80803E80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegTxDataboxState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80803E82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x80803E84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegisterInstancesOverlap_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x80803E86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegisterInstancesParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80803E88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusRegisterInstancesState_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80803E8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSendDataboxParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80803E8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSendRequestPGNParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80803E8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaAddrCaUsed_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80803E90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaAddrComm_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80803E92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaAddrInvCan_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80803E94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaAddrParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80803E96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaInfoParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80803E98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSetCaNameParam_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80803E9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_isobusSftyCanTxErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80803E9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_ReceiveSignal_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80803E9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_SendSignal_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_SendSignal"
    VALUE
    0x80803EA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_getStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_getStatus"
    VALUE
    0x80803EA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_gotoSleep_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80803EA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_scheduleRequest_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80803EA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_lin_wakeUp_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_lin_wakeUp"
    VALUE
    0x80803EA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memFlsCfgShr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80803EAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memGetStatus"
    VALUE
    0x80803EAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memMarkBlock_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memMarkBlock"
    VALUE
    0x80803EAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadApi1Error_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80803EB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadApi2Error_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80803EB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadBlock_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadBlock"
    VALUE
    0x80803EB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadCalibInputError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80803EB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadCalibOuputError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80803EB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memReadSystemError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memReadSystemError"
    VALUE
    0x80803EBA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_memWriteBlock_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_memWriteBlock"
    VALUE
    0x80803EBC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_moOV_FirstConstADC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80803EBE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_moOV_SecondConstADC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80803EC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_moUV_FirstConstADC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80803EC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_moUV_SecondConstADC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80803EC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_INH_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_INH"
    VALUE
    0x80803EC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_INHLatch_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_INHLatch"
    VALUE
    0x80803EC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_adcPDD_fail_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80803ECA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_memoryProtection_err_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80803ECC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02OC"
    VALUE
    0x80803ECE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02Unintended"
    VALUE
    0x80803ED0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03OC"
    VALUE
    0x80803ED2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03Unintended"
    VALUE
    0x80803ED4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04OC"
    VALUE
    0x80803ED6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04Unintended"
    VALUE
    0x80803ED8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05OC"
    VALUE
    0x80803EDA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05Unintended"
    VALUE
    0x80803EDC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07OC"
    VALUE
    0x80803EDE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA07Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA07Unintended"
    VALUE
    0x80803EE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08OC"
    VALUE
    0x80803EE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA08Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA08Unintended"
    VALUE
    0x80803EE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09OC"
    VALUE
    0x80803EE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA09Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA09Unintended"
    VALUE
    0x80803EE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10OC"
    VALUE
    0x80803EEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA10Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA10Unintended"
    VALUE
    0x80803EEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17OC"
    VALUE
    0x80803EEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA17Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA17Unintended"
    VALUE
    0x80803EF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18OC"
    VALUE
    0x80803EF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA18Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA18Unintended"
    VALUE
    0x80803EF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19OC"
    VALUE
    0x80803EF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA19Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA19Unintended"
    VALUE
    0x80803EF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20OC"
    VALUE
    0x80803EFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA20Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA20Unintended"
    VALUE
    0x80803EFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31OC"
    VALUE
    0x80803EFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA31Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA31Unintended"
    VALUE
    0x80803F00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32OC"
    VALUE
    0x80803F02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA32Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA32Unintended"
    VALUE
    0x80803F04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33OC"
    VALUE
    0x80803F06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA33Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA33Unintended"
    VALUE
    0x80803F08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34OC"
    VALUE
    0x80803F0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA34Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA34Unintended"
    VALUE
    0x80803F0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35OC"
    VALUE
    0x80803F0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA35Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA35Unintended"
    VALUE
    0x80803F10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46OC"
    VALUE
    0x80803F12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA46Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA46Unintended"
    VALUE
    0x80803F14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47OC"
    VALUE
    0x80803F16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA47Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA47Unintended"
    VALUE
    0x80803F18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48OC"
    VALUE
    0x80803F1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA48Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA48Unintended"
    VALUE
    0x80803F1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51OC"
    VALUE
    0x80803F1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA51Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA51Unintended"
    VALUE
    0x80803F20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52OC"
    VALUE
    0x80803F22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA52Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA52Unintended"
    VALUE
    0x80803F24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53OC"
    VALUE
    0x80803F26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA53Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA53Unintended"
    VALUE
    0x80803F28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54OC"
    VALUE
    0x80803F2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA54Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA54Unintended"
    VALUE
    0x80803F2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAov_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAov"
    VALUE
    0x80803F2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAovCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAovCfg"
    VALUE
    0x80803F30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAovCfgPI_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAovCfgPI"
    VALUE
    0x80803F32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAovGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAovGetStatus"
    VALUE
    0x80803F34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAovGetVoltage_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80803F36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outAovResetError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outAovResetError"
    VALUE
    0x80803F38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDo"
    VALUE
    0x80803F3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDoCfgPwrLs_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80803F3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDoDisable_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDoDisable"
    VALUE
    0x80803F3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDoGetCurrent_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80803F40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDoGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDoGetStatus"
    VALUE
    0x80803F42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outDoResetError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outDoResetError"
    VALUE
    0x80803F44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07OC"
    VALUE
    0x80803F46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK07Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK07Unintended"
    VALUE
    0x80803F48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08OC"
    VALUE
    0x80803F4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK08Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK08Unintended"
    VALUE
    0x80803F4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09OC"
    VALUE
    0x80803F4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK09Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK09Unintended"
    VALUE
    0x80803F50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12OC"
    VALUE
    0x80803F52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK12Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK12Unintended"
    VALUE
    0x80803F54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13OC"
    VALUE
    0x80803F56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK13Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK13Unintended"
    VALUE
    0x80803F58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14OC"
    VALUE
    0x80803F5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK14Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK14Unintended"
    VALUE
    0x80803F5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15OC"
    VALUE
    0x80803F5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK15Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK15Unintended"
    VALUE
    0x80803F60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16OC"
    VALUE
    0x80803F62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK16Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK16Unintended"
    VALUE
    0x80803F64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17OC"
    VALUE
    0x80803F66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK17Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK17Unintended"
    VALUE
    0x80803F68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29OC"
    VALUE
    0x80803F6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK29Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK29Unintended"
    VALUE
    0x80803F6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51OC"
    VALUE
    0x80803F6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK51Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK51Unintended"
    VALUE
    0x80803F70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73OC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73OC"
    VALUE
    0x80803F72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outK73Unintended_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outK73Unintended"
    VALUE
    0x80803F74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPo"
    VALUE
    0x80803F76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoCfg"
    VALUE
    0x80803F78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoCfgPeriod_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80803F7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoCfgPwrLs_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80803F7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoDisable_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoDisable"
    VALUE
    0x80803F7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoGetCurrent_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80803F80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoGetStatus"
    VALUE
    0x80803F82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoResetError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoResetError"
    VALUE
    0x80803F84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPoc_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPoc"
    VALUE
    0x80803F86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPocCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPocCfg"
    VALUE
    0x80803F88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPocCfgDither_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPocCfgDither"
    VALUE
    0x80803F8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPocCfgPI_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPocCfgPI"
    VALUE
    0x80803F8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPod_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPod"
    VALUE
    0x80803F8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPodCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPodCfg"
    VALUE
    0x80803F90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outPodCfgPeriod_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80803F92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_rsmFfiApiCallErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80803F94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safout_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safout"
    VALUE
    0x80803F96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutCfg"
    VALUE
    0x80803F98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl1"
    VALUE
    0x80803F9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl10"
    VALUE
    0x80803F9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl10Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80803F9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl10OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80803FA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl11"
    VALUE
    0x80803FA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl11Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80803FA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl11OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80803FA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl12_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl12"
    VALUE
    0x80803FA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl12Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80803FAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl12OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80803FAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl13"
    VALUE
    0x80803FAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl13Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80803FB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl13OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80803FB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl14"
    VALUE
    0x80803FB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl14Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80803FB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl14OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80803FB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl15_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl15"
    VALUE
    0x80803FBA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl15Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80803FBC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl15OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80803FBE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl16_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl16"
    VALUE
    0x80803FC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl16Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80803FC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl16OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80803FC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl17_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl17"
    VALUE
    0x80803FC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl17Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80803FC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl17OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80803FCA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl18_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl18"
    VALUE
    0x80803FCC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl18Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80803FCE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl18OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80803FD0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl1Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80803FD2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl1OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80803FD4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl2"
    VALUE
    0x80803FD6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl2Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80803FD8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl2OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80803FDA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl3"
    VALUE
    0x80803FDC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl3Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80803FDE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl3OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80803FE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl4"
    VALUE
    0x80803FE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl4Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x80803FE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl4OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80803FE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl5"
    VALUE
    0x80803FE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl5Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80803FEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl5OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80803FEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl6"
    VALUE
    0x80803FEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl6Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80803FF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl6OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80803FF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl7"
    VALUE
    0x80803FF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl7Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80803FF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl7OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80803FF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl8"
    VALUE
    0x80803FFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl8Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80803FFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl8OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80803FFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl9_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl9"
    VALUE
    0x80804000
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl9Dev_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80804002
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutChnl9OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x80804004
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutDevError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutDevError"
    VALUE
    0x80804006
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutGetStatus_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutGetStatus"
    VALUE
    0x80804008
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutIgnoreError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x8080400A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutResetError_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutResetError"
    VALUE
    0x8080400C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safoutUnlock_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safoutUnlock"
    VALUE
    0x8080400E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_safout_cfgDiag_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80804010
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secAccessDenied_RC_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80804012
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secAccessDenied_WDBI_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80804014
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secEvalRespKey_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secEvalRespKey"
    VALUE
    0x80804016
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secFlashingFailure_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secFlashingFailure"
    VALUE
    0x80804018
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secGetLevel_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secGetLevel"
    VALUE
    0x8080401A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secGetRnd_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secGetRnd"
    VALUE
    0x8080401C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secGetSeed_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secGetSeed"
    VALUE
    0x8080401E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secInvalidPassword_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secInvalidPassword"
    VALUE
    0x80804020
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secIsRequestAllowed_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80804022
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secResetLevel_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secResetLevel"
    VALUE
    0x80804024
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secSaveSecret_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secSaveSecret"
    VALUE
    0x80804026
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_secSetLevel_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_secSetLevel"
    VALUE
    0x80804028
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysAit_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysAit"
    VALUE
    0x8080402A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysAiv_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysAiv"
    VALUE
    0x8080402C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysDi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysDi"
    VALUE
    0x8080402E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysDo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysDo"
    VALUE
    0x80804030
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysGetVss_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysGetVss"
    VALUE
    0x80804032
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysInit_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysInit"
    VALUE
    0x80804034
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysOperHrIntegrityErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80804036
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysOperHrsSaturated_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80804038
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sysSetVss_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sysSetVss"
    VALUE
    0x8080403A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sys_coreload_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sys_coreload"
    VALUE
    0x8080403C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_sys_taskload_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_sys_taskload"
    VALUE
    0x8080403E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VSS1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80804040
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VSS2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80804042
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VSS1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80804044
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VSS2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x80804046
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80804048
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x8080404A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x8080404C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x8080404E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80804050
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_CAN_E_TIMEOUT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80804052
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80804054
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80804056
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80804058
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x8080405A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x8080405C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x8080405E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_LIN_E_TIMEOUT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80804060
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_MultiStackTrace_Threshold_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80804062
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_ETH_E_ACCESS_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x80804064
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x80804066
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80804068
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_MRly_Diag_Stk_Event_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x8080406A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x8080406C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_MemDiag_MemReadErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x8080406E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_MemDiag_MemWrErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80804070
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80804072
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_T15_Diag_ComInVld_Event_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80804074
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80804076
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80804078
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x8080407A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x8080407C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x8080407E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80804080
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80804082
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x80804084
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x80804086
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_22_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80804088
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_23_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x8080408A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x8080408C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x8080408E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80804090
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM0_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80804092
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM10_16_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80804094
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM10_17_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80804096
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM10_21_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80804098
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x8080409A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x8080409C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x8080409E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x808040A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x808040A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x808040A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x808040A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM11_9_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x808040A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x808040AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x808040AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x808040AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x808040B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x808040B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x808040B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x808040B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_22_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x808040B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_23_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x808040BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x808040BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x808040BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x808040C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM1_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x808040C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM21_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x808040C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM21_16_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x808040C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM21_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x808040C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x808040CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x808040CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x808040CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x808040D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x808040D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x808040D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_22_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x808040D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_23_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x808040D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x808040DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x808040DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x808040DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM2_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x808040E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x808040E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x808040E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x808040E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x808040E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x808040EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x808040EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_22_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x808040EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_23_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x808040F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x808040F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x808040F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x808040F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM3_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x808040F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x808040FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x808040FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_12_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x808040FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80804100
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_15_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80804102
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_17_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x80804104
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_18_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x80804106
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80804108
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_20_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x8080410A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_21_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x8080410C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_25_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x8080410E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80804110
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80804112
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80804114
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM6_8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80804116
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80804118
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_12_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x8080411A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x8080411C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_14_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x8080411E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_15_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80804120
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_16_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80804122
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_17_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80804124
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80804126
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_20_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80804128
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_25_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x8080412A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_26_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x8080412C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_28_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x8080412E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_29_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80804130
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_30_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80804132
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM7_31_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80804134
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80804136
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80804138
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_10_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x8080413A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_11_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x8080413C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_12_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x8080413E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_13_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80804140
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_16_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80804142
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_18_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80804144
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80804146
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80804148
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_30_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x8080414A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_31_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x8080414C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM8_4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x8080414E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM9_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80804150
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM9_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80804152
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM9_15_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80804154
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MOXEMM_SMU_ALM9_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80804156
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoCSOPICO_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoCSOPICO"
    VALUE
    0x80804158
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoFVarPostBldSel_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoFVarPostBldSel"
    VALUE
    0x8080415A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoSysCtrlReIni_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoSysCtrlReIni"
    VALUE
    0x8080415C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTMCUFW_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x8080415E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTMonBIST_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80804160
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTRegMonTest_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80804162
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80804164
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTTempSens_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80804166
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_MoXEMMHwLTUCBCfg_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80804168
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_OCWDAABEActv_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_OCWDAABEActv"
    VALUE
    0x8080416A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_OCWDACom_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_OCWDACom"
    VALUE
    0x8080416C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_OCWDAErrPin_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_OCWDAErrPin"
    VALUE
    0x8080416E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_SWReset_0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_SWReset_0"
    VALUE
    0x80804170
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_SWReset_1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_SWReset_1"
    VALUE
    0x80804172
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_SWReset_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_SWReset_2"
    VALUE
    0x80804174
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_Unused_C
    "OBD specific trouble code / "
    VALUE
    0x808051BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80c7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80c7"
    VALUE
    0x808051BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80c8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80c8"
    VALUE
    0x808051BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80c9_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80c9"
    VALUE
    0x808051C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ca_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ca"
    VALUE
    0x808051C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80cb_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80cb"
    VALUE
    0x808051C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80cc_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80cc"
    VALUE
    0x808051C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80cd_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80cd"
    VALUE
    0x808051C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ce_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ce"
    VALUE
    0x808051CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80cf_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80cf"
    VALUE
    0x808051CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80d0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80d0"
    VALUE
    0x808051CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80d1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80d1"
    VALUE
    0x808051D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80d2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80d2"
    VALUE
    0x808051D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80d3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80d3"
    VALUE
    0x808051D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80d4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80d4"
    VALUE
    0x808051D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80d5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80d5"
    VALUE
    0x808051D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80d6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80d6"
    VALUE
    0x808051DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80d7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80d7"
    VALUE
    0x808051DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80d8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80d8"
    VALUE
    0x808051DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80d9_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80d9"
    VALUE
    0x808051E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80da_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80da"
    VALUE
    0x808051E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80db_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80db"
    VALUE
    0x808051E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80dc_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80dc"
    VALUE
    0x808051E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80dd_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80dd"
    VALUE
    0x808051E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80de_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80de"
    VALUE
    0x808051EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80df_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80df"
    VALUE
    0x808051EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80e0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80e0"
    VALUE
    0x808051EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80e1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80e1"
    VALUE
    0x808051F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80e2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80e2"
    VALUE
    0x808051F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80e3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80e3"
    VALUE
    0x808051F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80e4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80e4"
    VALUE
    0x808051F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80e5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80e5"
    VALUE
    0x808051F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80e6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80e6"
    VALUE
    0x808051FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80e7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80e7"
    VALUE
    0x808051FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80e8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80e8"
    VALUE
    0x808051FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80e9_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80e9"
    VALUE
    0x80805200
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ea_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ea"
    VALUE
    0x80805202
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80eb_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80eb"
    VALUE
    0x80805204
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ec_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ec"
    VALUE
    0x80805206
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ed_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ed"
    VALUE
    0x80805208
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ee_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ee"
    VALUE
    0x8080520A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ef_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ef"
    VALUE
    0x8080520C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80f0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80f0"
    VALUE
    0x8080520E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80f1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80f1"
    VALUE
    0x80805210
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80f2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80805212
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80f3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80805214
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80f4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80805216
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80f5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80805218
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80f6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80f6"
    VALUE
    0x8080521A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80f7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80f7"
    VALUE
    0x8080521C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80f8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80f8"
    VALUE
    0x8080521E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80f9_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80f9"
    VALUE
    0x80805220
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80fa_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80fa"
    VALUE
    0x80805222
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80fb_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80fb"
    VALUE
    0x80805224
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80fc_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80fc"
    VALUE
    0x80805226
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80fd_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80fd"
    VALUE
    0x80805228
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80fe_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80fe"
    VALUE
    0x8080522A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ff_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ff"
    VALUE
    0x8080522C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8100_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8100"
    VALUE
    0x8080522E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8101_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8101"
    VALUE
    0x80805230
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8102_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8102"
    VALUE
    0x80805232
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8103_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8103"
    VALUE
    0x80805234
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8104_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8104"
    VALUE
    0x80805236
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8105_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8105"
    VALUE
    0x80805238
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8106_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8106"
    VALUE
    0x8080523A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8107_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8107"
    VALUE
    0x8080523C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8108_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8108"
    VALUE
    0x8080523E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8109_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8109"
    VALUE
    0x80805240
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x810a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x810a"
    VALUE
    0x80805242
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x810b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x810b"
    VALUE
    0x80805244
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x810c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x810c"
    VALUE
    0x80805246
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x810d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x810d"
    VALUE
    0x80805248
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x810e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x810e"
    VALUE
    0x8080524A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x810f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x810f"
    VALUE
    0x8080524C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8110_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8110"
    VALUE
    0x8080524E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8111_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8111"
    VALUE
    0x80805250
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8112_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8112"
    VALUE
    0x80805252
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8113_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8113"
    VALUE
    0x80805254
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8114_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8114"
    VALUE
    0x80805256
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8115_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8115"
    VALUE
    0x80805258
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8116_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8116"
    VALUE
    0x8080525A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8117_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8117"
    VALUE
    0x8080525C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8118_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8118"
    VALUE
    0x8080525E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8119_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8119"
    VALUE
    0x80805260
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x811a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x811a"
    VALUE
    0x80805262
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x811b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x811b"
    VALUE
    0x80805264
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x811c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x811c"
    VALUE
    0x80805266
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x811d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x811d"
    VALUE
    0x80805268
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x811e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x811e"
    VALUE
    0x8080526A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x811f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x811f"
    VALUE
    0x8080526C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8120_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8120"
    VALUE
    0x8080526E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8121_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8121"
    VALUE
    0x80805270
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8122_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8122"
    VALUE
    0x80805272
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8123_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8123"
    VALUE
    0x80805274
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8124_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8124"
    VALUE
    0x80805276
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8125_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8125"
    VALUE
    0x80805278
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8126_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8126"
    VALUE
    0x8080527A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8127_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8127"
    VALUE
    0x8080527C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8128_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8128"
    VALUE
    0x8080527E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8129_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8129"
    VALUE
    0x80805280
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x812a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x812a"
    VALUE
    0x80805282
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_TiInRow0x8B01_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_TiInRow0x8B01"
    VALUE
    0x80805284
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_TiInRow0x8B02_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_TiInRow0x8B02"
    VALUE
    0x80805286
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_TiInRow0x8B03_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_TiInRow0x8B03"
    VALUE
    0x80805288
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_DevLibBattUHi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_DevLibBattUHi"
    VALUE
    0x8080528A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_DevLibBattULo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_DevLibBattULo"
    VALUE
    0x8080528C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8063_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8063"
    VALUE
    0x8080528E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8064_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8064"
    VALUE
    0x80805290
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8065_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8065"
    VALUE
    0x80805292
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8066_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8066"
    VALUE
    0x80805294
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8067_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8067"
    VALUE
    0x80805296
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8068_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8068"
    VALUE
    0x80805298
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8069_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8069"
    VALUE
    0x8080529A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x806a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x806a"
    VALUE
    0x8080529C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x806b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x806b"
    VALUE
    0x8080529E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x806c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x806c"
    VALUE
    0x808052A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x806d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x806d"
    VALUE
    0x808052A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x806e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x806e"
    VALUE
    0x808052A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x806f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x806f"
    VALUE
    0x808052A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8070_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8070"
    VALUE
    0x808052A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8071_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8071"
    VALUE
    0x808052AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8072_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8072"
    VALUE
    0x808052AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8073_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8073"
    VALUE
    0x808052AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8074_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8074"
    VALUE
    0x808052B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8075_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8075"
    VALUE
    0x808052B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8076_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8076"
    VALUE
    0x808052B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8077_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8077"
    VALUE
    0x808052B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8078_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8078"
    VALUE
    0x808052B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8079_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8079"
    VALUE
    0x808052BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x807a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x807a"
    VALUE
    0x808052BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x807b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x807b"
    VALUE
    0x808052BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x807c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x807c"
    VALUE
    0x808052C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x807d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x807d"
    VALUE
    0x808052C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x807e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x807e"
    VALUE
    0x808052C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x807f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x807f"
    VALUE
    0x808052C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8080_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8080"
    VALUE
    0x808052C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8081_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8081"
    VALUE
    0x808052CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8082_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8082"
    VALUE
    0x808052CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8083_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8083"
    VALUE
    0x808052CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8084_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8084"
    VALUE
    0x808052D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8085_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8085"
    VALUE
    0x808052D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8086_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8086"
    VALUE
    0x808052D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8087_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8087"
    VALUE
    0x808052D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8088_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8088"
    VALUE
    0x808052D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8089_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8089"
    VALUE
    0x808052DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x808a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x808a"
    VALUE
    0x808052DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x808b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x808b"
    VALUE
    0x808052DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x808c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x808c"
    VALUE
    0x808052E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x808d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x808d"
    VALUE
    0x808052E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x808e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x808e"
    VALUE
    0x808052E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x808f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x808f"
    VALUE
    0x808052E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8090_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8090"
    VALUE
    0x808052E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8091_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8091"
    VALUE
    0x808052EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8092_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8092"
    VALUE
    0x808052EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8093_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8093"
    VALUE
    0x808052EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8094_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8094"
    VALUE
    0x808052F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8095_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8095"
    VALUE
    0x808052F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8096_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8096"
    VALUE
    0x808052F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8097_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8097"
    VALUE
    0x808052F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8098_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8098"
    VALUE
    0x808052F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8099_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8099"
    VALUE
    0x808052FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x809a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x809a"
    VALUE
    0x808052FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x809b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x809b"
    VALUE
    0x808052FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x809c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x809c"
    VALUE
    0x80805300
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x809d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x809d"
    VALUE
    0x80805302
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x809e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x809e"
    VALUE
    0x80805304
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x809f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x809f"
    VALUE
    0x80805306
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80a0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80a0"
    VALUE
    0x80805308
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80a1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80a1"
    VALUE
    0x8080530A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80a2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80a2"
    VALUE
    0x8080530C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80a3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80a3"
    VALUE
    0x8080530E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80a4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80a4"
    VALUE
    0x80805310
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80a5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80805312
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80a6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80a6"
    VALUE
    0x80805314
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80a7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80a7"
    VALUE
    0x80805316
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80a8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80a8"
    VALUE
    0x80805318
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80a9_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80a9"
    VALUE
    0x8080531A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80aa_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80aa"
    VALUE
    0x8080531C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ab_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ab"
    VALUE
    0x8080531E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ac_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ac"
    VALUE
    0x80805320
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ad_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ad"
    VALUE
    0x80805322
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ae_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ae"
    VALUE
    0x80805324
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80af_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80af"
    VALUE
    0x80805326
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80b0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80b0"
    VALUE
    0x80805328
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80b1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80b1"
    VALUE
    0x8080532A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80b2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80b2"
    VALUE
    0x8080532C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80b3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80b3"
    VALUE
    0x8080532E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80b4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80b4"
    VALUE
    0x80805330
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80b5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80b5"
    VALUE
    0x80805332
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80b6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80b6"
    VALUE
    0x80805334
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80b7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80b7"
    VALUE
    0x80805336
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80b8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80b8"
    VALUE
    0x80805338
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80b9_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80b9"
    VALUE
    0x8080533A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80ba_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80ba"
    VALUE
    0x8080533C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80bb_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80bb"
    VALUE
    0x8080533E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80bc_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80bc"
    VALUE
    0x80805340
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80bd_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80bd"
    VALUE
    0x80805342
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80be_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80be"
    VALUE
    0x80805344
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80bf_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80bf"
    VALUE
    0x80805346
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80c0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80c0"
    VALUE
    0x80805348
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80c1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80c1"
    VALUE
    0x8080534A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80c2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80c2"
    VALUE
    0x8080534C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80c3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80c3"
    VALUE
    0x8080534E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80c4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80c4"
    VALUE
    0x80805350
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80c5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80c5"
    VALUE
    0x80805352
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x80c6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x80c6"
    VALUE
    0x80805354
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_TiUpDwn0x8A01_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x80805356
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_TiUpDwn0x8A02_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x80805358
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_TiUpDwn0x8A03_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x8080535A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA13OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA13OR"
    VALUE
    0x8080535C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA13SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA13SCB"
    VALUE
    0x8080535E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA13SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA13SCG"
    VALUE
    0x80805360
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA14OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA14OR"
    VALUE
    0x80805362
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA14SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA14SCB"
    VALUE
    0x80805364
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA14SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA14SCG"
    VALUE
    0x80805366
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA21OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA21OR"
    VALUE
    0x80805368
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA21SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA21SCB"
    VALUE
    0x8080536A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA21SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA21SCG"
    VALUE
    0x8080536C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA22OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA22OR"
    VALUE
    0x8080536E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA22SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA22SCB"
    VALUE
    0x80805370
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA22SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA22SCG"
    VALUE
    0x80805372
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA23OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA23OR"
    VALUE
    0x80805374
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA23SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA23SCB"
    VALUE
    0x80805376
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA23SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA23SCG"
    VALUE
    0x80805378
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA24OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA24OR"
    VALUE
    0x8080537A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA24SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA24SCB"
    VALUE
    0x8080537C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA24SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA24SCG"
    VALUE
    0x8080537E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA25OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA25OR"
    VALUE
    0x80805380
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA25SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA25SCB"
    VALUE
    0x80805382
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA25SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA25SCG"
    VALUE
    0x80805384
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA26OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA26OR"
    VALUE
    0x80805386
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA26SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA26SCB"
    VALUE
    0x80805388
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA26SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA26SCG"
    VALUE
    0x8080538A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA27OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA27OR"
    VALUE
    0x8080538C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA27SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA27SCB"
    VALUE
    0x8080538E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA27SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA27SCG"
    VALUE
    0x80805390
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA28OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA28OR"
    VALUE
    0x80805392
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA28SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA28SCB"
    VALUE
    0x80805394
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA28SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA28SCG"
    VALUE
    0x80805396
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA29OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA29OR"
    VALUE
    0x80805398
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA29SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA29SCB"
    VALUE
    0x8080539A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA29SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA29SCG"
    VALUE
    0x8080539C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36AicSCB"
    VALUE
    0x8080539E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36AicSCG"
    VALUE
    0x808053A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36OR"
    VALUE
    0x808053A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36SCB"
    VALUE
    0x808053A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36SCG"
    VALUE
    0x808053A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA36ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x808053A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37AicSCB"
    VALUE
    0x808053AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37AicSCG"
    VALUE
    0x808053AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37OR"
    VALUE
    0x808053AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37SCB"
    VALUE
    0x808053B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37SCG"
    VALUE
    0x808053B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA37ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x808053B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38AicSCB"
    VALUE
    0x808053B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38AicSCG"
    VALUE
    0x808053B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38OR"
    VALUE
    0x808053BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38SCB"
    VALUE
    0x808053BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38SCG"
    VALUE
    0x808053BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA38ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x808053C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39AicSCB"
    VALUE
    0x808053C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39AicSCG"
    VALUE
    0x808053C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39OR"
    VALUE
    0x808053C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39SCB"
    VALUE
    0x808053C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39SCG"
    VALUE
    0x808053CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA39ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x808053CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA40OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA40OR"
    VALUE
    0x808053CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA40SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA40SCB"
    VALUE
    0x808053D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA40SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA40SCG"
    VALUE
    0x808053D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA41OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA41OR"
    VALUE
    0x808053D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA41SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA41SCB"
    VALUE
    0x808053D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA41SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA41SCG"
    VALUE
    0x808053D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA42OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA42OR"
    VALUE
    0x808053DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA42SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA42SCB"
    VALUE
    0x808053DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA42SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA42SCG"
    VALUE
    0x808053DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43AicSCB"
    VALUE
    0x808053E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43AicSCG"
    VALUE
    0x808053E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43OR"
    VALUE
    0x808053E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43SCB"
    VALUE
    0x808053E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43SCG"
    VALUE
    0x808053E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA43ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x808053EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA44OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA44OL"
    VALUE
    0x808053EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA44SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA44SCB"
    VALUE
    0x808053EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA44SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA44SCG"
    VALUE
    0x808053F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA57OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA57OR"
    VALUE
    0x808053F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA57SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA57SCB"
    VALUE
    0x808053F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA57SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA57SCG"
    VALUE
    0x808053F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA59OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA59OL"
    VALUE
    0x808053F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA59SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA59SCB"
    VALUE
    0x808053FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inA59SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inA59SCG"
    VALUE
    0x808053FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK10OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK10OR"
    VALUE
    0x808053FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK10SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK10SCB"
    VALUE
    0x80805400
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK10SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK10SCG"
    VALUE
    0x80805402
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK11OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK11OR"
    VALUE
    0x80805404
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK11SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK11SCB"
    VALUE
    0x80805406
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK11SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK11SCG"
    VALUE
    0x80805408
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30AicSCB"
    VALUE
    0x8080540A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30AicSCG"
    VALUE
    0x8080540C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30OR"
    VALUE
    0x8080540E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30SCB"
    VALUE
    0x80805410
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30SCG"
    VALUE
    0x80805412
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK30ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80805414
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK31OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK31OR"
    VALUE
    0x80805416
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK31SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK31SCB"
    VALUE
    0x80805418
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK31SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK31SCG"
    VALUE
    0x8080541A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK32OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK32OR"
    VALUE
    0x8080541C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK32SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK32SCB"
    VALUE
    0x8080541E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK32SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK32SCG"
    VALUE
    0x80805420
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK33OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK33OR"
    VALUE
    0x80805422
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK33SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK33SCB"
    VALUE
    0x80805424
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK33SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK33SCG"
    VALUE
    0x80805426
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK34OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK34OR"
    VALUE
    0x80805428
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK34SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK34SCB"
    VALUE
    0x8080542A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK34SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK34SCG"
    VALUE
    0x8080542C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK35OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK35OR"
    VALUE
    0x8080542E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK35SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK35SCB"
    VALUE
    0x80805430
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK35SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK35SCG"
    VALUE
    0x80805432
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK36OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK36OR"
    VALUE
    0x80805434
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK36SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK36SCB"
    VALUE
    0x80805436
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK36SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK36SCG"
    VALUE
    0x80805438
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37AicSCB"
    VALUE
    0x8080543A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37AicSCG"
    VALUE
    0x8080543C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37OR"
    VALUE
    0x8080543E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37SCB"
    VALUE
    0x80805440
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37SCG"
    VALUE
    0x80805442
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK37ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80805444
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80805446
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80805448
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38OR"
    VALUE
    0x8080544A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38SCB"
    VALUE
    0x8080544C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38SCG"
    VALUE
    0x8080544E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK38ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80805450
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39AicSCB"
    VALUE
    0x80805452
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80805454
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39OR"
    VALUE
    0x80805456
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39SCB"
    VALUE
    0x80805458
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39SCG"
    VALUE
    0x8080545A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK39ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x8080545C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40AicSCB"
    VALUE
    0x8080545E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80805460
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40OR"
    VALUE
    0x80805462
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40SCB"
    VALUE
    0x80805464
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40SCG"
    VALUE
    0x80805466
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK40ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80805468
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41AicSCB"
    VALUE
    0x8080546A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41AicSCG"
    VALUE
    0x8080546C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41OR"
    VALUE
    0x8080546E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41SCB"
    VALUE
    0x80805470
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41SCG"
    VALUE
    0x80805472
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK41ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80805474
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42AicSCB"
    VALUE
    0x80805476
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42AicSCG"
    VALUE
    0x80805478
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42OR"
    VALUE
    0x8080547A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42SCB"
    VALUE
    0x8080547C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42SCG"
    VALUE
    0x8080547E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK42ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80805480
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK43OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK43OR"
    VALUE
    0x80805482
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK43SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK43SCB"
    VALUE
    0x80805484
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK43SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK43SCG"
    VALUE
    0x80805486
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80805488
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44AicSCG"
    VALUE
    0x8080548A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44OR"
    VALUE
    0x8080548C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44SCB"
    VALUE
    0x8080548E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44SCG"
    VALUE
    0x80805490
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK44ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80805492
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45AicSCB"
    VALUE
    0x80805494
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45AicSCG"
    VALUE
    0x80805496
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45OR"
    VALUE
    0x80805498
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45SCB"
    VALUE
    0x8080549A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45SCG"
    VALUE
    0x8080549C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK45ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x8080549E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK52OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK52OR"
    VALUE
    0x808054A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK52SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK52SCB"
    VALUE
    0x808054A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK52SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK52SCG"
    VALUE
    0x808054A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK53OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK53OR"
    VALUE
    0x808054A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK53SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK53SCB"
    VALUE
    0x808054A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK53SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK53SCG"
    VALUE
    0x808054AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54AicSCB"
    VALUE
    0x808054AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54AicSCG"
    VALUE
    0x808054AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54OR"
    VALUE
    0x808054B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54SCB"
    VALUE
    0x808054B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54SCG"
    VALUE
    0x808054B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK54ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x808054B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55AicSCB"
    VALUE
    0x808054B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55AicSCG"
    VALUE
    0x808054BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55OR"
    VALUE
    0x808054BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55SCB"
    VALUE
    0x808054BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55SCG"
    VALUE
    0x808054C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK55ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x808054C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK56OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK56OR"
    VALUE
    0x808054C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK56SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK56SCB"
    VALUE
    0x808054C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK56SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK56SCG"
    VALUE
    0x808054C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK57OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK57OR"
    VALUE
    0x808054CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK57SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK57SCB"
    VALUE
    0x808054CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK57SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK57SCG"
    VALUE
    0x808054CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK58OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK58OR"
    VALUE
    0x808054D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK58SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK58SCB"
    VALUE
    0x808054D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK58SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK58SCG"
    VALUE
    0x808054D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK59OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK59OR"
    VALUE
    0x808054D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK59SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK59SCB"
    VALUE
    0x808054D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK59SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK59SCG"
    VALUE
    0x808054DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK60OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK60OR"
    VALUE
    0x808054DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK60SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK60SCB"
    VALUE
    0x808054DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK60SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK60SCG"
    VALUE
    0x808054E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61AicSCB"
    VALUE
    0x808054E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61AicSCG"
    VALUE
    0x808054E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61OR"
    VALUE
    0x808054E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61SCB"
    VALUE
    0x808054E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61SCG"
    VALUE
    0x808054EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK61ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x808054EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK62OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK62OR"
    VALUE
    0x808054EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK62SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK62SCB"
    VALUE
    0x808054F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK62SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK62SCG"
    VALUE
    0x808054F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63AicSCB"
    VALUE
    0x808054F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63AicSCG"
    VALUE
    0x808054F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63OR"
    VALUE
    0x808054F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63SCB"
    VALUE
    0x808054FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63SCG"
    VALUE
    0x808054FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK63ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x808054FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64AicSCB"
    VALUE
    0x80805500
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64AicSCG"
    VALUE
    0x80805502
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64OR"
    VALUE
    0x80805504
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64SCB"
    VALUE
    0x80805506
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64SCG"
    VALUE
    0x80805508
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK64ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x8080550A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65AicSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65AicSCB"
    VALUE
    0x8080550C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65AicSCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65AicSCG"
    VALUE
    0x8080550E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65OR"
    VALUE
    0x80805510
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65SCB"
    VALUE
    0x80805512
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65SCG"
    VALUE
    0x80805514
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK65ShuntSCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80805516
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK74OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK74OR"
    VALUE
    0x80805518
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK74SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK74SCB"
    VALUE
    0x8080551A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK74SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK74SCG"
    VALUE
    0x8080551C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK75OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK75OR"
    VALUE
    0x8080551E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK75SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK75SCB"
    VALUE
    0x80805520
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK75SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK75SCG"
    VALUE
    0x80805522
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK76OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK76OR"
    VALUE
    0x80805524
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK76SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK76SCB"
    VALUE
    0x80805526
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK76SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK76SCG"
    VALUE
    0x80805528
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK77OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK77OR"
    VALUE
    0x8080552A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK77SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK77SCB"
    VALUE
    0x8080552C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK77SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK77SCG"
    VALUE
    0x8080552E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK78OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK78OR"
    VALUE
    0x80805530
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK78SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK78SCB"
    VALUE
    0x80805532
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inK78SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inK78SCG"
    VALUE
    0x80805534
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_DvUBAT_FWs_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80805536
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OVErr_VPR6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80805538
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OVWarn_VPR6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x8080553A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x8080553C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x8080553E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_UBAT_MON_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80805540
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80805542
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80805544
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_UBRM24_MON_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80805546
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VDD5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80805548
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VDD5_IN_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x8080554A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VPR6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x8080554C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VSS3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x8080554E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VSS4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80805550
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_Temp1_HTErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80805552
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_Temp1_HTWarn_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80805554
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_Temp2_HTErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80805556
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_Temp2_HTWarn_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80805558
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x8080555A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x8080555C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VDD5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x8080555E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VDD5_IN_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80805560
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VPR6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80805562
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VSS3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80805564
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VSS4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80805566
    Val_Wu16
    65535.00
    DFES_OneToOne
