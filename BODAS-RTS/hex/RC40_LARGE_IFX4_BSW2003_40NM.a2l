    DFES_EnvRef.DFC_rbr_inK41SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41SCB"
    VALUE
    0x808076F3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK41SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41SCG"
    VALUE
    0x808076F4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK41ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x808076F5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42AicSCB"
    VALUE
    0x808076F6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42AicSCG"
    VALUE
    0x808076F7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42OR"
    VALUE
    0x808076F8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42SCB"
    VALUE
    0x808076F9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42SCG"
    VALUE
    0x808076FA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK42ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x808076FB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK43OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK43OR"
    VALUE
    0x808076FC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK43SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK43SCB"
    VALUE
    0x808076FD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK43SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK43SCG"
    VALUE
    0x808076FE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44AicSCB"
    VALUE
    0x808076FF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44AicSCG"
    VALUE
    0x80807700
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44OR"
    VALUE
    0x80807701
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44SCB"
    VALUE
    0x80807702
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44SCG"
    VALUE
    0x80807703
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK44ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80807704
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45AicSCB"
    VALUE
    0x80807705
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45AicSCG"
    VALUE
    0x80807706
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45OR"
    VALUE
    0x80807707
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45SCB"
    VALUE
    0x80807708
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45SCG"
    VALUE
    0x80807709
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK45ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x8080770A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK52OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK52OR"
    VALUE
    0x8080770B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK52SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK52SCB"
    VALUE
    0x8080770C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK52SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK52SCG"
    VALUE
    0x8080770D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK53OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK53OR"
    VALUE
    0x8080770E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK53SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK53SCB"
    VALUE
    0x8080770F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK53SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK53SCG"
    VALUE
    0x80807710
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54AicSCB"
    VALUE
    0x80807711
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80807712
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54OR"
    VALUE
    0x80807713
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54SCB"
    VALUE
    0x80807714
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54SCG"
    VALUE
    0x80807715
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK54ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80807716
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55AicSCB"
    VALUE
    0x80807717
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55AicSCG"
    VALUE
    0x80807718
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55OR"
    VALUE
    0x80807719
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55SCB"
    VALUE
    0x8080771A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55SCG"
    VALUE
    0x8080771B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK55ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x8080771C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK56OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK56OR"
    VALUE
    0x8080771D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK56SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK56SCB"
    VALUE
    0x8080771E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK56SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK56SCG"
    VALUE
    0x8080771F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK57OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK57OR"
    VALUE
    0x80807720
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK57SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK57SCB"
    VALUE
    0x80807721
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK57SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK57SCG"
    VALUE
    0x80807722
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK58OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK58OR"
    VALUE
    0x80807723
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK58SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK58SCB"
    VALUE
    0x80807724
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK58SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK58SCG"
    VALUE
    0x80807725
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK59OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK59OR"
    VALUE
    0x80807726
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK59SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK59SCB"
    VALUE
    0x80807727
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK59SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK59SCG"
    VALUE
    0x80807728
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK60OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK60OR"
    VALUE
    0x80807729
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK60SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK60SCB"
    VALUE
    0x8080772A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK60SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK60SCG"
    VALUE
    0x8080772B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61AicSCB"
    VALUE
    0x8080772C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61AicSCG"
    VALUE
    0x8080772D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61OR"
    VALUE
    0x8080772E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61SCB"
    VALUE
    0x8080772F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61SCG"
    VALUE
    0x80807730
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK61ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80807731
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK62OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK62OR"
    VALUE
    0x80807732
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK62SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK62SCB"
    VALUE
    0x80807733
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK62SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK62SCG"
    VALUE
    0x80807734
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80807735
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63AicSCG"
    VALUE
    0x80807736
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63OR"
    VALUE
    0x80807737
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63SCB"
    VALUE
    0x80807738
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63SCG"
    VALUE
    0x80807739
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK63ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x8080773A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64AicSCB"
    VALUE
    0x8080773B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64AicSCG"
    VALUE
    0x8080773C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64OR"
    VALUE
    0x8080773D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64SCB"
    VALUE
    0x8080773E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64SCG"
    VALUE
    0x8080773F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK64ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80807740
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65AicSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80807741
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65AicSCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80807742
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65OR"
    VALUE
    0x80807743
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65SCB"
    VALUE
    0x80807744
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65SCG"
    VALUE
    0x80807745
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK65ShuntSCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80807746
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK74OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK74OR"
    VALUE
    0x80807747
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK74SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK74SCB"
    VALUE
    0x80807748
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK74SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK74SCG"
    VALUE
    0x80807749
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK75OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK75OR"
    VALUE
    0x8080774A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK75SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK75SCB"
    VALUE
    0x8080774B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK75SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK75SCG"
    VALUE
    0x8080774C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK76OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK76OR"
    VALUE
    0x8080774D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK76SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK76SCB"
    VALUE
    0x8080774E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK76SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK76SCG"
    VALUE
    0x8080774F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK77OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK77OR"
    VALUE
    0x80807750
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK77SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK77SCB"
    VALUE
    0x80807751
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK77SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK77SCG"
    VALUE
    0x80807752
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK78OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK78OR"
    VALUE
    0x80807753
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK78SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK78SCB"
    VALUE
    0x80807754
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inK78SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inK78SCG"
    VALUE
    0x80807755
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_DvUBAT_FWs_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80807756
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OVErr_VPR6_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80807757
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OVWarn_VPR6_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80807758
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80807759
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x8080775A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_UBAT_MON_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x8080775B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x8080775C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x8080775D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_UBRM24_MON_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x8080775E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VDD5_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x8080775F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VDD5_IN_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80807760
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VPR6_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80807761
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VSS3_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80807762
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VSS4_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80807763
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_Temp1_HTErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80807764
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_Temp1_HTWarn_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80807765
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_Temp2_HTErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80807766
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_Temp2_HTWarn_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80807767
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80807768
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80807769
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VDD5_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x8080776A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VDD5_IN_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x8080776B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VPR6_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x8080776C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VSS3_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x8080776D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VSS4_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x8080776E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA01OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA01OL"
    VALUE
    0x8080776F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA01OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA01OT"
    VALUE
    0x80807770
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA01SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA01SCB"
    VALUE
    0x80807771
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA01SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA01SCG"
    VALUE
    0x80807772
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02OL"
    VALUE
    0x80807773
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02OR"
    VALUE
    0x80807774
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02OT"
    VALUE
    0x80807775
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02SCB"
    VALUE
    0x80807776
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02SCG"
    VALUE
    0x80807777
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03OL"
    VALUE
    0x80807778
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03OT"
    VALUE
    0x80807779
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03SCB"
    VALUE
    0x8080777A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03SCG"
    VALUE
    0x8080777B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04OL"
    VALUE
    0x8080777C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04OT"
    VALUE
    0x8080777D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04SCB"
    VALUE
    0x8080777E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04SCG"
    VALUE
    0x8080777F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05OL"
    VALUE
    0x80807780
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05OR"
    VALUE
    0x80807781
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05OT"
    VALUE
    0x80807782
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05SCB"
    VALUE
    0x80807783
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05SCG"
    VALUE
    0x80807784
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA06OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA06OL"
    VALUE
    0x80807785
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA06OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA06OR"
    VALUE
    0x80807786
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA06OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA06OT"
    VALUE
    0x80807787
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA06SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA06SCB"
    VALUE
    0x80807788
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA06SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA06SCG"
    VALUE
    0x80807789
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07OL"
    VALUE
    0x8080778A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07OT"
    VALUE
    0x8080778B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07SCB"
    VALUE
    0x8080778C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07SCG"
    VALUE
    0x8080778D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08OL"
    VALUE
    0x8080778E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08OT"
    VALUE
    0x8080778F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08SCB"
    VALUE
    0x80807790
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08SCG"
    VALUE
    0x80807791
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09OL"
    VALUE
    0x80807792
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09OR"
    VALUE
    0x80807793
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09OT"
    VALUE
    0x80807794
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09SCB"
    VALUE
    0x80807795
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09SCG"
    VALUE
    0x80807796
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10OL"
    VALUE
    0x80807797
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10OT"
    VALUE
    0x80807798
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10SCB"
    VALUE
    0x80807799
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10SCG"
    VALUE
    0x8080779A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA11OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA11OL"
    VALUE
    0x8080779B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA11OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA11OT"
    VALUE
    0x8080779C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA11SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA11SCB"
    VALUE
    0x8080779D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA11SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA11SCG"
    VALUE
    0x8080779E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA12OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA12OR"
    VALUE
    0x8080779F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA12SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA12SCB"
    VALUE
    0x808077A0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA12SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA12SCG"
    VALUE
    0x808077A1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA16OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA16OL"
    VALUE
    0x808077A2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA16OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA16OT"
    VALUE
    0x808077A3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA16SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA16SCB"
    VALUE
    0x808077A4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA16SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA16SCG"
    VALUE
    0x808077A5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17OL"
    VALUE
    0x808077A6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17OR"
    VALUE
    0x808077A7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17OT"
    VALUE
    0x808077A8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17SCB"
    VALUE
    0x808077A9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17SCG"
    VALUE
    0x808077AA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18OL"
    VALUE
    0x808077AB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18OT"
    VALUE
    0x808077AC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18SCB"
    VALUE
    0x808077AD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18SCG"
    VALUE
    0x808077AE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19OL"
    VALUE
    0x808077AF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19OR"
    VALUE
    0x808077B0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19OT"
    VALUE
    0x808077B1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19SCB"
    VALUE
    0x808077B2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19SCG"
    VALUE
    0x808077B3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20OL"
    VALUE
    0x808077B4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20OR"
    VALUE
    0x808077B5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20OT"
    VALUE
    0x808077B6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20SCB"
    VALUE
    0x808077B7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20SCG"
    VALUE
    0x808077B8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31OL"
    VALUE
    0x808077B9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31OR"
    VALUE
    0x808077BA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31OT"
    VALUE
    0x808077BB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31SCB"
    VALUE
    0x808077BC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31SCG"
    VALUE
    0x808077BD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32OL"
    VALUE
    0x808077BE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32OR"
    VALUE
    0x808077BF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32OT"
    VALUE
    0x808077C0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32SCB"
    VALUE
    0x808077C1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32SCG"
    VALUE
    0x808077C2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33OL"
    VALUE
    0x808077C3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33OR"
    VALUE
    0x808077C4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33OT"
    VALUE
    0x808077C5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33SCB"
    VALUE
    0x808077C6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33SCG"
    VALUE
    0x808077C7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34OL"
    VALUE
    0x808077C8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34OR"
    VALUE
    0x808077C9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34OT"
    VALUE
    0x808077CA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34SCB"
    VALUE
    0x808077CB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34SCG"
    VALUE
    0x808077CC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35OL"
    VALUE
    0x808077CD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35OR"
    VALUE
    0x808077CE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35OT"
    VALUE
    0x808077CF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35SCB"
    VALUE
    0x808077D0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35SCG"
    VALUE
    0x808077D1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46OL"
    VALUE
    0x808077D2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46OR"
    VALUE
    0x808077D3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46OT"
    VALUE
    0x808077D4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46SCB"
    VALUE
    0x808077D5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46SCG"
    VALUE
    0x808077D6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47OL"
    VALUE
    0x808077D7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47OR"
    VALUE
    0x808077D8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47OT"
    VALUE
    0x808077D9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47SCB"
    VALUE
    0x808077DA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47SCG"
    VALUE
    0x808077DB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48OL"
    VALUE
    0x808077DC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48OR"
    VALUE
    0x808077DD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48OT"
    VALUE
    0x808077DE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48SCB"
    VALUE
    0x808077DF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48SCG"
    VALUE
    0x808077E0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA49OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA49OL"
    VALUE
    0x808077E1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA49OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA49OT"
    VALUE
    0x808077E2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA49SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA49SCB"
    VALUE
    0x808077E3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA49SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA49SCG"
    VALUE
    0x808077E4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA50OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA50OL"
    VALUE
    0x808077E5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA50OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA50OT"
    VALUE
    0x808077E6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA50SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA50SCB"
    VALUE
    0x808077E7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA50SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA50SCG"
    VALUE
    0x808077E8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51OL"
    VALUE
    0x808077E9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51OR"
    VALUE
    0x808077EA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51OT"
    VALUE
    0x808077EB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51SCB"
    VALUE
    0x808077EC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51SCG"
    VALUE
    0x808077ED
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52OL"
    VALUE
    0x808077EE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52OR"
    VALUE
    0x808077EF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52OT"
    VALUE
    0x808077F0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52SCB"
    VALUE
    0x808077F1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52SCG"
    VALUE
    0x808077F2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53OL"
    VALUE
    0x808077F3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53OR"
    VALUE
    0x808077F4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53OT"
    VALUE
    0x808077F5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53SCB"
    VALUE
    0x808077F6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53SCG"
    VALUE
    0x808077F7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54OL"
    VALUE
    0x808077F8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54OR"
    VALUE
    0x808077F9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54OT"
    VALUE
    0x808077FA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54SCB"
    VALUE
    0x808077FB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54SCG"
    VALUE
    0x808077FC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA55OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA55OL"
    VALUE
    0x808077FD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA55OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA55OT"
    VALUE
    0x808077FE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA55SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA55SCB"
    VALUE
    0x808077FF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA55SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA55SCG"
    VALUE
    0x80807800
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA56OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA56OL"
    VALUE
    0x80807801
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA56OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA56OT"
    VALUE
    0x80807802
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA56SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA56SCB"
    VALUE
    0x80807803
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA56SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA56SCG"
    VALUE
    0x80807804
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA58OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA58OL"
    VALUE
    0x80807805
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA58OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA58OT"
    VALUE
    0x80807806
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA58SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA58SCB"
    VALUE
    0x80807807
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA58SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA58SCG"
    VALUE
    0x80807808
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07OL"
    VALUE
    0x80807809
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07OR"
    VALUE
    0x8080780A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07OT"
    VALUE
    0x8080780B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07SCB"
    VALUE
    0x8080780C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07SCG"
    VALUE
    0x8080780D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08OL"
    VALUE
    0x8080780E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08OR"
    VALUE
    0x8080780F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08OT"
    VALUE
    0x80807810
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08SCB"
    VALUE
    0x80807811
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08SCG"
    VALUE
    0x80807812
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09OL"
    VALUE
    0x80807813
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09OR"
    VALUE
    0x80807814
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09OT"
    VALUE
    0x80807815
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09SCB"
    VALUE
    0x80807816
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09SCG"
    VALUE
    0x80807817
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12OL"
    VALUE
    0x80807818
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12OT"
    VALUE
    0x80807819
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12SCB"
    VALUE
    0x8080781A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12SCG"
    VALUE
    0x8080781B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13OL"
    VALUE
    0x8080781C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13OT"
    VALUE
    0x8080781D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13SCB"
    VALUE
    0x8080781E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13SCG"
    VALUE
    0x8080781F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14OL"
    VALUE
    0x80807820
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14OR"
    VALUE
    0x80807821
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14OT"
    VALUE
    0x80807822
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14SCB"
    VALUE
    0x80807823
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14SCG"
    VALUE
    0x80807824
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15OL"
    VALUE
    0x80807825
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15OR"
    VALUE
    0x80807826
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15OT"
    VALUE
    0x80807827
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15SCB"
    VALUE
    0x80807828
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15SCG"
    VALUE
    0x80807829
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16OL"
    VALUE
    0x8080782A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16OR"
    VALUE
    0x8080782B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16OT"
    VALUE
    0x8080782C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16SCB"
    VALUE
    0x8080782D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16SCG"
    VALUE
    0x8080782E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17OL"
    VALUE
    0x8080782F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17OR"
    VALUE
    0x80807830
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17OT"
    VALUE
    0x80807831
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17SCB"
    VALUE
    0x80807832
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17SCG"
    VALUE
    0x80807833
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK25OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK25OR"
    VALUE
    0x80807834
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK25SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK25SCB"
    VALUE
    0x80807835
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK25SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK25SCG"
    VALUE
    0x80807836
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29OL"
    VALUE
    0x80807837
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29OR"
    VALUE
    0x80807838
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29OT"
    VALUE
    0x80807839
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29SCB"
    VALUE
    0x8080783A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29SCG"
    VALUE
    0x8080783B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51OL"
    VALUE
    0x8080783C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51OT"
    VALUE
    0x8080783D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51SCB"
    VALUE
    0x8080783E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51SCG"
    VALUE
    0x8080783F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK62OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK62OR"
    VALUE
    0x80807840
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK62SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK62SCB"
    VALUE
    0x80807841
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK62SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK62SCG"
    VALUE
    0x80807842
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73OL"
    VALUE
    0x80807843
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73OR"
    VALUE
    0x80807844
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73OT"
    VALUE
    0x80807845
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73SCB"
    VALUE
    0x80807846
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73SCG"
    VALUE
    0x80807847
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK80OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK80OL"
    VALUE
    0x80807848
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK80OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK80OT"
    VALUE
    0x80807849
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK80SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK80SCB"
    VALUE
    0x8080784A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK80SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK80SCG"
    VALUE
    0x8080784B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK81OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK81OL"
    VALUE
    0x8080784C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK81OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK81OT"
    VALUE
    0x8080784D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK81SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK81SCB"
    VALUE
    0x8080784E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK81SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK81SCG"
    VALUE
    0x8080784F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK82OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK82OL"
    VALUE
    0x80807850
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK82OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK82OT"
    VALUE
    0x80807851
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK82SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK82SCB"
    VALUE
    0x80807852
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK82SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK82SCG"
    VALUE
    0x80807853
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK83OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK83OL"
    VALUE
    0x80807854
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK83OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK83OT"
    VALUE
    0x80807855
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK83SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK83SCB"
    VALUE
    0x80807856
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK83SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK83SCG"
    VALUE
    0x80807857
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK84OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK84OL"
    VALUE
    0x80807858
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK84OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK84OT"
    VALUE
    0x80807859
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK84SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK84SCB"
    VALUE
    0x8080785A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK84SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK84SCG"
    VALUE
    0x8080785B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK85OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK85OL"
    VALUE
    0x8080785C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK85OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK85OT"
    VALUE
    0x8080785D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK85SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK85SCB"
    VALUE
    0x8080785E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK85SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK85SCG"
    VALUE
    0x8080785F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK86OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK86OL"
    VALUE
    0x80807860
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK86OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK86OT"
    VALUE
    0x80807861
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK86SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK86SCB"
    VALUE
    0x80807862
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK86SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK86SCG"
    VALUE
    0x80807863
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK87OL_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK87OL"
    VALUE
    0x80807864
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK87OT_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK87OT"
    VALUE
    0x80807865
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK87SCB_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK87SCB"
    VALUE
    0x80807866
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK87SCG_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK87SCG"
    VALUE
    0x80807867
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_DSMDummy_C
    "used environment signals / Reference to used environment condition set for check DFC_DSMDummy"
    VALUE
    0x80807868
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8000_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8000"
    VALUE
    0x80807869
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8001_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8001"
    VALUE
    0x8080786A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8002_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8002"
    VALUE
    0x8080786B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8003_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8003"
    VALUE
    0x8080786C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8004_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8004"
    VALUE
    0x8080786D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8005_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8005"
    VALUE
    0x8080786E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8006_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8006"
    VALUE
    0x8080786F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8007_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8007"
    VALUE
    0x80807870
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8008_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8008"
    VALUE
    0x80807871
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8009_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8009"
    VALUE
    0x80807872
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x800a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x800a"
    VALUE
    0x80807873
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x800b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x800b"
    VALUE
    0x80807874
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x800c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x800c"
    VALUE
    0x80807875
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x800d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x800d"
    VALUE
    0x80807876
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x800e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x800e"
    VALUE
    0x80807877
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x800f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x800f"
    VALUE
    0x80807878
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8010_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8010"
    VALUE
    0x80807879
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8011_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8011"
    VALUE
    0x8080787A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8012_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8012"
    VALUE
    0x8080787B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8013_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8013"
    VALUE
    0x8080787C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8014_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8014"
    VALUE
    0x8080787D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8015_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8015"
    VALUE
    0x8080787E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8016_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8016"
    VALUE
    0x8080787F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8017_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8017"
    VALUE
    0x80807880
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8018_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8018"
    VALUE
    0x80807881
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8019_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8019"
    VALUE
    0x80807882
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x801a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x801a"
    VALUE
    0x80807883
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x801b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x801b"
    VALUE
    0x80807884
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x801c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x801c"
    VALUE
    0x80807885
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x801d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x801d"
    VALUE
    0x80807886
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x801e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x801e"
    VALUE
    0x80807887
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x801f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x801f"
    VALUE
    0x80807888
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8020_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8020"
    VALUE
    0x80807889
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8021_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8021"
    VALUE
    0x8080788A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8022_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8022"
    VALUE
    0x8080788B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8023_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8023"
    VALUE
    0x8080788C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8024_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8024"
    VALUE
    0x8080788D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8025_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8025"
    VALUE
    0x8080788E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8026_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8026"
    VALUE
    0x8080788F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8027_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8027"
    VALUE
    0x80807890
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8028_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8028"
    VALUE
    0x80807891
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8029_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8029"
    VALUE
    0x80807892
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x802a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x802a"
    VALUE
    0x80807893
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x802b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x802b"
    VALUE
    0x80807894
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x802c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x802c"
    VALUE
    0x80807895
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x802d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x802d"
    VALUE
    0x80807896
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x802e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x802e"
    VALUE
    0x80807897
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x802f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x802f"
    VALUE
    0x80807898
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8030_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8030"
    VALUE
    0x80807899
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8031_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8031"
    VALUE
    0x8080789A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8032_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8032"
    VALUE
    0x8080789B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8033_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8033"
    VALUE
    0x8080789C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8034_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8034"
    VALUE
    0x8080789D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8035_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8035"
    VALUE
    0x8080789E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8036_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8036"
    VALUE
    0x8080789F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8037_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8037"
    VALUE
    0x808078A0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8038_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8038"
    VALUE
    0x808078A1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8039_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8039"
    VALUE
    0x808078A2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x803a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x803a"
    VALUE
    0x808078A3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x803b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x803b"
    VALUE
    0x808078A4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x803c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x803c"
    VALUE
    0x808078A5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x803d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x803d"
    VALUE
    0x808078A6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x803e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x803e"
    VALUE
    0x808078A7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x803f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x803f"
    VALUE
    0x808078A8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8040_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8040"
    VALUE
    0x808078A9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8041_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8041"
    VALUE
    0x808078AA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8042_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8042"
    VALUE
    0x808078AB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8043_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8043"
    VALUE
    0x808078AC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8044_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8044"
    VALUE
    0x808078AD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8045_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8045"
    VALUE
    0x808078AE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8046_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8046"
    VALUE
    0x808078AF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8047_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8047"
    VALUE
    0x808078B0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8048_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8048"
    VALUE
    0x808078B1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8049_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8049"
    VALUE
    0x808078B2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x804a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x804a"
    VALUE
    0x808078B3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x804b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x804b"
    VALUE
    0x808078B4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x804c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x804c"
    VALUE
    0x808078B5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x804d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x804d"
    VALUE
    0x808078B6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x804e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x804e"
    VALUE
    0x808078B7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x804f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x804f"
    VALUE
    0x808078B8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8050_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8050"
    VALUE
    0x808078B9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8051_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8051"
    VALUE
    0x808078BA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8052_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8052"
    VALUE
    0x808078BB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8053_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8053"
    VALUE
    0x808078BC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8054_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8054"
    VALUE
    0x808078BD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8055_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8055"
    VALUE
    0x808078BE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8056_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8056"
    VALUE
    0x808078BF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8057_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8057"
    VALUE
    0x808078C0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8058_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8058"
    VALUE
    0x808078C1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8059_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8059"
    VALUE
    0x808078C2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x805a_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x805a"
    VALUE
    0x808078C3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x805b_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x805b"
    VALUE
    0x808078C4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x805c_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x805c"
    VALUE
    0x808078C5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x805d_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x805d"
    VALUE
    0x808078C6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x805e_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x805e"
    VALUE
    0x808078C7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x805f_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x805f"
    VALUE
    0x808078C8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8060_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8060"
    VALUE
    0x808078C9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8061_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8061"
    VALUE
    0x808078CA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8062_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8062"
    VALUE
    0x808078CB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8C01_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8C01"
    VALUE
    0x808078CC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8C02_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8C02"
    VALUE
    0x808078CD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_bds_NoDeb0x8C03_C
    "used environment signals / Reference to used environment condition set for check DFC_bds_NoDeb0x8C03"
    VALUE
    0x808078CE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetDataNoBuf_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x808078CF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetDataParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetDataParam"
    VALUE
    0x808078D0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetDataboxNoInit_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x808078D1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x808078D2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetRxBufStatusParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x808078D3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetStatusParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetStatusParam"
    VALUE
    0x808078D4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canGetTxBufStatusParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x808078D5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canInitParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canInitParam"
    VALUE
    0x808078D6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canInitRxDataboxOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x808078D7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canInitRxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x808078D8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canInitTxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x808078D9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canIpduGroupControl_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x808078DA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canIsDataboxFreeNoInit_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x808078DB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canIsDataboxFreeParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x808078DC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canIsTxEmptyParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x808078DD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegBusOffCallbInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x808078DE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegBusOffCallbParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x808078DF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxBufInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x808078E0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxBufOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x808078E1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxBufParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x808078E2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxCallbInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x808078E3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxCallbParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x808078E4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxDataboxInvNumb_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x808078E5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxDataboxInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x808078E6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxDataboxOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x808078E7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegRxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x808078E8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxBufInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x808078E9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxBufOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x808078EA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxBufParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x808078EB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxDataboxInvNumb_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x808078EC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxDataboxInvState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x808078ED
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxDataboxOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x808078EE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canRegTxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x808078EF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canResetTxBufParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x808078F0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canSendDataBufOvfl_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x808078F1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canSendDataParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canSendDataParam"
    VALUE
    0x808078F2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canSendDataboxNoInit_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x808078F3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canSendDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x808078F4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canSetTxCycleParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x808078F5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canStartParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canStartParam"
    VALUE
    0x808078F6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_canStopParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_canStopParam"
    VALUE
    0x808078F7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_can_ClearIpduGroup_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x808078F8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_can_ReceiveSignal_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x808078F9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_can_SendSignal_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_can_SendSignal"
    VALUE
    0x808078FA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_can_SetIpduGroup_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x808078FB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmDTCJ1939_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x808078FC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmDelDTCJ1939_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x808078FD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmDelErrors_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmDelErrors"
    VALUE
    0x808078FE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmGetDFES_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmGetDFES"
    VALUE
    0x808078FF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmGetDTCJ1939_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80807900
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmGetErrors_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmGetErrors"
    VALUE
    0x80807901
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmGetNumErrors_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80807902
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmInitQueueOverflow_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80807903
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmNumDTCJ1939_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80807904
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmTesterror_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmTesterror"
    VALUE
    0x80807905
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmUpdateDebError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80807906
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmUpdateError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmUpdateError"
    VALUE
    0x80807907
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmgetDFCStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80807908
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_dsmtestErrorDFC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80807909
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAi_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAi"
    VALUE
    0x8080790A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAic_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAic"
    VALUE
    0x8080790B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAicCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAicCfg"
    VALUE
    0x8080790C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAicGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAicGetStatus"
    VALUE
    0x8080790D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAid_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAid"
    VALUE
    0x8080790E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAidCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAidCfg"
    VALUE
    0x8080790F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAiv_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAiv"
    VALUE
    0x80807910
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAivCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAivCfg"
    VALUE
    0x80807911
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inAivGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inAivGetStatus"
    VALUE
    0x80807912
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inDi_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inDi"
    VALUE
    0x80807913
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inFi_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inFi"
    VALUE
    0x80807914
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inFiCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inFiCfg"
    VALUE
    0x80807915
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inFiGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inFiGetStatus"
    VALUE
    0x80807916
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inFi_Buffered_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inFi_Buffered"
    VALUE
    0x80807917
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inPhase_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inPhase"
    VALUE
    0x80807918
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inPhaseGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80807919
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inPhaseResetCounter_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x8080791A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inRi_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inRi"
    VALUE
    0x8080791B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inRiCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inRiCfg"
    VALUE
    0x8080791C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inRiCfgTemp_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x8080791D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inRiGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inRiGetStatus"
    VALUE
    0x8080791E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inRiGetTemp_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inRiGetTemp"
    VALUE
    0x8080791F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentCopyFDFifo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80807920
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentDisable_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentDisable"
    VALUE
    0x80807921
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentEnable_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentEnable"
    VALUE
    0x80807922
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentGetErrorStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80807923
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentGetFD_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentGetFD"
    VALUE
    0x80807924
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentGetSD_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentGetSD"
    VALUE
    0x80807925
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentGetSDDatabox_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80807926
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentGetStatus"
    VALUE
    0x80807927
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentInitSDDatabox_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80807928
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentRegisterCopyFDFifo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80807929
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentRegisterFDFifo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x8080792A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_inSentRegisterSDDataboxes_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x8080792B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusCanRxBufferOverflow_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x8080792C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusGetCaAddrParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x8080792D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusGetDiagnosticParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x8080792E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x8080792F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusGetStatusParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80807930
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitCommCaMissing_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80807931
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitCommParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80807932
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitCommState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitCommState"
    VALUE
    0x80807933
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitDiagnosticParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80807934
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitFailureListParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80807935
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitRxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80807936
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusInitTxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80807937
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegRxDataboxOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80807938
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegRxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80807939
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegRxDataboxState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x8080793A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegTxDataboxOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x8080793B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegTxDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x8080793C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegTxDataboxState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x8080793D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x8080793E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegisterInstancesOverlap_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x8080793F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegisterInstancesParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80807940
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusRegisterInstancesState_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80807941
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSendDataboxParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80807942
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSendRequestPGNParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80807943
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaAddrCaUsed_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80807944
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaAddrComm_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80807945
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaAddrInvCan_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80807946
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaAddrParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80807947
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaInfoParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80807948
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSetCaNameParam_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80807949
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_isobusSftyCanTxErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x8080794A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_ReceiveSignal_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x8080794B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_SendSignal_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_SendSignal"
    VALUE
    0x8080794C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_getStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_getStatus"
    VALUE
    0x8080794D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_gotoSleep_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x8080794E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_scheduleRequest_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x8080794F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_lin_wakeUp_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_lin_wakeUp"
    VALUE
    0x80807950
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memFlsCfgShr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80807951
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memGetStatus"
    VALUE
    0x80807952
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memMarkBlock_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memMarkBlock"
    VALUE
    0x80807953
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadApi1Error_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80807954
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadApi2Error_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80807955
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadBlock_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadBlock"
    VALUE
    0x80807956
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadCalibInputError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80807957
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadCalibOuputError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80807958
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memReadSystemError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memReadSystemError"
    VALUE
    0x80807959
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_memWriteBlock_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_memWriteBlock"
    VALUE
    0x8080795A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_moOV_FirstConstADC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x8080795B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_moOV_SecondConstADC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x8080795C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_moUV_FirstConstADC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x8080795D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_moUV_SecondConstADC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x8080795E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_INH_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_INH"
    VALUE
    0x8080795F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_INHLatch_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_INHLatch"
    VALUE
    0x80807960
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_adcPDD_fail_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80807961
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_memoryProtection_err_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80807962
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02OC"
    VALUE
    0x80807963
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA02Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA02Unintended"
    VALUE
    0x80807964
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03OC"
    VALUE
    0x80807965
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA03Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA03Unintended"
    VALUE
    0x80807966
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04OC"
    VALUE
    0x80807967
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA04Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA04Unintended"
    VALUE
    0x80807968
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05OC"
    VALUE
    0x80807969
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA05Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA05Unintended"
    VALUE
    0x8080796A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07OC"
    VALUE
    0x8080796B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA07Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA07Unintended"
    VALUE
    0x8080796C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08OC"
    VALUE
    0x8080796D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA08Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA08Unintended"
    VALUE
    0x8080796E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09OC"
    VALUE
    0x8080796F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA09Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA09Unintended"
    VALUE
    0x80807970
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10OC"
    VALUE
    0x80807971
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA10Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA10Unintended"
    VALUE
    0x80807972
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17OC"
    VALUE
    0x80807973
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA17Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA17Unintended"
    VALUE
    0x80807974
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18OC"
    VALUE
    0x80807975
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA18Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA18Unintended"
    VALUE
    0x80807976
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19OC"
    VALUE
    0x80807977
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA19Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA19Unintended"
    VALUE
    0x80807978
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20OC"
    VALUE
    0x80807979
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA20Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA20Unintended"
    VALUE
    0x8080797A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31OC"
    VALUE
    0x8080797B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA31Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA31Unintended"
    VALUE
    0x8080797C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32OC"
    VALUE
    0x8080797D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA32Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA32Unintended"
    VALUE
    0x8080797E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33OC"
    VALUE
    0x8080797F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA33Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA33Unintended"
    VALUE
    0x80807980
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34OC"
    VALUE
    0x80807981
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA34Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA34Unintended"
    VALUE
    0x80807982
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35OC"
    VALUE
    0x80807983
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA35Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA35Unintended"
    VALUE
    0x80807984
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46OC"
    VALUE
    0x80807985
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA46Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA46Unintended"
    VALUE
    0x80807986
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47OC"
    VALUE
    0x80807987
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA47Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA47Unintended"
    VALUE
    0x80807988
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48OC"
    VALUE
    0x80807989
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA48Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA48Unintended"
    VALUE
    0x8080798A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51OC"
    VALUE
    0x8080798B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA51Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA51Unintended"
    VALUE
    0x8080798C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52OC"
    VALUE
    0x8080798D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA52Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA52Unintended"
    VALUE
    0x8080798E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53OC"
    VALUE
    0x8080798F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA53Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA53Unintended"
    VALUE
    0x80807990
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54OC"
    VALUE
    0x80807991
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outA54Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outA54Unintended"
    VALUE
    0x80807992
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAov_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAov"
    VALUE
    0x80807993
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAovCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAovCfg"
    VALUE
    0x80807994
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAovCfgPI_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAovCfgPI"
    VALUE
    0x80807995
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAovGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAovGetStatus"
    VALUE
    0x80807996
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAovGetVoltage_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80807997
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outAovResetError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outAovResetError"
    VALUE
    0x80807998
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDo"
    VALUE
    0x80807999
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDoCfgPwrLs_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x8080799A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDoDisable_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDoDisable"
    VALUE
    0x8080799B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDoGetCurrent_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x8080799C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDoGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDoGetStatus"
    VALUE
    0x8080799D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outDoResetError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outDoResetError"
    VALUE
    0x8080799E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07OC"
    VALUE
    0x8080799F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK07Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK07Unintended"
    VALUE
    0x808079A0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08OC"
    VALUE
    0x808079A1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK08Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK08Unintended"
    VALUE
    0x808079A2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09OC"
    VALUE
    0x808079A3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK09Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK09Unintended"
    VALUE
    0x808079A4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12OC"
    VALUE
    0x808079A5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK12Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK12Unintended"
    VALUE
    0x808079A6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13OC"
    VALUE
    0x808079A7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK13Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK13Unintended"
    VALUE
    0x808079A8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14OC"
    VALUE
    0x808079A9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK14Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK14Unintended"
    VALUE
    0x808079AA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15OC"
    VALUE
    0x808079AB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK15Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK15Unintended"
    VALUE
    0x808079AC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16OC"
    VALUE
    0x808079AD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK16Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK16Unintended"
    VALUE
    0x808079AE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17OC"
    VALUE
    0x808079AF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK17Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK17Unintended"
    VALUE
    0x808079B0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29OC"
    VALUE
    0x808079B1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK29Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK29Unintended"
    VALUE
    0x808079B2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51OC"
    VALUE
    0x808079B3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK51Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK51Unintended"
    VALUE
    0x808079B4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73OC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73OC"
    VALUE
    0x808079B5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outK73Unintended_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outK73Unintended"
    VALUE
    0x808079B6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPo"
    VALUE
    0x808079B7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoCfg"
    VALUE
    0x808079B8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoCfgPeriod_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x808079B9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoCfgPwrLs_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x808079BA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoDisable_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoDisable"
    VALUE
    0x808079BB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoGetCurrent_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x808079BC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoGetStatus"
    VALUE
    0x808079BD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoResetError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoResetError"
    VALUE
    0x808079BE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPoc_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPoc"
    VALUE
    0x808079BF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPocCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPocCfg"
    VALUE
    0x808079C0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPocCfgDither_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPocCfgDither"
    VALUE
    0x808079C1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPocCfgPI_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPocCfgPI"
    VALUE
    0x808079C2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPod_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPod"
    VALUE
    0x808079C3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPodCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPodCfg"
    VALUE
    0x808079C4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_outPodCfgPeriod_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x808079C5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_rsmFfiApiCallErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x808079C6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safout_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safout"
    VALUE
    0x808079C7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutCfg"
    VALUE
    0x808079C8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl1_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl1"
    VALUE
    0x808079C9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl10_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl10"
    VALUE
    0x808079CA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl10Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x808079CB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl10OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x808079CC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl11_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl11"
    VALUE
    0x808079CD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl11Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x808079CE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl11OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x808079CF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl12_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl12"
    VALUE
    0x808079D0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl12Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x808079D1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl12OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x808079D2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl13_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl13"
    VALUE
    0x808079D3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl13Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x808079D4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl13OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x808079D5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl14_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl14"
    VALUE
    0x808079D6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl14Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x808079D7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl14OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x808079D8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl15_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl15"
    VALUE
    0x808079D9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl15Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x808079DA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl15OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x808079DB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl16_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl16"
    VALUE
    0x808079DC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl16Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x808079DD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl16OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x808079DE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl17_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl17"
    VALUE
    0x808079DF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl17Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x808079E0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl17OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x808079E1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl18_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl18"
    VALUE
    0x808079E2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl18Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x808079E3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl18OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x808079E4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl1Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x808079E5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl1OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x808079E6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl2_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl2"
    VALUE
    0x808079E7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl2Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x808079E8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl2OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x808079E9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl3_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl3"
    VALUE
    0x808079EA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl3Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x808079EB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl3OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x808079EC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl4_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl4"
    VALUE
    0x808079ED
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl4Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x808079EE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl4OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x808079EF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl5_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl5"
    VALUE
    0x808079F0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl5Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x808079F1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl5OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x808079F2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl6_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl6"
    VALUE
    0x808079F3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl6Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x808079F4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl6OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x808079F5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl7_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl7"
    VALUE
    0x808079F6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl7Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x808079F7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl7OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x808079F8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl8_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl8"
    VALUE
    0x808079F9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl8Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x808079FA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl8OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x808079FB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl9_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl9"
    VALUE
    0x808079FC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl9Dev_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x808079FD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutChnl9OR_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x808079FE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutDevError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutDevError"
    VALUE
    0x808079FF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutGetStatus_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutGetStatus"
    VALUE
    0x80807A00
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutIgnoreError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80807A01
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutResetError_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutResetError"
    VALUE
    0x80807A02
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safoutUnlock_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safoutUnlock"
    VALUE
    0x80807A03
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_safout_cfgDiag_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80807A04
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secAccessDenied_RC_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80807A05
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secAccessDenied_WDBI_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80807A06
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secEvalRespKey_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secEvalRespKey"
    VALUE
    0x80807A07
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secFlashingFailure_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secFlashingFailure"
    VALUE
    0x80807A08
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secGetLevel_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secGetLevel"
    VALUE
    0x80807A09
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secGetRnd_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secGetRnd"
    VALUE
    0x80807A0A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secGetSeed_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secGetSeed"
    VALUE
    0x80807A0B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secInvalidPassword_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secInvalidPassword"
    VALUE
    0x80807A0C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secIsRequestAllowed_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80807A0D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secResetLevel_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secResetLevel"
    VALUE
    0x80807A0E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secSaveSecret_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secSaveSecret"
    VALUE
    0x80807A0F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_secSetLevel_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_secSetLevel"
    VALUE
    0x80807A10
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysAit_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysAit"
    VALUE
    0x80807A11
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysAiv_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysAiv"
    VALUE
    0x80807A12
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysDi_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysDi"
    VALUE
    0x80807A13
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysDo_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysDo"
    VALUE
    0x80807A14
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysGetVss_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysGetVss"
    VALUE
    0x80807A15
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysInit_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysInit"
    VALUE
    0x80807A16
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysOperHrIntegrityErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80807A17
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysOperHrsSaturated_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80807A18
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sysSetVss_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sysSetVss"
    VALUE
    0x80807A19
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sys_coreload_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sys_coreload"
    VALUE
    0x80807A1A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_sys_taskload_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_sys_taskload"
    VALUE
    0x80807A1B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VSS1_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80807A1C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_OV_VSS2_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80807A1D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VSS1_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80807A1E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rbr_mo_UV_VSS2_C
    "used environment signals / Reference to used environment condition set for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x80807A1F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "used environment signals / Reference to used environment condition set for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80807A20
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "used environment signals / Reference to used environment condition set for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80807A21
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "used environment signals / Reference to used environment condition set for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80807A22
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "used environment signals / Reference to used environment condition set for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80807A23
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "used environment signals / Reference to used environment condition set for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80807A24
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_CAN_E_TIMEOUT_C
    "used environment signals / Reference to used environment condition set for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80807A25
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80807A26
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80807A27
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80807A28
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80807A29
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80807A2A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "used environment signals / Reference to used environment condition set for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80807A2B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_LIN_E_TIMEOUT_C
    "used environment signals / Reference to used environment condition set for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80807A2C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_MultiStackTrace_Threshold_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80807A2D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_ETH_E_ACCESS_0_C
    "used environment signals / Reference to used environment condition set for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x80807A2E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "used environment signals / Reference to used environment condition set for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x80807A2F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "used environment signals / Reference to used environment condition set for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80807A30
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_MRly_Diag_Stk_Event_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80807A31
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80807A32
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_MemDiag_MemReadErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80807A33
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_MemDiag_MemWrErr_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80807A34
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80807A35
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_T15_Diag_ComInVld_Event_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80807A36
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80807A37
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "used environment signals / Reference to used environment condition set for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80807A38
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80807A39
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80807A3A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_10_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80807A3B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80807A3C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80807A3D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x80807A3E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x80807A3F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_22_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80807A40
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_23_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80807A41
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80807A42
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80807A43
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_7_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80807A44
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM0_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80807A45
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM10_16_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80807A46
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM10_17_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80807A47
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM10_21_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80807A48
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80807A49
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80807A4A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80807A4B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_3_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80807A4C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80807A4D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x80807A4E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x80807A4F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM11_9_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80807A50
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80807A51
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80807A52
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_10_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80807A53
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80807A54
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80807A55
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80807A56
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80807A57
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_22_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80807A58
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_23_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80807A59
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80807A5A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80807A5B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_7_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80807A5C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM1_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80807A5D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM21_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x80807A5E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM21_16_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x80807A5F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM21_3_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80807A60
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80807A61
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_10_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80807A62
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80807A63
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80807A64
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80807A65
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80807A66
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_22_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80807A67
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_23_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80807A68
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80807A69
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80807A6A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_7_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80807A6B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM2_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80807A6C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80807A6D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_10_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x80807A6E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x80807A6F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80807A70
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80807A71
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80807A72
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_22_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80807A73
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_23_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80807A74
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80807A75
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80807A76
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_7_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80807A77
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM3_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80807A78
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80807A79
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80807A7A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_12_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80807A7B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80807A7C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_15_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80807A7D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_17_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x80807A7E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_18_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x80807A7F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80807A80
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_20_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80807A81
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_21_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80807A82
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_25_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80807A83
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80807A84
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_5_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80807A85
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_7_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80807A86
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM6_8_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80807A87
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80807A88
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_12_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80807A89
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80807A8A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_14_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80807A8B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_15_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80807A8C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_16_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80807A8D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_17_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80807A8E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80807A8F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_20_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80807A90
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_25_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80807A91
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_26_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80807A92
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_28_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80807A93
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_29_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80807A94
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_30_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80807A95
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM7_31_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80807A96
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80807A97
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80807A98
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_10_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80807A99
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_11_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80807A9A
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_12_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80807A9B
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_13_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80807A9C
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_16_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80807A9D
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_18_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80807A9E
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_2_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80807A9F
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_3_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80807AA0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_30_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80807AA1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_31_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80807AA2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM8_4_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80807AA3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_0_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80807AA4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_1_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80807AA5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_15_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80807AA6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MOXEMM_SMU_ALM9_3_C
    "used environment signals / Reference to used environment condition set for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80807AA7
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoCSOPICO_C
    "used environment signals / Reference to used environment condition set for check DFC_MoCSOPICO"
    VALUE
    0x80807AA8
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoFVarPostBldSel_C
    "used environment signals / Reference to used environment condition set for check DFC_MoFVarPostBldSel"
    VALUE
    0x80807AA9
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoSysCtrlReIni_C
    "used environment signals / Reference to used environment condition set for check DFC_MoSysCtrlReIni"
    VALUE
    0x80807AAA
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTMCUFW_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80807AAB
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTMonBIST_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80807AAC
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTRegMonTest_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80807AAD
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80807AAE
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTTempSens_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80807AAF
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_MoXEMMHwLTUCBCfg_C
    "used environment signals / Reference to used environment condition set for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80807AB0
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_OCWDAABEActv_C
    "used environment signals / Reference to used environment condition set for check DFC_OCWDAABEActv"
    VALUE
    0x80807AB1
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_OCWDACom_C
    "used environment signals / Reference to used environment condition set for check DFC_OCWDACom"
    VALUE
    0x80807AB2
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_OCWDAErrPin_C
    "used environment signals / Reference to used environment condition set for check DFC_OCWDAErrPin"
    VALUE
    0x80807AB3
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_SWReset_0_C
    "used environment signals / Reference to used environment condition set for check DFC_SWReset_0"
    VALUE
    0x80807AB4
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_SWReset_1_C
    "used environment signals / Reference to used environment condition set for check DFC_SWReset_1"
    VALUE
    0x80807AB5
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_EnvRef.DFC_SWReset_2_C
    "used environment signals / Reference to used environment condition set for check DFC_SWReset_2"
    VALUE
    0x80807AB6
    Val_Wu8
    4.
    DFES_EnvTabVerb
    0.00
    4.

    FORMAT "%2.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_Unused_C
    "assigned fault type / "
    VALUE
    0x80807AB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80c7_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80807AB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80c8_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80c8"
    VALUE
    0x80807ABA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80c9_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80c9"
    VALUE
    0x80807ABB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ca_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ca"
    VALUE
    0x80807ABC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80cb_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80cb"
    VALUE
    0x80807ABD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80cc_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80cc"
    VALUE
    0x80807ABE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80cd_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80cd"
    VALUE
    0x80807ABF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ce_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ce"
    VALUE
    0x80807AC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80cf_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80cf"
    VALUE
    0x80807AC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80d0_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80d0"
    VALUE
    0x80807AC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80d1_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80d1"
    VALUE
    0x80807AC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80d2_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80807AC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80d3_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80807AC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80d4_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80807AC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80d5_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80807AC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80d6_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80807AC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80d7_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80d7"
    VALUE
    0x80807AC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80d8_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80d8"
    VALUE
    0x80807ACA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80d9_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80d9"
    VALUE
    0x80807ACB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80da_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80da"
    VALUE
    0x80807ACC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80db_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80db"
    VALUE
    0x80807ACD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80dc_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80dc"
    VALUE
    0x80807ACE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80dd_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80dd"
    VALUE
    0x80807ACF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80de_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80de"
    VALUE
    0x80807AD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80df_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80df"
    VALUE
    0x80807AD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80e0_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80e0"
    VALUE
    0x80807AD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80e1_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80e1"
    VALUE
    0x80807AD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80e2_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80807AD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80e3_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80807AD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80e4_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80807AD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80e5_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80807AD7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80e6_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80807AD8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80e7_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80e7"
    VALUE
    0x80807AD9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80e8_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80e8"
    VALUE
    0x80807ADA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80e9_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80e9"
    VALUE
    0x80807ADB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ea_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ea"
    VALUE
    0x80807ADC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80eb_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80eb"
    VALUE
    0x80807ADD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ec_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ec"
    VALUE
    0x80807ADE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ed_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ed"
    VALUE
    0x80807ADF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ee_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ee"
    VALUE
    0x80807AE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ef_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ef"
    VALUE
    0x80807AE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80f0_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80f0"
    VALUE
    0x80807AE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80f1_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80f1"
    VALUE
    0x80807AE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80f2_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80807AE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80f3_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80807AE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80f4_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80807AE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80f5_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80807AE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80f6_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80f6"
    VALUE
    0x80807AE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80f7_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80f7"
    VALUE
    0x80807AE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80f8_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80f8"
    VALUE
    0x80807AEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80f9_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80f9"
    VALUE
    0x80807AEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80fa_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80fa"
    VALUE
    0x80807AEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80fb_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80fb"
    VALUE
    0x80807AED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80fc_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80fc"
    VALUE
    0x80807AEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80fd_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80fd"
    VALUE
    0x80807AEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80fe_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80fe"
    VALUE
    0x80807AF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ff_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ff"
    VALUE
    0x80807AF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8100_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8100"
    VALUE
    0x80807AF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8101_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8101"
    VALUE
    0x80807AF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8102_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8102"
    VALUE
    0x80807AF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8103_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8103"
    VALUE
    0x80807AF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8104_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8104"
    VALUE
    0x80807AF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8105_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8105"
    VALUE
    0x80807AF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8106_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8106"
    VALUE
    0x80807AF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8107_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8107"
    VALUE
    0x80807AF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8108_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8108"
    VALUE
    0x80807AFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8109_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8109"
    VALUE
    0x80807AFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x810a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x810a"
    VALUE
    0x80807AFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x810b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x810b"
    VALUE
    0x80807AFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x810c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x810c"
    VALUE
    0x80807AFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x810d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x810d"
    VALUE
    0x80807AFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x810e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x810e"
    VALUE
    0x80807B00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x810f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x810f"
    VALUE
    0x80807B01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8110_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8110"
    VALUE
    0x80807B02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8111_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8111"
    VALUE
    0x80807B03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8112_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8112"
    VALUE
    0x80807B04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8113_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8113"
    VALUE
    0x80807B05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8114_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8114"
    VALUE
    0x80807B06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8115_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8115"
    VALUE
    0x80807B07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8116_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8116"
    VALUE
    0x80807B08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8117_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8117"
    VALUE
    0x80807B09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8118_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8118"
    VALUE
    0x80807B0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8119_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8119"
    VALUE
    0x80807B0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x811a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x811a"
    VALUE
    0x80807B0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x811b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x811b"
    VALUE
    0x80807B0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x811c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x811c"
    VALUE
    0x80807B0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x811d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x811d"
    VALUE
    0x80807B0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x811e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x811e"
    VALUE
    0x80807B10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x811f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x811f"
    VALUE
    0x80807B11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8120_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8120"
    VALUE
    0x80807B12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8121_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8121"
    VALUE
    0x80807B13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8122_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8122"
    VALUE
    0x80807B14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8123_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8123"
    VALUE
    0x80807B15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8124_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8124"
    VALUE
    0x80807B16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8125_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8125"
    VALUE
    0x80807B17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8126_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8126"
    VALUE
    0x80807B18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8127_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8127"
    VALUE
    0x80807B19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8128_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8128"
    VALUE
    0x80807B1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8129_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8129"
    VALUE
    0x80807B1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x812a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x812a"
    VALUE
    0x80807B1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_TiInRow0x8B01_C
    "assigned fault type / Fault type assignment for check DFC_bds_TiInRow0x8B01"
    VALUE
    0x80807B1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_TiInRow0x8B02_C
    "assigned fault type / Fault type assignment for check DFC_bds_TiInRow0x8B02"
    VALUE
    0x80807B1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_TiInRow0x8B03_C
    "assigned fault type / Fault type assignment for check DFC_bds_TiInRow0x8B03"
    VALUE
    0x80807B1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_DevLibBattUHi_C
    "assigned fault type / Fault type assignment for check DFC_DevLibBattUHi"
    VALUE
    0x80807B20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_DevLibBattULo_C
    "assigned fault type / Fault type assignment for check DFC_DevLibBattULo"
    VALUE
    0x80807B21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8063_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8063"
    VALUE
    0x80807B22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8064_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8064"
    VALUE
    0x80807B23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8065_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8065"
    VALUE
    0x80807B24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8066_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8066"
    VALUE
    0x80807B25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8067_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8067"
    VALUE
    0x80807B26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8068_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8068"
    VALUE
    0x80807B27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8069_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8069"
    VALUE
    0x80807B28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x806a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x806a"
    VALUE
    0x80807B29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x806b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x806b"
    VALUE
    0x80807B2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x806c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x806c"
    VALUE
    0x80807B2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x806d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x806d"
    VALUE
    0x80807B2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x806e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x806e"
    VALUE
    0x80807B2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x806f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x806f"
    VALUE
    0x80807B2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8070_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8070"
    VALUE
    0x80807B2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8071_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8071"
    VALUE
    0x80807B30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8072_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8072"
    VALUE
    0x80807B31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8073_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8073"
    VALUE
    0x80807B32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8074_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8074"
    VALUE
    0x80807B33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8075_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8075"
    VALUE
    0x80807B34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8076_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8076"
    VALUE
    0x80807B35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8077_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8077"
    VALUE
    0x80807B36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8078_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8078"
    VALUE
    0x80807B37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8079_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8079"
    VALUE
    0x80807B38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x807a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x807a"
    VALUE
    0x80807B39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x807b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x807b"
    VALUE
    0x80807B3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x807c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x807c"
    VALUE
    0x80807B3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x807d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x807d"
    VALUE
    0x80807B3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x807e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x807e"
    VALUE
    0x80807B3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x807f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x807f"
    VALUE
    0x80807B3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8080_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8080"
    VALUE
    0x80807B3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8081_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8081"
    VALUE
    0x80807B40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8082_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8082"
    VALUE
    0x80807B41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8083_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8083"
    VALUE
    0x80807B42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8084_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8084"
    VALUE
    0x80807B43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8085_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8085"
    VALUE
    0x80807B44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8086_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8086"
    VALUE
    0x80807B45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8087_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8087"
    VALUE
    0x80807B46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8088_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8088"
    VALUE
    0x80807B47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8089_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8089"
    VALUE
    0x80807B48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x808a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x808a"
    VALUE
    0x80807B49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x808b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x808b"
    VALUE
    0x80807B4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x808c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x808c"
    VALUE
    0x80807B4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x808d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x808d"
    VALUE
    0x80807B4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x808e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x808e"
    VALUE
    0x80807B4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x808f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x808f"
    VALUE
    0x80807B4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8090_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8090"
    VALUE
    0x80807B4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8091_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8091"
    VALUE
    0x80807B50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8092_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8092"
    VALUE
    0x80807B51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8093_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8093"
    VALUE
    0x80807B52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8094_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8094"
    VALUE
    0x80807B53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8095_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8095"
    VALUE
    0x80807B54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8096_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8096"
    VALUE
    0x80807B55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8097_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8097"
    VALUE
    0x80807B56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8098_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8098"
    VALUE
    0x80807B57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8099_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8099"
    VALUE
    0x80807B58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x809a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x809a"
    VALUE
    0x80807B59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x809b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x809b"
    VALUE
    0x80807B5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x809c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x809c"
    VALUE
    0x80807B5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x809d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x809d"
    VALUE
    0x80807B5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x809e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x809e"
    VALUE
    0x80807B5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x809f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x809f"
    VALUE
    0x80807B5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80a0_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80a0"
    VALUE
    0x80807B5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80a1_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80a1"
    VALUE
    0x80807B60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80a2_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80a2"
    VALUE
    0x80807B61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80a3_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80a3"
    VALUE
    0x80807B62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80a4_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80a4"
    VALUE
    0x80807B63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80a5_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80807B64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80a6_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80a6"
    VALUE
    0x80807B65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80a7_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80a7"
    VALUE
    0x80807B66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80a8_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80a8"
    VALUE
    0x80807B67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80a9_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80a9"
    VALUE
    0x80807B68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80aa_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80aa"
    VALUE
    0x80807B69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ab_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ab"
    VALUE
    0x80807B6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ac_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ac"
    VALUE
    0x80807B6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ad_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ad"
    VALUE
    0x80807B6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ae_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ae"
    VALUE
    0x80807B6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80af_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80af"
    VALUE
    0x80807B6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80b0_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80b0"
    VALUE
    0x80807B6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80b1_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80b1"
    VALUE
    0x80807B70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80b2_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80b2"
    VALUE
    0x80807B71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80b3_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80b3"
    VALUE
    0x80807B72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80b4_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80b4"
    VALUE
    0x80807B73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80b5_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80b5"
    VALUE
    0x80807B74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80b6_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80b6"
    VALUE
    0x80807B75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80b7_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80b7"
    VALUE
    0x80807B76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80b8_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80b8"
    VALUE
    0x80807B77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80b9_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80b9"
    VALUE
    0x80807B78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80ba_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80ba"
    VALUE
    0x80807B79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80bb_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80bb"
    VALUE
    0x80807B7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80bc_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80bc"
    VALUE
    0x80807B7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80bd_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80bd"
    VALUE
    0x80807B7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80be_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80be"
    VALUE
    0x80807B7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80bf_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80bf"
    VALUE
    0x80807B7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80c0_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80c0"
    VALUE
    0x80807B7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80c1_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80c1"
    VALUE
    0x80807B80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80c2_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80c2"
    VALUE
    0x80807B81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80c3_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80c3"
    VALUE
    0x80807B82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80c4_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80c4"
    VALUE
    0x80807B83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80c5_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80c5"
    VALUE
    0x80807B84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x80c6_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x80c6"
    VALUE
    0x80807B85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_TiUpDwn0x8A01_C
    "assigned fault type / Fault type assignment for check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x80807B86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_TiUpDwn0x8A02_C
    "assigned fault type / Fault type assignment for check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x80807B87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_TiUpDwn0x8A03_C
    "assigned fault type / Fault type assignment for check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x80807B88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA13OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA13OR"
    VALUE
    0x80807B89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA13SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA13SCB"
    VALUE
    0x80807B8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA13SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA13SCG"
    VALUE
    0x80807B8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA14OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA14OR"
    VALUE
    0x80807B8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA14SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA14SCB"
    VALUE
    0x80807B8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA14SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA14SCG"
    VALUE
    0x80807B8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA21OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA21OR"
    VALUE
    0x80807B8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA21SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA21SCB"
    VALUE
    0x80807B90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA21SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA21SCG"
    VALUE
    0x80807B91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA22OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA22OR"
    VALUE
    0x80807B92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA22SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA22SCB"
    VALUE
    0x80807B93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA22SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA22SCG"
    VALUE
    0x80807B94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA23OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA23OR"
    VALUE
    0x80807B95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA23SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA23SCB"
    VALUE
    0x80807B96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA23SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA23SCG"
    VALUE
    0x80807B97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA24OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA24OR"
    VALUE
    0x80807B98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA24SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA24SCB"
    VALUE
    0x80807B99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA24SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA24SCG"
    VALUE
    0x80807B9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA25OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA25OR"
    VALUE
    0x80807B9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA25SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA25SCB"
    VALUE
    0x80807B9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA25SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA25SCG"
    VALUE
    0x80807B9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA26OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA26OR"
    VALUE
    0x80807B9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA26SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA26SCB"
    VALUE
    0x80807B9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA26SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA26SCG"
    VALUE
    0x80807BA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA27OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA27OR"
    VALUE
    0x80807BA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA27SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA27SCB"
    VALUE
    0x80807BA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA27SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA27SCG"
    VALUE
    0x80807BA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA28OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA28OR"
    VALUE
    0x80807BA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA28SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA28SCB"
    VALUE
    0x80807BA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA28SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA28SCG"
    VALUE
    0x80807BA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA29OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA29OR"
    VALUE
    0x80807BA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA29SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA29SCB"
    VALUE
    0x80807BA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA29SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA29SCG"
    VALUE
    0x80807BA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36AicSCB"
    VALUE
    0x80807BAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36AicSCG"
    VALUE
    0x80807BAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36OR"
    VALUE
    0x80807BAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36SCB"
    VALUE
    0x80807BAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36SCG"
    VALUE
    0x80807BAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA36ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80807BAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37AicSCB"
    VALUE
    0x80807BB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37AicSCG"
    VALUE
    0x80807BB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37OR"
    VALUE
    0x80807BB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37SCB"
    VALUE
    0x80807BB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37SCG"
    VALUE
    0x80807BB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA37ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80807BB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA38AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80807BB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA38AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA38AicSCG"
    VALUE
    0x80807BB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA38OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA38OR"
    VALUE
    0x80807BB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA38SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA38SCB"
    VALUE
    0x80807BB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA38SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA38SCG"
    VALUE
    0x80807BBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA38ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80807BBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39AicSCB"
    VALUE
    0x80807BBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80807BBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39OR"
    VALUE
    0x80807BBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39SCB"
    VALUE
    0x80807BBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39SCG"
    VALUE
    0x80807BC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA39ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80807BC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA40OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA40OR"
    VALUE
    0x80807BC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA40SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA40SCB"
    VALUE
    0x80807BC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA40SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA40SCG"
    VALUE
    0x80807BC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA41OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA41OR"
    VALUE
    0x80807BC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA41SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA41SCB"
    VALUE
    0x80807BC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA41SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA41SCG"
    VALUE
    0x80807BC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA42OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA42OR"
    VALUE
    0x80807BC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA42SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA42SCB"
    VALUE
    0x80807BC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA42SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA42SCG"
    VALUE
    0x80807BCA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80807BCB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43AicSCG"
    VALUE
    0x80807BCC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43OR"
    VALUE
    0x80807BCD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43SCB"
    VALUE
    0x80807BCE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43SCG"
    VALUE
    0x80807BCF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA43ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80807BD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA44OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA44OL"
    VALUE
    0x80807BD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA44SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA44SCB"
    VALUE
    0x80807BD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA44SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA44SCG"
    VALUE
    0x80807BD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA57OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA57OR"
    VALUE
    0x80807BD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA57SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA57SCB"
    VALUE
    0x80807BD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA57SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA57SCG"
    VALUE
    0x80807BD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA59OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA59OL"
    VALUE
    0x80807BD7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA59SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA59SCB"
    VALUE
    0x80807BD8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inA59SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inA59SCG"
    VALUE
    0x80807BD9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK10OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK10OR"
    VALUE
    0x80807BDA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK10SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK10SCB"
    VALUE
    0x80807BDB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK10SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK10SCG"
    VALUE
    0x80807BDC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK11OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK11OR"
    VALUE
    0x80807BDD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK11SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK11SCB"
    VALUE
    0x80807BDE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK11SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK11SCG"
    VALUE
    0x80807BDF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30AicSCB"
    VALUE
    0x80807BE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80807BE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30OR"
    VALUE
    0x80807BE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30SCB"
    VALUE
    0x80807BE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30SCG"
    VALUE
    0x80807BE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK30ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80807BE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK31OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK31OR"
    VALUE
    0x80807BE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK31SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK31SCB"
    VALUE
    0x80807BE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK31SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK31SCG"
    VALUE
    0x80807BE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK32OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK32OR"
    VALUE
    0x80807BE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK32SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK32SCB"
    VALUE
    0x80807BEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK32SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK32SCG"
    VALUE
    0x80807BEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK33OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK33OR"
    VALUE
    0x80807BEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK33SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK33SCB"
    VALUE
    0x80807BED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK33SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK33SCG"
    VALUE
    0x80807BEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK34OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK34OR"
    VALUE
    0x80807BEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK34SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK34SCB"
    VALUE
    0x80807BF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK34SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK34SCG"
    VALUE
    0x80807BF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK35OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK35OR"
    VALUE
    0x80807BF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK35SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK35SCB"
    VALUE
    0x80807BF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK35SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK35SCG"
    VALUE
    0x80807BF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK36OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK36OR"
    VALUE
    0x80807BF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK36SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK36SCB"
    VALUE
    0x80807BF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK36SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK36SCG"
    VALUE
    0x80807BF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37AicSCB"
    VALUE
    0x80807BF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37AicSCG"
    VALUE
    0x80807BF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37OR"
    VALUE
    0x80807BFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37SCB"
    VALUE
    0x80807BFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37SCG"
    VALUE
    0x80807BFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK37ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80807BFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80807BFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80807BFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38OR"
    VALUE
    0x80807C00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38SCB"
    VALUE
    0x80807C01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38SCG"
    VALUE
    0x80807C02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK38ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80807C03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39AicSCB"
    VALUE
    0x80807C04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80807C05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39OR"
    VALUE
    0x80807C06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39SCB"
    VALUE
    0x80807C07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39SCG"
    VALUE
    0x80807C08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK39ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80807C09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40AicSCB"
    VALUE
    0x80807C0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80807C0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40OR"
    VALUE
    0x80807C0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40SCB"
    VALUE
    0x80807C0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40SCG"
    VALUE
    0x80807C0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK40ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80807C0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41AicSCB"
    VALUE
    0x80807C10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41AicSCG"
    VALUE
    0x80807C11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41OR"
    VALUE
    0x80807C12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41SCB"
    VALUE
    0x80807C13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41SCG"
    VALUE
    0x80807C14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK41ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80807C15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42AicSCB"
    VALUE
    0x80807C16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42AicSCG"
    VALUE
    0x80807C17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42OR"
    VALUE
    0x80807C18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42SCB"
    VALUE
    0x80807C19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42SCG"
    VALUE
    0x80807C1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK42ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80807C1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK43OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK43OR"
    VALUE
    0x80807C1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK43SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK43SCB"
    VALUE
    0x80807C1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK43SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK43SCG"
    VALUE
    0x80807C1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80807C1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44AicSCG"
    VALUE
    0x80807C20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44OR"
    VALUE
    0x80807C21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44SCB"
    VALUE
    0x80807C22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44SCG"
    VALUE
    0x80807C23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK44ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80807C24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45AicSCB"
    VALUE
    0x80807C25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45AicSCG"
    VALUE
    0x80807C26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45OR"
    VALUE
    0x80807C27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45SCB"
    VALUE
    0x80807C28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45SCG"
    VALUE
    0x80807C29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK45ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80807C2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK52OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK52OR"
    VALUE
    0x80807C2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK52SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK52SCB"
    VALUE
    0x80807C2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK52SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK52SCG"
    VALUE
    0x80807C2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK53OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK53OR"
    VALUE
    0x80807C2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK53SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK53SCB"
    VALUE
    0x80807C2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK53SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK53SCG"
    VALUE
    0x80807C30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54AicSCB"
    VALUE
    0x80807C31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80807C32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54OR"
    VALUE
    0x80807C33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54SCB"
    VALUE
    0x80807C34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54SCG"
    VALUE
    0x80807C35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK54ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80807C36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55AicSCB"
    VALUE
    0x80807C37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55AicSCG"
    VALUE
    0x80807C38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55OR"
    VALUE
    0x80807C39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55SCB"
    VALUE
    0x80807C3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55SCG"
    VALUE
    0x80807C3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK55ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80807C3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK56OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK56OR"
    VALUE
    0x80807C3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK56SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK56SCB"
    VALUE
    0x80807C3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK56SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK56SCG"
    VALUE
    0x80807C3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK57OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK57OR"
    VALUE
    0x80807C40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK57SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK57SCB"
    VALUE
    0x80807C41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK57SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK57SCG"
    VALUE
    0x80807C42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK58OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK58OR"
    VALUE
    0x80807C43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK58SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK58SCB"
    VALUE
    0x80807C44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK58SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK58SCG"
    VALUE
    0x80807C45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK59OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK59OR"
    VALUE
    0x80807C46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK59SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK59SCB"
    VALUE
    0x80807C47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK59SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK59SCG"
    VALUE
    0x80807C48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK60OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK60OR"
    VALUE
    0x80807C49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK60SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK60SCB"
    VALUE
    0x80807C4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK60SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK60SCG"
    VALUE
    0x80807C4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61AicSCB"
    VALUE
    0x80807C4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61AicSCG"
    VALUE
    0x80807C4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61OR"
    VALUE
    0x80807C4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61SCB"
    VALUE
    0x80807C4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61SCG"
    VALUE
    0x80807C50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK61ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80807C51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK62OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK62OR"
    VALUE
    0x80807C52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK62SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK62SCB"
    VALUE
    0x80807C53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK62SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK62SCG"
    VALUE
    0x80807C54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80807C55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63AicSCG"
    VALUE
    0x80807C56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63OR"
    VALUE
    0x80807C57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63SCB"
    VALUE
    0x80807C58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63SCG"
    VALUE
    0x80807C59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK63ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80807C5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64AicSCB"
    VALUE
    0x80807C5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64AicSCG"
    VALUE
    0x80807C5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64OR"
    VALUE
    0x80807C5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64SCB"
    VALUE
    0x80807C5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64SCG"
    VALUE
    0x80807C5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
