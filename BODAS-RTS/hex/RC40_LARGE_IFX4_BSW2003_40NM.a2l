    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK64ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80807C60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65AicSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80807C61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65AicSCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80807C62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65OR"
    VALUE
    0x80807C63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65SCB"
    VALUE
    0x80807C64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65SCG"
    VALUE
    0x80807C65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK65ShuntSCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80807C66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK74OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK74OR"
    VALUE
    0x80807C67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK74SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK74SCB"
    VALUE
    0x80807C68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK74SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK74SCG"
    VALUE
    0x80807C69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK75OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK75OR"
    VALUE
    0x80807C6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK75SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK75SCB"
    VALUE
    0x80807C6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK75SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK75SCG"
    VALUE
    0x80807C6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK76OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK76OR"
    VALUE
    0x80807C6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK76SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK76SCB"
    VALUE
    0x80807C6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK76SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK76SCG"
    VALUE
    0x80807C6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK77OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK77OR"
    VALUE
    0x80807C70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK77SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK77SCB"
    VALUE
    0x80807C71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK77SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK77SCG"
    VALUE
    0x80807C72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK78OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK78OR"
    VALUE
    0x80807C73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK78SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK78SCB"
    VALUE
    0x80807C74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inK78SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inK78SCG"
    VALUE
    0x80807C75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_DvUBAT_FWs_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80807C76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OVErr_VPR6_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80807C77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OVWarn_VPR6_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80807C78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80807C79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80807C7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_UBAT_MON_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80807C7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80807C7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80807C7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_UBRM24_MON_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80807C7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VDD5_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80807C7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VDD5_IN_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80807C80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VPR6_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80807C81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VSS3_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80807C82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VSS4_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80807C83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_Temp1_HTErr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80807C84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_Temp1_HTWarn_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80807C85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_Temp2_HTErr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80807C86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_Temp2_HTWarn_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80807C87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80807C88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80807C89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VDD5_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80807C8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VDD5_IN_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80807C8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VPR6_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80807C8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VSS3_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80807C8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VSS4_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80807C8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA01OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA01OL"
    VALUE
    0x80807C8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA01OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA01OT"
    VALUE
    0x80807C90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA01SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA01SCB"
    VALUE
    0x80807C91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA01SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA01SCG"
    VALUE
    0x80807C92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02OL"
    VALUE
    0x80807C93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02OR"
    VALUE
    0x80807C94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02OT"
    VALUE
    0x80807C95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02SCB"
    VALUE
    0x80807C96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02SCG"
    VALUE
    0x80807C97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03OL"
    VALUE
    0x80807C98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03OT"
    VALUE
    0x80807C99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03SCB"
    VALUE
    0x80807C9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03SCG"
    VALUE
    0x80807C9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04OL"
    VALUE
    0x80807C9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04OT"
    VALUE
    0x80807C9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04SCB"
    VALUE
    0x80807C9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04SCG"
    VALUE
    0x80807C9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05OL"
    VALUE
    0x80807CA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05OR"
    VALUE
    0x80807CA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05OT"
    VALUE
    0x80807CA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05SCB"
    VALUE
    0x80807CA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05SCG"
    VALUE
    0x80807CA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA06OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA06OL"
    VALUE
    0x80807CA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA06OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA06OR"
    VALUE
    0x80807CA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA06OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA06OT"
    VALUE
    0x80807CA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA06SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA06SCB"
    VALUE
    0x80807CA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA06SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA06SCG"
    VALUE
    0x80807CA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07OL"
    VALUE
    0x80807CAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07OT"
    VALUE
    0x80807CAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07SCB"
    VALUE
    0x80807CAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07SCG"
    VALUE
    0x80807CAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08OL"
    VALUE
    0x80807CAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08OT"
    VALUE
    0x80807CAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08SCB"
    VALUE
    0x80807CB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08SCG"
    VALUE
    0x80807CB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09OL"
    VALUE
    0x80807CB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09OR"
    VALUE
    0x80807CB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09OT"
    VALUE
    0x80807CB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09SCB"
    VALUE
    0x80807CB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09SCG"
    VALUE
    0x80807CB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10OL"
    VALUE
    0x80807CB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10OT"
    VALUE
    0x80807CB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10SCB"
    VALUE
    0x80807CB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10SCG"
    VALUE
    0x80807CBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA11OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA11OL"
    VALUE
    0x80807CBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA11OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA11OT"
    VALUE
    0x80807CBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA11SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA11SCB"
    VALUE
    0x80807CBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA11SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA11SCG"
    VALUE
    0x80807CBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA12OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA12OR"
    VALUE
    0x80807CBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA12SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA12SCB"
    VALUE
    0x80807CC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA12SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA12SCG"
    VALUE
    0x80807CC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA16OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA16OL"
    VALUE
    0x80807CC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA16OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA16OT"
    VALUE
    0x80807CC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA16SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA16SCB"
    VALUE
    0x80807CC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA16SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA16SCG"
    VALUE
    0x80807CC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17OL"
    VALUE
    0x80807CC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17OR"
    VALUE
    0x80807CC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17OT"
    VALUE
    0x80807CC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17SCB"
    VALUE
    0x80807CC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17SCG"
    VALUE
    0x80807CCA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18OL"
    VALUE
    0x80807CCB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18OT"
    VALUE
    0x80807CCC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18SCB"
    VALUE
    0x80807CCD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18SCG"
    VALUE
    0x80807CCE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19OL"
    VALUE
    0x80807CCF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19OR"
    VALUE
    0x80807CD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19OT"
    VALUE
    0x80807CD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19SCB"
    VALUE
    0x80807CD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19SCG"
    VALUE
    0x80807CD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20OL"
    VALUE
    0x80807CD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20OR"
    VALUE
    0x80807CD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20OT"
    VALUE
    0x80807CD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20SCB"
    VALUE
    0x80807CD7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20SCG"
    VALUE
    0x80807CD8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31OL"
    VALUE
    0x80807CD9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31OR"
    VALUE
    0x80807CDA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31OT"
    VALUE
    0x80807CDB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31SCB"
    VALUE
    0x80807CDC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31SCG"
    VALUE
    0x80807CDD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32OL"
    VALUE
    0x80807CDE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32OR"
    VALUE
    0x80807CDF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32OT"
    VALUE
    0x80807CE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32SCB"
    VALUE
    0x80807CE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32SCG"
    VALUE
    0x80807CE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33OL"
    VALUE
    0x80807CE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33OR"
    VALUE
    0x80807CE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33OT"
    VALUE
    0x80807CE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33SCB"
    VALUE
    0x80807CE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33SCG"
    VALUE
    0x80807CE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34OL"
    VALUE
    0x80807CE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34OR"
    VALUE
    0x80807CE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34OT"
    VALUE
    0x80807CEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34SCB"
    VALUE
    0x80807CEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34SCG"
    VALUE
    0x80807CEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35OL"
    VALUE
    0x80807CED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35OR"
    VALUE
    0x80807CEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35OT"
    VALUE
    0x80807CEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35SCB"
    VALUE
    0x80807CF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35SCG"
    VALUE
    0x80807CF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46OL"
    VALUE
    0x80807CF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46OR"
    VALUE
    0x80807CF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46OT"
    VALUE
    0x80807CF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46SCB"
    VALUE
    0x80807CF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46SCG"
    VALUE
    0x80807CF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47OL"
    VALUE
    0x80807CF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47OR"
    VALUE
    0x80807CF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47OT"
    VALUE
    0x80807CF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47SCB"
    VALUE
    0x80807CFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47SCG"
    VALUE
    0x80807CFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48OL"
    VALUE
    0x80807CFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48OR"
    VALUE
    0x80807CFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48OT"
    VALUE
    0x80807CFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48SCB"
    VALUE
    0x80807CFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48SCG"
    VALUE
    0x80807D00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA49OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA49OL"
    VALUE
    0x80807D01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA49OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA49OT"
    VALUE
    0x80807D02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA49SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA49SCB"
    VALUE
    0x80807D03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA49SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA49SCG"
    VALUE
    0x80807D04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA50OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA50OL"
    VALUE
    0x80807D05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA50OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA50OT"
    VALUE
    0x80807D06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA50SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA50SCB"
    VALUE
    0x80807D07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA50SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA50SCG"
    VALUE
    0x80807D08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51OL"
    VALUE
    0x80807D09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51OR"
    VALUE
    0x80807D0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51OT"
    VALUE
    0x80807D0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51SCB"
    VALUE
    0x80807D0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51SCG"
    VALUE
    0x80807D0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52OL"
    VALUE
    0x80807D0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52OR"
    VALUE
    0x80807D0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52OT"
    VALUE
    0x80807D10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52SCB"
    VALUE
    0x80807D11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52SCG"
    VALUE
    0x80807D12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53OL"
    VALUE
    0x80807D13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53OR"
    VALUE
    0x80807D14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53OT"
    VALUE
    0x80807D15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53SCB"
    VALUE
    0x80807D16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53SCG"
    VALUE
    0x80807D17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54OL"
    VALUE
    0x80807D18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54OR"
    VALUE
    0x80807D19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54OT"
    VALUE
    0x80807D1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54SCB"
    VALUE
    0x80807D1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54SCG"
    VALUE
    0x80807D1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA55OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA55OL"
    VALUE
    0x80807D1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA55OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA55OT"
    VALUE
    0x80807D1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA55SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA55SCB"
    VALUE
    0x80807D1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA55SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA55SCG"
    VALUE
    0x80807D20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA56OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA56OL"
    VALUE
    0x80807D21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA56OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA56OT"
    VALUE
    0x80807D22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA56SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA56SCB"
    VALUE
    0x80807D23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA56SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA56SCG"
    VALUE
    0x80807D24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA58OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA58OL"
    VALUE
    0x80807D25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA58OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA58OT"
    VALUE
    0x80807D26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA58SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA58SCB"
    VALUE
    0x80807D27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA58SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA58SCG"
    VALUE
    0x80807D28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07OL"
    VALUE
    0x80807D29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07OR"
    VALUE
    0x80807D2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07OT"
    VALUE
    0x80807D2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07SCB"
    VALUE
    0x80807D2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07SCG"
    VALUE
    0x80807D2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08OL"
    VALUE
    0x80807D2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08OR"
    VALUE
    0x80807D2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08OT"
    VALUE
    0x80807D30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08SCB"
    VALUE
    0x80807D31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08SCG"
    VALUE
    0x80807D32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09OL"
    VALUE
    0x80807D33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09OR"
    VALUE
    0x80807D34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09OT"
    VALUE
    0x80807D35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09SCB"
    VALUE
    0x80807D36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09SCG"
    VALUE
    0x80807D37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12OL"
    VALUE
    0x80807D38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12OT"
    VALUE
    0x80807D39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12SCB"
    VALUE
    0x80807D3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12SCG"
    VALUE
    0x80807D3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13OL"
    VALUE
    0x80807D3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13OT"
    VALUE
    0x80807D3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13SCB"
    VALUE
    0x80807D3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13SCG"
    VALUE
    0x80807D3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14OL"
    VALUE
    0x80807D40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14OR"
    VALUE
    0x80807D41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14OT"
    VALUE
    0x80807D42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14SCB"
    VALUE
    0x80807D43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14SCG"
    VALUE
    0x80807D44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15OL"
    VALUE
    0x80807D45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15OR"
    VALUE
    0x80807D46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15OT"
    VALUE
    0x80807D47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15SCB"
    VALUE
    0x80807D48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15SCG"
    VALUE
    0x80807D49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16OL"
    VALUE
    0x80807D4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16OR"
    VALUE
    0x80807D4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16OT"
    VALUE
    0x80807D4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16SCB"
    VALUE
    0x80807D4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16SCG"
    VALUE
    0x80807D4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17OL"
    VALUE
    0x80807D4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17OR"
    VALUE
    0x80807D50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17OT"
    VALUE
    0x80807D51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17SCB"
    VALUE
    0x80807D52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17SCG"
    VALUE
    0x80807D53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK25OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK25OR"
    VALUE
    0x80807D54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK25SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK25SCB"
    VALUE
    0x80807D55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK25SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK25SCG"
    VALUE
    0x80807D56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29OL"
    VALUE
    0x80807D57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29OR"
    VALUE
    0x80807D58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29OT"
    VALUE
    0x80807D59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29SCB"
    VALUE
    0x80807D5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29SCG"
    VALUE
    0x80807D5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51OL"
    VALUE
    0x80807D5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51OT"
    VALUE
    0x80807D5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51SCB"
    VALUE
    0x80807D5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51SCG"
    VALUE
    0x80807D5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK62OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK62OR"
    VALUE
    0x80807D60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK62SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK62SCB"
    VALUE
    0x80807D61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK62SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK62SCG"
    VALUE
    0x80807D62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73OL"
    VALUE
    0x80807D63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73OR"
    VALUE
    0x80807D64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73OT"
    VALUE
    0x80807D65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73SCB"
    VALUE
    0x80807D66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73SCG"
    VALUE
    0x80807D67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK80OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK80OL"
    VALUE
    0x80807D68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK80OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK80OT"
    VALUE
    0x80807D69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK80SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK80SCB"
    VALUE
    0x80807D6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK80SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK80SCG"
    VALUE
    0x80807D6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK81OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK81OL"
    VALUE
    0x80807D6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK81OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK81OT"
    VALUE
    0x80807D6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK81SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK81SCB"
    VALUE
    0x80807D6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK81SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK81SCG"
    VALUE
    0x80807D6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK82OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK82OL"
    VALUE
    0x80807D70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK82OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK82OT"
    VALUE
    0x80807D71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK82SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK82SCB"
    VALUE
    0x80807D72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK82SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK82SCG"
    VALUE
    0x80807D73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK83OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK83OL"
    VALUE
    0x80807D74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK83OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK83OT"
    VALUE
    0x80807D75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK83SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK83SCB"
    VALUE
    0x80807D76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK83SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK83SCG"
    VALUE
    0x80807D77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK84OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK84OL"
    VALUE
    0x80807D78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK84OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK84OT"
    VALUE
    0x80807D79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK84SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK84SCB"
    VALUE
    0x80807D7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK84SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK84SCG"
    VALUE
    0x80807D7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK85OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK85OL"
    VALUE
    0x80807D7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK85OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK85OT"
    VALUE
    0x80807D7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK85SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK85SCB"
    VALUE
    0x80807D7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK85SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK85SCG"
    VALUE
    0x80807D7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK86OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK86OL"
    VALUE
    0x80807D80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK86OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK86OT"
    VALUE
    0x80807D81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK86SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK86SCB"
    VALUE
    0x80807D82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK86SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK86SCG"
    VALUE
    0x80807D83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK87OL_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK87OL"
    VALUE
    0x80807D84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK87OT_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK87OT"
    VALUE
    0x80807D85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK87SCB_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK87SCB"
    VALUE
    0x80807D86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK87SCG_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK87SCG"
    VALUE
    0x80807D87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_DSMDummy_C
    "assigned fault type / Fault type assignment for check DFC_DSMDummy"
    VALUE
    0x80807D88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8000_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8000"
    VALUE
    0x80807D89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8001_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8001"
    VALUE
    0x80807D8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8002_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8002"
    VALUE
    0x80807D8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8003_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8003"
    VALUE
    0x80807D8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8004_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8004"
    VALUE
    0x80807D8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8005_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8005"
    VALUE
    0x80807D8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8006_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8006"
    VALUE
    0x80807D8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8007_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8007"
    VALUE
    0x80807D90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8008_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8008"
    VALUE
    0x80807D91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8009_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8009"
    VALUE
    0x80807D92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x800a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x800a"
    VALUE
    0x80807D93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x800b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x800b"
    VALUE
    0x80807D94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x800c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x800c"
    VALUE
    0x80807D95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x800d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x800d"
    VALUE
    0x80807D96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x800e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x800e"
    VALUE
    0x80807D97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x800f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x800f"
    VALUE
    0x80807D98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8010_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8010"
    VALUE
    0x80807D99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8011_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8011"
    VALUE
    0x80807D9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8012_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8012"
    VALUE
    0x80807D9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8013_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8013"
    VALUE
    0x80807D9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8014_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8014"
    VALUE
    0x80807D9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8015_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8015"
    VALUE
    0x80807D9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8016_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8016"
    VALUE
    0x80807D9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8017_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8017"
    VALUE
    0x80807DA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8018_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8018"
    VALUE
    0x80807DA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8019_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8019"
    VALUE
    0x80807DA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x801a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x801a"
    VALUE
    0x80807DA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x801b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x801b"
    VALUE
    0x80807DA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x801c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x801c"
    VALUE
    0x80807DA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x801d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x801d"
    VALUE
    0x80807DA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x801e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x801e"
    VALUE
    0x80807DA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x801f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x801f"
    VALUE
    0x80807DA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8020_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8020"
    VALUE
    0x80807DA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8021_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8021"
    VALUE
    0x80807DAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8022_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8022"
    VALUE
    0x80807DAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8023_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8023"
    VALUE
    0x80807DAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8024_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8024"
    VALUE
    0x80807DAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8025_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8025"
    VALUE
    0x80807DAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8026_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8026"
    VALUE
    0x80807DAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8027_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8027"
    VALUE
    0x80807DB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8028_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8028"
    VALUE
    0x80807DB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8029_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8029"
    VALUE
    0x80807DB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x802a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x802a"
    VALUE
    0x80807DB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x802b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x802b"
    VALUE
    0x80807DB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x802c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x802c"
    VALUE
    0x80807DB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x802d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x802d"
    VALUE
    0x80807DB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x802e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x802e"
    VALUE
    0x80807DB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x802f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x802f"
    VALUE
    0x80807DB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8030_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8030"
    VALUE
    0x80807DB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8031_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8031"
    VALUE
    0x80807DBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8032_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8032"
    VALUE
    0x80807DBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8033_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8033"
    VALUE
    0x80807DBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8034_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8034"
    VALUE
    0x80807DBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8035_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8035"
    VALUE
    0x80807DBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8036_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8036"
    VALUE
    0x80807DBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8037_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8037"
    VALUE
    0x80807DC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8038_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8038"
    VALUE
    0x80807DC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8039_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8039"
    VALUE
    0x80807DC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x803a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x803a"
    VALUE
    0x80807DC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x803b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x803b"
    VALUE
    0x80807DC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x803c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x803c"
    VALUE
    0x80807DC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x803d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x803d"
    VALUE
    0x80807DC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x803e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x803e"
    VALUE
    0x80807DC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x803f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x803f"
    VALUE
    0x80807DC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8040_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8040"
    VALUE
    0x80807DC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8041_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8041"
    VALUE
    0x80807DCA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8042_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8042"
    VALUE
    0x80807DCB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8043_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8043"
    VALUE
    0x80807DCC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8044_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8044"
    VALUE
    0x80807DCD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8045_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8045"
    VALUE
    0x80807DCE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8046_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8046"
    VALUE
    0x80807DCF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8047_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8047"
    VALUE
    0x80807DD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8048_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8048"
    VALUE
    0x80807DD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8049_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8049"
    VALUE
    0x80807DD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x804a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x804a"
    VALUE
    0x80807DD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x804b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x804b"
    VALUE
    0x80807DD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x804c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x804c"
    VALUE
    0x80807DD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x804d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x804d"
    VALUE
    0x80807DD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x804e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x804e"
    VALUE
    0x80807DD7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x804f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x804f"
    VALUE
    0x80807DD8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8050_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8050"
    VALUE
    0x80807DD9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8051_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8051"
    VALUE
    0x80807DDA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8052_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8052"
    VALUE
    0x80807DDB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8053_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8053"
    VALUE
    0x80807DDC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8054_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8054"
    VALUE
    0x80807DDD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8055_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8055"
    VALUE
    0x80807DDE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8056_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8056"
    VALUE
    0x80807DDF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8057_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8057"
    VALUE
    0x80807DE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8058_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8058"
    VALUE
    0x80807DE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8059_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8059"
    VALUE
    0x80807DE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x805a_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x805a"
    VALUE
    0x80807DE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x805b_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x805b"
    VALUE
    0x80807DE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x805c_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x805c"
    VALUE
    0x80807DE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x805d_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x805d"
    VALUE
    0x80807DE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x805e_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x805e"
    VALUE
    0x80807DE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x805f_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x805f"
    VALUE
    0x80807DE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8060_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8060"
    VALUE
    0x80807DE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8061_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8061"
    VALUE
    0x80807DEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8062_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8062"
    VALUE
    0x80807DEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8C01_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8C01"
    VALUE
    0x80807DEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8C02_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8C02"
    VALUE
    0x80807DED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_bds_NoDeb0x8C03_C
    "assigned fault type / Fault type assignment for check DFC_bds_NoDeb0x8C03"
    VALUE
    0x80807DEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetDataNoBuf_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80807DEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetDataParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetDataParam"
    VALUE
    0x80807DF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetDataboxNoInit_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80807DF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80807DF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetRxBufStatusParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80807DF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetStatusParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetStatusParam"
    VALUE
    0x80807DF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canGetTxBufStatusParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80807DF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canInitParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canInitParam"
    VALUE
    0x80807DF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canInitRxDataboxOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80807DF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canInitRxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80807DF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canInitTxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80807DF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canIpduGroupControl_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80807DFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canIsDataboxFreeNoInit_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80807DFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canIsDataboxFreeParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80807DFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canIsTxEmptyParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80807DFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegBusOffCallbInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80807DFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegBusOffCallbParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80807DFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxBufInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80807E00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxBufOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80807E01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxBufParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80807E02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxCallbInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80807E03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxCallbParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80807E04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxDataboxInvNumb_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80807E05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxDataboxInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80807E06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxDataboxOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80807E07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegRxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80807E08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxBufInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80807E09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxBufOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80807E0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxBufParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80807E0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxDataboxInvNumb_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80807E0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxDataboxInvState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80807E0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxDataboxOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x80807E0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canRegTxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80807E0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canResetTxBufParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80807E10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canSendDataBufOvfl_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80807E11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canSendDataParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canSendDataParam"
    VALUE
    0x80807E12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canSendDataboxNoInit_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80807E13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canSendDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80807E14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canSetTxCycleParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80807E15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canStartParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canStartParam"
    VALUE
    0x80807E16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_canStopParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_canStopParam"
    VALUE
    0x80807E17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_can_ClearIpduGroup_C
    "assigned fault type / Fault type assignment for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80807E18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_can_ReceiveSignal_C
    "assigned fault type / Fault type assignment for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80807E19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_can_SendSignal_C
    "assigned fault type / Fault type assignment for check DFC_rbr_can_SendSignal"
    VALUE
    0x80807E1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_can_SetIpduGroup_C
    "assigned fault type / Fault type assignment for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80807E1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmDTCJ1939_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80807E1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmDelDTCJ1939_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80807E1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmDelErrors_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmDelErrors"
    VALUE
    0x80807E1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmGetDFES_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmGetDFES"
    VALUE
    0x80807E1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmGetDTCJ1939_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80807E20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmGetErrors_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmGetErrors"
    VALUE
    0x80807E21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmGetNumErrors_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80807E22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmInitQueueOverflow_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80807E23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmNumDTCJ1939_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80807E24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmTesterror_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmTesterror"
    VALUE
    0x80807E25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmUpdateDebError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80807E26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmUpdateError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmUpdateError"
    VALUE
    0x80807E27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmgetDFCStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80807E28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_dsmtestErrorDFC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80807E29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAi_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAi"
    VALUE
    0x80807E2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAic_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAic"
    VALUE
    0x80807E2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAicCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAicCfg"
    VALUE
    0x80807E2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAicGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAicGetStatus"
    VALUE
    0x80807E2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAid_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAid"
    VALUE
    0x80807E2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAidCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAidCfg"
    VALUE
    0x80807E2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAiv_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAiv"
    VALUE
    0x80807E30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAivCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAivCfg"
    VALUE
    0x80807E31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inAivGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inAivGetStatus"
    VALUE
    0x80807E32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inDi_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inDi"
    VALUE
    0x80807E33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inFi_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inFi"
    VALUE
    0x80807E34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inFiCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inFiCfg"
    VALUE
    0x80807E35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inFiGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inFiGetStatus"
    VALUE
    0x80807E36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inFi_Buffered_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inFi_Buffered"
    VALUE
    0x80807E37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inPhase_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inPhase"
    VALUE
    0x80807E38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inPhaseGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80807E39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inPhaseResetCounter_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x80807E3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inRi_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inRi"
    VALUE
    0x80807E3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inRiCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inRiCfg"
    VALUE
    0x80807E3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inRiCfgTemp_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x80807E3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inRiGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inRiGetStatus"
    VALUE
    0x80807E3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inRiGetTemp_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inRiGetTemp"
    VALUE
    0x80807E3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentCopyFDFifo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x80807E40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentDisable_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentDisable"
    VALUE
    0x80807E41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentEnable_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentEnable"
    VALUE
    0x80807E42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentGetErrorStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x80807E43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentGetFD_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentGetFD"
    VALUE
    0x80807E44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentGetSD_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentGetSD"
    VALUE
    0x80807E45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentGetSDDatabox_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x80807E46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentGetStatus"
    VALUE
    0x80807E47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentInitSDDatabox_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x80807E48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentRegisterCopyFDFifo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x80807E49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentRegisterFDFifo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x80807E4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_inSentRegisterSDDataboxes_C
    "assigned fault type / Fault type assignment for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x80807E4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusCanRxBufferOverflow_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x80807E4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusGetCaAddrParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x80807E4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusGetDiagnosticParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x80807E4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x80807E4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusGetStatusParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x80807E50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitCommCaMissing_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x80807E51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitCommParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x80807E52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitCommState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitCommState"
    VALUE
    0x80807E53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitDiagnosticParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x80807E54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitFailureListParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x80807E55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitRxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x80807E56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusInitTxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x80807E57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegRxDataboxOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x80807E58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegRxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x80807E59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegRxDataboxState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x80807E5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegTxDataboxOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80807E5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegTxDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80807E5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegTxDataboxState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80807E5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x80807E5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegisterInstancesOverlap_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x80807E5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegisterInstancesParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x80807E60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusRegisterInstancesState_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x80807E61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSendDataboxParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x80807E62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSendRequestPGNParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80807E63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaAddrCaUsed_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80807E64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaAddrComm_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80807E65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaAddrInvCan_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80807E66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaAddrParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80807E67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaInfoParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80807E68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSetCaNameParam_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80807E69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_isobusSftyCanTxErr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80807E6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_ReceiveSignal_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80807E6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_SendSignal_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_SendSignal"
    VALUE
    0x80807E6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_getStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_getStatus"
    VALUE
    0x80807E6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_gotoSleep_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80807E6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_scheduleRequest_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80807E6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_lin_wakeUp_C
    "assigned fault type / Fault type assignment for check DFC_rbr_lin_wakeUp"
    VALUE
    0x80807E70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memFlsCfgShr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x80807E71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memGetStatus"
    VALUE
    0x80807E72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memMarkBlock_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memMarkBlock"
    VALUE
    0x80807E73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadApi1Error_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80807E74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadApi2Error_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80807E75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadBlock_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadBlock"
    VALUE
    0x80807E76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadCalibInputError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80807E77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadCalibOuputError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80807E78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memReadSystemError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memReadSystemError"
    VALUE
    0x80807E79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_memWriteBlock_C
    "assigned fault type / Fault type assignment for check DFC_rbr_memWriteBlock"
    VALUE
    0x80807E7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_moOV_FirstConstADC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80807E7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_moOV_SecondConstADC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80807E7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_moUV_FirstConstADC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80807E7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_moUV_SecondConstADC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80807E7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_INH_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_INH"
    VALUE
    0x80807E7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_INHLatch_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_INHLatch"
    VALUE
    0x80807E80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_adcPDD_fail_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x80807E81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_memoryProtection_err_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x80807E82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02OC"
    VALUE
    0x80807E83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA02Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA02Unintended"
    VALUE
    0x80807E84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03OC"
    VALUE
    0x80807E85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA03Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA03Unintended"
    VALUE
    0x80807E86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04OC"
    VALUE
    0x80807E87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA04Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA04Unintended"
    VALUE
    0x80807E88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05OC"
    VALUE
    0x80807E89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA05Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA05Unintended"
    VALUE
    0x80807E8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07OC"
    VALUE
    0x80807E8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA07Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA07Unintended"
    VALUE
    0x80807E8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08OC"
    VALUE
    0x80807E8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA08Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA08Unintended"
    VALUE
    0x80807E8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09OC"
    VALUE
    0x80807E8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA09Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA09Unintended"
    VALUE
    0x80807E90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10OC"
    VALUE
    0x80807E91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA10Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA10Unintended"
    VALUE
    0x80807E92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17OC"
    VALUE
    0x80807E93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA17Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA17Unintended"
    VALUE
    0x80807E94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18OC"
    VALUE
    0x80807E95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA18Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA18Unintended"
    VALUE
    0x80807E96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19OC"
    VALUE
    0x80807E97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA19Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA19Unintended"
    VALUE
    0x80807E98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20OC"
    VALUE
    0x80807E99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA20Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA20Unintended"
    VALUE
    0x80807E9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31OC"
    VALUE
    0x80807E9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA31Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA31Unintended"
    VALUE
    0x80807E9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32OC"
    VALUE
    0x80807E9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA32Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA32Unintended"
    VALUE
    0x80807E9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33OC"
    VALUE
    0x80807E9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA33Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA33Unintended"
    VALUE
    0x80807EA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34OC"
    VALUE
    0x80807EA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA34Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA34Unintended"
    VALUE
    0x80807EA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35OC"
    VALUE
    0x80807EA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA35Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA35Unintended"
    VALUE
    0x80807EA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46OC"
    VALUE
    0x80807EA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA46Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA46Unintended"
    VALUE
    0x80807EA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47OC"
    VALUE
    0x80807EA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA47Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA47Unintended"
    VALUE
    0x80807EA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48OC"
    VALUE
    0x80807EA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA48Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA48Unintended"
    VALUE
    0x80807EAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51OC"
    VALUE
    0x80807EAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA51Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA51Unintended"
    VALUE
    0x80807EAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52OC"
    VALUE
    0x80807EAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA52Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA52Unintended"
    VALUE
    0x80807EAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53OC"
    VALUE
    0x80807EAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA53Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA53Unintended"
    VALUE
    0x80807EB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54OC"
    VALUE
    0x80807EB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outA54Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outA54Unintended"
    VALUE
    0x80807EB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAov_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAov"
    VALUE
    0x80807EB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAovCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAovCfg"
    VALUE
    0x80807EB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAovCfgPI_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAovCfgPI"
    VALUE
    0x80807EB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAovGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAovGetStatus"
    VALUE
    0x80807EB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAovGetVoltage_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80807EB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outAovResetError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outAovResetError"
    VALUE
    0x80807EB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDo"
    VALUE
    0x80807EB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDoCfgPwrLs_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80807EBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDoDisable_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDoDisable"
    VALUE
    0x80807EBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDoGetCurrent_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80807EBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDoGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDoGetStatus"
    VALUE
    0x80807EBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outDoResetError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outDoResetError"
    VALUE
    0x80807EBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07OC"
    VALUE
    0x80807EBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK07Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK07Unintended"
    VALUE
    0x80807EC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08OC"
    VALUE
    0x80807EC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK08Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK08Unintended"
    VALUE
    0x80807EC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09OC"
    VALUE
    0x80807EC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK09Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK09Unintended"
    VALUE
    0x80807EC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12OC"
    VALUE
    0x80807EC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK12Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK12Unintended"
    VALUE
    0x80807EC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13OC"
    VALUE
    0x80807EC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK13Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK13Unintended"
    VALUE
    0x80807EC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14OC"
    VALUE
    0x80807EC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK14Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK14Unintended"
    VALUE
    0x80807ECA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15OC"
    VALUE
    0x80807ECB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK15Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK15Unintended"
    VALUE
    0x80807ECC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16OC"
    VALUE
    0x80807ECD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK16Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK16Unintended"
    VALUE
    0x80807ECE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17OC"
    VALUE
    0x80807ECF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK17Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK17Unintended"
    VALUE
    0x80807ED0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29OC"
    VALUE
    0x80807ED1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK29Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK29Unintended"
    VALUE
    0x80807ED2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51OC"
    VALUE
    0x80807ED3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK51Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK51Unintended"
    VALUE
    0x80807ED4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73OC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73OC"
    VALUE
    0x80807ED5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outK73Unintended_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outK73Unintended"
    VALUE
    0x80807ED6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPo"
    VALUE
    0x80807ED7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoCfg"
    VALUE
    0x80807ED8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoCfgPeriod_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80807ED9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoCfgPwrLs_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80807EDA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoDisable_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoDisable"
    VALUE
    0x80807EDB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoGetCurrent_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80807EDC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoGetStatus"
    VALUE
    0x80807EDD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoResetError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoResetError"
    VALUE
    0x80807EDE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPoc_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPoc"
    VALUE
    0x80807EDF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPocCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPocCfg"
    VALUE
    0x80807EE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPocCfgDither_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPocCfgDither"
    VALUE
    0x80807EE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPocCfgPI_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPocCfgPI"
    VALUE
    0x80807EE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPod_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPod"
    VALUE
    0x80807EE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPodCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPodCfg"
    VALUE
    0x80807EE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_outPodCfgPeriod_C
    "assigned fault type / Fault type assignment for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80807EE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_rsmFfiApiCallErr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80807EE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safout_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safout"
    VALUE
    0x80807EE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutCfg_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutCfg"
    VALUE
    0x80807EE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl1_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl1"
    VALUE
    0x80807EE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl10_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl10"
    VALUE
    0x80807EEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl10Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80807EEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl10OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80807EEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl11_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl11"
    VALUE
    0x80807EED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl11Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80807EEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl11OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80807EEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl12_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl12"
    VALUE
    0x80807EF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl12Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80807EF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl12OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80807EF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl13_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl13"
    VALUE
    0x80807EF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl13Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80807EF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl13OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80807EF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl14_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl14"
    VALUE
    0x80807EF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl14Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80807EF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl14OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80807EF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl15_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl15"
    VALUE
    0x80807EF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl15Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80807EFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl15OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80807EFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl16_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl16"
    VALUE
    0x80807EFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl16Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80807EFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl16OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80807EFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl17_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl17"
    VALUE
    0x80807EFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl17Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80807F00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl17OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80807F01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl18_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl18"
    VALUE
    0x80807F02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl18Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80807F03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl18OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80807F04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl1Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80807F05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl1OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80807F06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl2_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl2"
    VALUE
    0x80807F07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl2Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80807F08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl2OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80807F09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl3_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl3"
    VALUE
    0x80807F0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl3Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80807F0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl3OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80807F0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl4_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl4"
    VALUE
    0x80807F0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl4Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x80807F0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl4OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80807F0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl5_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl5"
    VALUE
    0x80807F10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl5Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80807F11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl5OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80807F12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl6_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl6"
    VALUE
    0x80807F13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl6Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80807F14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl6OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80807F15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl7_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl7"
    VALUE
    0x80807F16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl7Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80807F17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl7OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80807F18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl8_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl8"
    VALUE
    0x80807F19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl8Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80807F1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl8OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80807F1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl9_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl9"
    VALUE
    0x80807F1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl9Dev_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80807F1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutChnl9OR_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x80807F1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutDevError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutDevError"
    VALUE
    0x80807F1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutGetStatus_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutGetStatus"
    VALUE
    0x80807F20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutIgnoreError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80807F21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutResetError_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutResetError"
    VALUE
    0x80807F22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safoutUnlock_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safoutUnlock"
    VALUE
    0x80807F23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_safout_cfgDiag_C
    "assigned fault type / Fault type assignment for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80807F24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secAccessDenied_RC_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80807F25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secAccessDenied_WDBI_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80807F26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secEvalRespKey_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secEvalRespKey"
    VALUE
    0x80807F27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secFlashingFailure_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secFlashingFailure"
    VALUE
    0x80807F28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secGetLevel_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secGetLevel"
    VALUE
    0x80807F29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secGetRnd_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secGetRnd"
    VALUE
    0x80807F2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secGetSeed_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secGetSeed"
    VALUE
    0x80807F2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secInvalidPassword_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secInvalidPassword"
    VALUE
    0x80807F2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secIsRequestAllowed_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80807F2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secResetLevel_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secResetLevel"
    VALUE
    0x80807F2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secSaveSecret_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secSaveSecret"
    VALUE
    0x80807F2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_secSetLevel_C
    "assigned fault type / Fault type assignment for check DFC_rbr_secSetLevel"
    VALUE
    0x80807F30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysAit_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysAit"
    VALUE
    0x80807F31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysAiv_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysAiv"
    VALUE
    0x80807F32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysDi_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysDi"
    VALUE
    0x80807F33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysDo_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysDo"
    VALUE
    0x80807F34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysGetVss_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysGetVss"
    VALUE
    0x80807F35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysInit_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysInit"
    VALUE
    0x80807F36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysOperHrIntegrityErr_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80807F37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysOperHrsSaturated_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80807F38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sysSetVss_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sysSetVss"
    VALUE
    0x80807F39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sys_coreload_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sys_coreload"
    VALUE
    0x80807F3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_sys_taskload_C
    "assigned fault type / Fault type assignment for check DFC_rbr_sys_taskload"
    VALUE
    0x80807F3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VSS1_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80807F3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_OV_VSS2_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80807F3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VSS1_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80807F3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rbr_mo_UV_VSS2_C
    "assigned fault type / Fault type assignment for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x80807F3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "assigned fault type / Fault type assignment for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80807F40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "assigned fault type / Fault type assignment for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80807F41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "assigned fault type / Fault type assignment for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80807F42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "assigned fault type / Fault type assignment for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80807F43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "assigned fault type / Fault type assignment for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80807F44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_CAN_E_TIMEOUT_C
    "assigned fault type / Fault type assignment for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80807F45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80807F46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80807F47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80807F48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80807F49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80807F4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "assigned fault type / Fault type assignment for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80807F4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_LIN_E_TIMEOUT_C
    "assigned fault type / Fault type assignment for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80807F4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_MultiStackTrace_Threshold_C
    "assigned fault type / Fault type assignment for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80807F4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_ETH_E_ACCESS_0_C
    "assigned fault type / Fault type assignment for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x80807F4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "assigned fault type / Fault type assignment for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x80807F4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "assigned fault type / Fault type assignment for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80807F50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_MRly_Diag_Stk_Event_C
    "assigned fault type / Fault type assignment for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80807F51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "assigned fault type / Fault type assignment for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80807F52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_MemDiag_MemReadErr_C
    "assigned fault type / Fault type assignment for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80807F53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_MemDiag_MemWrErr_C
    "assigned fault type / Fault type assignment for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80807F54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "assigned fault type / Fault type assignment for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80807F55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_T15_Diag_ComInVld_Event_C
    "assigned fault type / Fault type assignment for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80807F56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "assigned fault type / Fault type assignment for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80807F57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "assigned fault type / Fault type assignment for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80807F58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80807F59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80807F5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_10_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80807F5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80807F5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80807F5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x80807F5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x80807F5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_22_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80807F60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_23_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80807F61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80807F62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80807F63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_7_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80807F64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM0_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80807F65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM10_16_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80807F66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM10_17_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80807F67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM10_21_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80807F68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80807F69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80807F6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80807F6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_3_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80807F6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80807F6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x80807F6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x80807F6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM11_9_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80807F70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80807F71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80807F72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_10_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80807F73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80807F74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80807F75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80807F76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80807F77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_22_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80807F78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_23_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80807F79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80807F7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80807F7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_7_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80807F7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM1_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80807F7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM21_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x80807F7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM21_16_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x80807F7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM21_3_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80807F80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80807F81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_10_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80807F82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80807F83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80807F84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80807F85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80807F86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_22_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80807F87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_23_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80807F88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80807F89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80807F8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_7_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80807F8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM2_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80807F8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80807F8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_10_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x80807F8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x80807F8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80807F90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80807F91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80807F92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_22_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80807F93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_23_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80807F94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80807F95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80807F96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_7_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80807F97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM3_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80807F98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80807F99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80807F9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_12_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80807F9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80807F9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_15_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80807F9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_17_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x80807F9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_18_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x80807F9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80807FA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_20_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80807FA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_21_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80807FA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_25_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80807FA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80807FA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_5_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80807FA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_7_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80807FA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM6_8_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80807FA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80807FA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_12_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80807FA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80807FAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_14_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80807FAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_15_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80807FAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_16_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80807FAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_17_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80807FAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80807FAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_20_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80807FB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_25_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80807FB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_26_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80807FB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_28_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80807FB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_29_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80807FB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_30_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80807FB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM7_31_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80807FB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80807FB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80807FB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_10_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80807FB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_11_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80807FBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_12_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80807FBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_13_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80807FBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_16_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80807FBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_18_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80807FBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_2_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80807FBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_3_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80807FC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_30_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80807FC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_31_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80807FC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM8_4_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80807FC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_0_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80807FC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_1_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80807FC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_15_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80807FC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MOXEMM_SMU_ALM9_3_C
    "assigned fault type / Fault type assignment for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80807FC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoCSOPICO_C
    "assigned fault type / Fault type assignment for check DFC_MoCSOPICO"
    VALUE
    0x80807FC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoFVarPostBldSel_C
    "assigned fault type / Fault type assignment for check DFC_MoFVarPostBldSel"
    VALUE
    0x80807FC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoSysCtrlReIni_C
    "assigned fault type / Fault type assignment for check DFC_MoSysCtrlReIni"
    VALUE
    0x80807FCA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTMCUFW_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80807FCB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTMonBIST_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80807FCC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTRegMonTest_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80807FCD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80807FCE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTTempSens_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80807FCF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_MoXEMMHwLTUCBCfg_C
    "assigned fault type / Fault type assignment for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80807FD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_OCWDAABEActv_C
    "assigned fault type / Fault type assignment for check DFC_OCWDAABEActv"
    VALUE
    0x80807FD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_OCWDACom_C
    "assigned fault type / Fault type assignment for check DFC_OCWDACom"
    VALUE
    0x80807FD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_OCWDAErrPin_C
    "assigned fault type / Fault type assignment for check DFC_OCWDAErrPin"
    VALUE
    0x80807FD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_SWReset_0_C
    "assigned fault type / Fault type assignment for check DFC_SWReset_0"
    VALUE
    0x80807FD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_SWReset_1_C
    "assigned fault type / Fault type assignment for check DFC_SWReset_1"
    VALUE
    0x80807FD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_FaultTyp.DFC_SWReset_2_C
    "assigned fault type / Fault type assignment for check DFC_SWReset_2"
    VALUE
    0x80807FD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_MonEvtMSK0_C
    "Event filter mask of Monitoring - Mask Id mast have 0 at bit mask 0 positions"
    VALUE
    0x80801876
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_MonEvtMSK1_C
    "Event filter mask of Monitoring - Mask Id mast have 1 at bit mask 1 positions"
    VALUE
    0x80801878
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_MonRepeat_C
    "switch to ignore same kind of monitoring events, set to 0 to suppress identical events in a row"
    VALUE
    0x8080187A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsDlt_CA
    "Fault class parameter: Number of cycles for OBD delete counter"
    VAL_BLK
    0x8080187B
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsFaultCycl_CA
    "Fault class parameter: Number of cycles for fault counter"
    VAL_BLK
    0x8080187F
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsHealCycl_CA
    "Fault class parameter: Number of cycles for healing counter"
    VAL_BLK
    0x80801883
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsPndDlt_CA
    "Fault class parameter: Number of cycles for pending delete counter"
    VAL_BLK
    0x80801887
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsSvcDlt_CA
    "Fault class parameter: Number of cycles for delete counter"
    VAL_BLK
    0x8080188B
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsSVSFaultCycl_CA
    "Fault class parameter: Number of cycles for SVS lamp fault counter"
    VAL_BLK
    0x8080188F
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numClsSVSHealCycl_CA
    "Fault class parameter: Number of cycles for SVS lamp healing counter"
    VAL_BLK
    0x80801893
    ValA_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_numPDTC_C
    "Number of permanent DTCs (from 0 to configured maximum value)"
    VALUE
    0x80801897
    Val_Wu8
    4.000
    DFES_OneToOne
    0.00
    4.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_ThresSimCond.n_C
    ""
    VALUE
    0x80801898
    Val_Wu16
    16383.75
    DFES_nPID0C
    0.00
    16383.75

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_ThresSimCond.r_C
    ""
    VALUE
    0x8080189A
    Val_Wu8
    100.0
    DFES_rPID04
    0.00
    100.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_ThresSimCond.t_C
    ""
    VALUE
    0x8080189B
    Val_Wu8
    255.0
    DFES_tPID05
    -40.0
    215.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_tiDefCntr_C
    ""
    VALUE
    0x8080189C
    Val_Wu32
    65535.0000000
    DFES_tiDefCntr_compu
    0.00
    65535.0000000

    FORMAT "%13.7"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_tiDelEngRun_C
    ""
    VALUE
    0x808018A0
    Val_Wu16
    65519.00
    DFES_Time_1min
    1.00
    65520.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_tiDelTstd_C
    ""
    VALUE
    0x808018A2
    Val_Wu8
    1.00000000000
    DFES_Enable
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xAsgnFrzFrDid_CA
    "Signal selection for freeze frame (DID based)"
    VAL_BLK
    0x808018A6
    ValA_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsDltTrg_CA
    "Fault class parameter: Trigger type for OBD delete counter"
    VAL_BLK
    0x808018AE
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsFaultTrg_CA
    "Fault class parameter: Trigger type for fault counter"
    VAL_BLK
    0x808018B2
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsFltAWL_CA
    "Customer specific fault class parameter"
    VAL_BLK
    0x80808F74
    ValA_Wu8
    8.
    DFES_LampFltAWL
    0.00
    8.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsFltMIL_CA
    "Fault class parameter: MIL control"
    VAL_BLK
    0x808018B6
    ValA_Wu8
    3.
    DFES_LampFltMIL
    0.00
    3.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsFltRSL_CA
    "Customer specific fault class parameter"
    VAL_BLK
    0x80808F78
    ValA_Wu8
    8.
    DFES_LampFltRSL
    0.00
    8.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsFltSVS_CA
    "Fault class parameter: SVS lamp control"
    VAL_BLK
    0x808018BA
    ValA_Wu8
    8.
    DFES_LampFltSVS
    0.00
    8.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsHealTrg_CA
    "Fault class parameter: Trigger type for healing counter"
    VAL_BLK
    0x808018BE
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsPndDltTrg_CA
    "Fault class parameter: Trigger type for pending delete counter"
    VAL_BLK
    0x808018C2
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsPrio_CA
    "Fault class parameter: Static priority and tester visibility"
    VAL_BLK
    0x808018C6
    ValA_Wu8
    228.000000000
    DFES_TstVisAndPrio
    3.000000000
    231.000000000

    FORMAT "%13.9"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsSvcDltTrg_CA
    "Fault class parameter: Trigger type for delete counter"
    VAL_BLK
    0x808018CA
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsSVSFaultTrg_CA
    "Fault class parameter: Trigger type for SVS lamp fault counter"
    VAL_BLK
    0x808018CE
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xClsSVSHealTrg_CA
    "Fault class parameter: Trigger type for SVS lamp healing counter"
    VAL_BLK
    0x808018D2
    ValA_Wu8
    10.
    DSMAUX_DTRGVerb
    0.00
    10.

    FORMAT "%2.0"
    
    MATRIX_DIM 4 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xEnaHealPend_C
    ""
    VALUE
    0x808018D6
    Val_Wu8
    1.00000000000
    DFES_Enable
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xEnaHistoryPend_C
    ""
    VALUE
    0x808018D7
    Val_Wu8
    1.00000000000
    DFES_Enable
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xEnaTiDelWithFlt_C
    ""
    VALUE
    0x808018D8
    Val_Wu8
    1.00000000000
    DFES_Enable
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xSelDsplStgyMIL_C
    ""
    VALUE
    0x808018D9
    Val_Wu8
    2.00000000000
    DFES_DsplStgy
    0.00
    2.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_xSelDTCTyp_C
    ""
    VALUE
    0x808018DA
    Val_Wu8
    255.000000000
    DFES_DTCTyp_Verb
    0.00
    255.000000000

    FORMAT "%13.9"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFP_UBR
    "Internal fault path number: ambient conditions"
    VALUE
    0x8080928C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecHBrdgDiag_DbgSigId_C
    "Select H-Bridge signal to be debugged."
    VALUE
    0x8080912E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecHBrdgDiag_DbgSigType_C
    "Select the signal type of signal to be debugged."
    VALUE
    0x80809130
    Val_Wu8
    1.00000000000
    DiaActr_ElecHBrdgDiag_DbgSigType_COMPU_VERB
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecHBrdgDiag_OlEnaSwtOff_C
    "Enable powerstage switchoff during permanent error and preliminary heal of open load error. [Relevant only if open load is configured in active \ normal drive mode]."
    VALUE
    0x80809131
    Val_Wu8
    1.00000000000
    DiaActr_ElecHBrdgDiag_OlEnaSwtOff_COMPU_VERB
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecPsDiag_DbgSigId_C
    "Signal Id to be debugged"
    VALUE
    0x80809134
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecPsDiag_DbgSigTyp_C
    "Type of the output signal (PWMOut, DigOut, Pmd) to be debugged."
    VALUE
    0x80809138
    Val_Wu8
    3.00000000000
    DiaActr_ElecPsDiag_DbgSigTyp_COMPU_VERB
    0.00
    3.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiaActr_ElecPsDiag_SigOutDurgOpenLd_C
    "Take into account Open-Load-Error for Shut-Off request."
    VALUE
    0x80809139
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80c7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80c7"
    VAL_BLK
    0x808018DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80c8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80c8"
    VAL_BLK
    0x808018E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80c9_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80c9"
    VAL_BLK
    0x808018E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ca_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ca"
    VAL_BLK
    0x808018E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80cb_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80cb"
    VAL_BLK
    0x808018EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80cc_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80cc"
    VAL_BLK
    0x808018F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80cd_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80cd"
    VAL_BLK
    0x808018F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ce_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ce"
    VAL_BLK
    0x808018F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80cf_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80cf"
    VAL_BLK
    0x808018FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80d0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80d0"
    VAL_BLK
    0x80801900
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80d1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80d1"
    VAL_BLK
    0x80801904
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80d2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80d2"
    VAL_BLK
    0x80801908
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80d3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80d3"
    VAL_BLK
    0x8080190C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80d4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80d4"
    VAL_BLK
    0x80801910
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80d5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80d5"
    VAL_BLK
    0x80801914
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80d6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80d6"
    VAL_BLK
    0x80801918
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80d7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80d7"
    VAL_BLK
    0x8080191C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80d8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80d8"
    VAL_BLK
    0x80801920
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80d9_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80d9"
    VAL_BLK
    0x80801924
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80da_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80da"
    VAL_BLK
    0x80801928
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80db_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80db"
    VAL_BLK
    0x8080192C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80dc_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80dc"
    VAL_BLK
    0x80801930
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80dd_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80dd"
    VAL_BLK
    0x80801934
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80de_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80de"
    VAL_BLK
    0x80801938
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80df_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80df"
    VAL_BLK
    0x8080193C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80e0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80e0"
    VAL_BLK
    0x80801940
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80e1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80e1"
    VAL_BLK
    0x80801944
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80e2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80e2"
    VAL_BLK
    0x80801948
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80e3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80e3"
    VAL_BLK
    0x8080194C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80e4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80e4"
    VAL_BLK
    0x80801950
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80e5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80e5"
    VAL_BLK
    0x80801954
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80e6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80e6"
    VAL_BLK
    0x80801958
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80e7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80e7"
    VAL_BLK
    0x8080195C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80e8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80e8"
    VAL_BLK
    0x80801960
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80e9_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80e9"
    VAL_BLK
    0x80801964
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ea_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ea"
    VAL_BLK
    0x80801968
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80eb_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80eb"
    VAL_BLK
    0x8080196C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ec_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ec"
    VAL_BLK
    0x80801970
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ed_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ed"
    VAL_BLK
    0x80801974
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ee_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ee"
    VAL_BLK
    0x80801978
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ef_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ef"
    VAL_BLK
    0x8080197C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80f0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80f0"
    VAL_BLK
    0x80801980
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80f1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80f1"
    VAL_BLK
    0x80801984
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80f2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80f2"
    VAL_BLK
    0x80801988
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80f3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80f3"
    VAL_BLK
    0x8080198C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80f4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80f4"
    VAL_BLK
    0x80801990
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80f5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80f5"
    VAL_BLK
    0x80801994
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80f6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80f6"
    VAL_BLK
    0x80801998
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80f7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80f7"
    VAL_BLK
    0x8080199C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80f8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80f8"
    VAL_BLK
    0x808019A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80f9_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80f9"
    VAL_BLK
    0x808019A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80fa_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80fa"
    VAL_BLK
    0x808019A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80fb_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80fb"
    VAL_BLK
    0x808019AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80fc_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80fc"
    VAL_BLK
    0x808019B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80fd_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80fd"
    VAL_BLK
    0x808019B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80fe_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80fe"
    VAL_BLK
    0x808019B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ff_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ff"
    VAL_BLK
    0x808019BC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8100_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8100"
    VAL_BLK
    0x808019C0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8101_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8101"
    VAL_BLK
    0x808019C4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8102_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8102"
    VAL_BLK
    0x808019C8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8103_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8103"
    VAL_BLK
    0x808019CC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8104_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8104"
    VAL_BLK
    0x808019D0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8105_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8105"
    VAL_BLK
    0x808019D4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8106_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8106"
    VAL_BLK
    0x808019D8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8107_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8107"
    VAL_BLK
    0x808019DC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8108_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8108"
    VAL_BLK
    0x808019E0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8109_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8109"
    VAL_BLK
    0x808019E4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x810a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x810a"
    VAL_BLK
    0x808019E8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x810b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x810b"
    VAL_BLK
    0x808019EC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x810c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x810c"
    VAL_BLK
    0x808019F0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x810d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x810d"
    VAL_BLK
    0x808019F4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x810e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x810e"
    VAL_BLK
    0x808019F8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x810f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x810f"
    VAL_BLK
    0x808019FC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8110_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8110"
    VAL_BLK
    0x80801A00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8111_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8111"
    VAL_BLK
    0x80801A04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8112_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8112"
    VAL_BLK
    0x80801A08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8113_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8113"
    VAL_BLK
    0x80801A0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8114_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8114"
    VAL_BLK
    0x80801A10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8115_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8115"
    VAL_BLK
    0x80801A14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8116_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8116"
    VAL_BLK
    0x80801A18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8117_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8117"
    VAL_BLK
    0x80801A1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8118_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8118"
    VAL_BLK
    0x80801A20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8119_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8119"
    VAL_BLK
    0x80801A24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x811a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x811a"
    VAL_BLK
    0x80801A28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x811b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x811b"
    VAL_BLK
    0x80801A2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x811c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x811c"
    VAL_BLK
    0x80801A30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x811d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x811d"
    VAL_BLK
    0x80801A34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x811e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x811e"
    VAL_BLK
    0x80801A38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x811f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x811f"
    VAL_BLK
    0x80801A3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8120_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8120"
    VAL_BLK
    0x80801A40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8121_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8121"
    VAL_BLK
    0x80801A44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8122_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8122"
    VAL_BLK
    0x80801A48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8123_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8123"
    VAL_BLK
    0x80801A4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8124_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8124"
    VAL_BLK
    0x80801A50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8125_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8125"
    VAL_BLK
    0x80801A54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8126_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8126"
    VAL_BLK
    0x80801A58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8127_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8127"
    VAL_BLK
    0x80801A5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8128_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8128"
    VAL_BLK
    0x80801A60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8129_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8129"
    VAL_BLK
    0x80801A64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x812a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x812a"
    VAL_BLK
    0x80801A68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_TiInRow0x8B01_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_TiInRow0x8B01"
    VAL_BLK
    0x80801A6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_TiInRow0x8B02_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_TiInRow0x8B02"
    VAL_BLK
    0x80801A70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_TiInRow0x8B03_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_TiInRow0x8B03"
    VAL_BLK
    0x80801A74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_DevLibBattUHi_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_DevLibBattUHi"
    VAL_BLK
    0x80801A78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_DevLibBattULo_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_DevLibBattULo"
    VAL_BLK
    0x80801A7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8063_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8063"
    VAL_BLK
    0x80801A80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8064_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8064"
    VAL_BLK
    0x80801A84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8065_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8065"
    VAL_BLK
    0x80801A88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8066_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8066"
    VAL_BLK
    0x80801A8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8067_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8067"
    VAL_BLK
    0x80801A90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8068_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8068"
    VAL_BLK
    0x80801A94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8069_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8069"
    VAL_BLK
    0x80801A98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x806a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x806a"
    VAL_BLK
    0x80801A9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x806b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x806b"
    VAL_BLK
    0x80801AA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x806c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x806c"
    VAL_BLK
    0x80801AA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x806d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x806d"
    VAL_BLK
    0x80801AA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x806e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x806e"
    VAL_BLK
    0x80801AAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x806f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x806f"
    VAL_BLK
    0x80801AB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8070_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8070"
    VAL_BLK
    0x80801AB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8071_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8071"
    VAL_BLK
    0x80801AB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8072_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8072"
    VAL_BLK
    0x80801ABC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8073_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8073"
    VAL_BLK
    0x80801AC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8074_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8074"
    VAL_BLK
    0x80801AC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8075_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8075"
    VAL_BLK
    0x80801AC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8076_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8076"
    VAL_BLK
    0x80801ACC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8077_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8077"
    VAL_BLK
    0x80801AD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8078_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8078"
    VAL_BLK
    0x80801AD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8079_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8079"
    VAL_BLK
    0x80801AD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x807a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x807a"
    VAL_BLK
    0x80801ADC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x807b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x807b"
    VAL_BLK
    0x80801AE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x807c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x807c"
    VAL_BLK
    0x80801AE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x807d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x807d"
    VAL_BLK
    0x80801AE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x807e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x807e"
    VAL_BLK
    0x80801AEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x807f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x807f"
    VAL_BLK
    0x80801AF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8080_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8080"
    VAL_BLK
    0x80801AF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8081_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8081"
    VAL_BLK
    0x80801AF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8082_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8082"
    VAL_BLK
    0x80801AFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8083_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8083"
    VAL_BLK
    0x80801B00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8084_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8084"
    VAL_BLK
    0x80801B04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8085_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8085"
    VAL_BLK
    0x80801B08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8086_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8086"
    VAL_BLK
    0x80801B0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8087_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8087"
    VAL_BLK
    0x80801B10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8088_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8088"
    VAL_BLK
    0x80801B14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8089_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8089"
    VAL_BLK
    0x80801B18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x808a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x808a"
    VAL_BLK
    0x80801B1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x808b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x808b"
    VAL_BLK
    0x80801B20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x808c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x808c"
    VAL_BLK
    0x80801B24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x808d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x808d"
    VAL_BLK
    0x80801B28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x808e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x808e"
    VAL_BLK
    0x80801B2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x808f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x808f"
    VAL_BLK
    0x80801B30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8090_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8090"
    VAL_BLK
    0x80801B34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8091_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8091"
    VAL_BLK
    0x80801B38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8092_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8092"
    VAL_BLK
    0x80801B3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8093_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8093"
    VAL_BLK
    0x80801B40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8094_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8094"
    VAL_BLK
    0x80801B44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8095_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8095"
    VAL_BLK
    0x80801B48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8096_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8096"
    VAL_BLK
    0x80801B4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8097_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8097"
    VAL_BLK
    0x80801B50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8098_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8098"
    VAL_BLK
    0x80801B54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x8099_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x8099"
    VAL_BLK
    0x80801B58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x809a_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x809a"
    VAL_BLK
    0x80801B5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x809b_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x809b"
    VAL_BLK
    0x80801B60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x809c_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x809c"
    VAL_BLK
    0x80801B64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x809d_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x809d"
    VAL_BLK
    0x80801B68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x809e_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x809e"
    VAL_BLK
    0x80801B6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x809f_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x809f"
    VAL_BLK
    0x80801B70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80a0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80a0"
    VAL_BLK
    0x80801B74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80a1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80a1"
    VAL_BLK
    0x80801B78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80a2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80a2"
    VAL_BLK
    0x80801B7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80a3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80a3"
    VAL_BLK
    0x80801B80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80a4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80a4"
    VAL_BLK
    0x80801B84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80a5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80a5"
    VAL_BLK
    0x80801B88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80a6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80a6"
    VAL_BLK
    0x80801B8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80a7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80a7"
    VAL_BLK
    0x80801B90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80a8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80a8"
    VAL_BLK
    0x80801B94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80a9_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80a9"
    VAL_BLK
    0x80801B98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80aa_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80aa"
    VAL_BLK
    0x80801B9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ab_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ab"
    VAL_BLK
    0x80801BA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ac_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ac"
    VAL_BLK
    0x80801BA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ad_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ad"
    VAL_BLK
    0x80801BA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ae_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ae"
    VAL_BLK
    0x80801BAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80af_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80af"
    VAL_BLK
    0x80801BB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80b0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80b0"
    VAL_BLK
    0x80801BB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80b1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80b1"
    VAL_BLK
    0x80801BB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80b2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80b2"
    VAL_BLK
    0x80801BBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80b3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80b3"
    VAL_BLK
    0x80801BC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80b4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80b4"
    VAL_BLK
    0x80801BC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80b5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80b5"
    VAL_BLK
    0x80801BC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80b6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80b6"
    VAL_BLK
    0x80801BCC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80b7_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80b7"
    VAL_BLK
    0x80801BD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80b8_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80b8"
    VAL_BLK
    0x80801BD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80b9_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80b9"
    VAL_BLK
    0x80801BD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80ba_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80ba"
    VAL_BLK
    0x80801BDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80bb_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80bb"
    VAL_BLK
    0x80801BE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80bc_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80bc"
    VAL_BLK
    0x80801BE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80bd_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80bd"
    VAL_BLK
    0x80801BE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80be_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80be"
    VAL_BLK
    0x80801BEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80bf_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80bf"
    VAL_BLK
    0x80801BF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80c0_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80c0"
    VAL_BLK
    0x80801BF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80c1_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80c1"
    VAL_BLK
    0x80801BF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80c2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80c2"
    VAL_BLK
    0x80801BFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80c3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80c3"
    VAL_BLK
    0x80801C00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80c4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80c4"
    VAL_BLK
    0x80801C04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80c5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80c5"
    VAL_BLK
    0x80801C08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_NoDeb0x80c6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_NoDeb0x80c6"
    VAL_BLK
    0x80801C0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_TiUpDwn0x8A01_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_TiUpDwn0x8A01"
    VAL_BLK
    0x80801C10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_TiUpDwn0x8A02_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_TiUpDwn0x8A02"
    VAL_BLK
    0x80801C14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_bds_TiUpDwn0x8A03_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_bds_TiUpDwn0x8A03"
    VAL_BLK
    0x80801C18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA13OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA13OR"
    VAL_BLK
    0x80801C1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA13SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA13SCB"
    VAL_BLK
    0x80801C20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA13SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA13SCG"
    VAL_BLK
    0x80801C24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA14OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA14OR"
    VAL_BLK
    0x80801C28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA14SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA14SCB"
    VAL_BLK
    0x80801C2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA14SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA14SCG"
    VAL_BLK
    0x80801C30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA21OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA21OR"
    VAL_BLK
    0x80801C34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA21SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA21SCB"
    VAL_BLK
    0x80801C38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA21SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA21SCG"
    VAL_BLK
    0x80801C3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA22OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA22OR"
    VAL_BLK
    0x80801C40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA22SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA22SCB"
    VAL_BLK
    0x80801C44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA22SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA22SCG"
    VAL_BLK
    0x80801C48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA23OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA23OR"
    VAL_BLK
    0x80801C4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA23SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA23SCB"
    VAL_BLK
    0x80801C50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA23SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA23SCG"
    VAL_BLK
    0x80801C54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA24OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA24OR"
    VAL_BLK
    0x80801C58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA24SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA24SCB"
    VAL_BLK
    0x80801C5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA24SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA24SCG"
    VAL_BLK
    0x80801C60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA25OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA25OR"
    VAL_BLK
    0x80801C64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA25SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA25SCB"
    VAL_BLK
    0x80801C68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA25SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA25SCG"
    VAL_BLK
    0x80801C6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA26OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA26OR"
    VAL_BLK
    0x80801C70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA26SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA26SCB"
    VAL_BLK
    0x80801C74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA26SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA26SCG"
    VAL_BLK
    0x80801C78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA27OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA27OR"
    VAL_BLK
    0x80801C7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA27SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA27SCB"
    VAL_BLK
    0x80801C80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA27SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA27SCG"
    VAL_BLK
    0x80801C84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA28OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA28OR"
    VAL_BLK
    0x80801C88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA28SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA28SCB"
    VAL_BLK
    0x80801C8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA28SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA28SCG"
    VAL_BLK
    0x80801C90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA29OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA29OR"
    VAL_BLK
    0x80801C94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA29SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA29SCB"
    VAL_BLK
    0x80801C98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA29SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA29SCG"
    VAL_BLK
    0x80801C9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36AicSCB"
    VAL_BLK
    0x80801CA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36AicSCG"
    VAL_BLK
    0x80801CA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36OR"
    VAL_BLK
    0x80801CA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36SCB"
    VAL_BLK
    0x80801CAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36SCG"
    VAL_BLK
    0x80801CB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA36ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA36ShuntSCB"
    VAL_BLK
    0x80801CB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37AicSCB"
    VAL_BLK
    0x80801CB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37AicSCG"
    VAL_BLK
    0x80801CBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37OR"
    VAL_BLK
    0x80801CC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37SCB"
    VAL_BLK
    0x80801CC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37SCG"
    VAL_BLK
    0x80801CC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA37ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA37ShuntSCB"
    VAL_BLK
    0x80801CCC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38AicSCB"
    VAL_BLK
    0x80801CD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38AicSCG"
    VAL_BLK
    0x80801CD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38OR"
    VAL_BLK
    0x80801CD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38SCB"
    VAL_BLK
    0x80801CDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38SCG"
    VAL_BLK
    0x80801CE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA38ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA38ShuntSCB"
    VAL_BLK
    0x80801CE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39AicSCB"
    VAL_BLK
    0x80801CE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39AicSCG"
    VAL_BLK
    0x80801CEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39OR"
    VAL_BLK
    0x80801CF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39SCB"
    VAL_BLK
    0x80801CF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39SCG"
    VAL_BLK
    0x80801CF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA39ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA39ShuntSCB"
    VAL_BLK
    0x80801CFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA40OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA40OR"
    VAL_BLK
    0x80801D00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA40SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA40SCB"
    VAL_BLK
    0x80801D04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA40SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA40SCG"
    VAL_BLK
    0x80801D08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA41OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA41OR"
    VAL_BLK
    0x80801D0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA41SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA41SCB"
    VAL_BLK
    0x80801D10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA41SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA41SCG"
    VAL_BLK
    0x80801D14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA42OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA42OR"
    VAL_BLK
    0x80801D18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA42SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA42SCB"
    VAL_BLK
    0x80801D1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA42SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA42SCG"
    VAL_BLK
    0x80801D20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43AicSCB"
    VAL_BLK
    0x80801D24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43AicSCG"
    VAL_BLK
    0x80801D28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43OR"
    VAL_BLK
    0x80801D2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43SCB"
    VAL_BLK
    0x80801D30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43SCG"
    VAL_BLK
    0x80801D34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA43ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA43ShuntSCB"
    VAL_BLK
    0x80801D38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA44OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA44OL"
    VAL_BLK
    0x80801D3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA44SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA44SCB"
    VAL_BLK
    0x80801D40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA44SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA44SCG"
    VAL_BLK
    0x80801D44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA57OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA57OR"
    VAL_BLK
    0x80801D48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA57SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA57SCB"
    VAL_BLK
    0x80801D4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA57SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA57SCG"
    VAL_BLK
    0x80801D50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA59OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA59OL"
    VAL_BLK
    0x80801D54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA59SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA59SCB"
    VAL_BLK
    0x80801D58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inA59SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inA59SCG"
    VAL_BLK
    0x80801D5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK10OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK10OR"
    VAL_BLK
    0x80801D60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK10SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK10SCB"
    VAL_BLK
    0x80801D64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK10SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK10SCG"
    VAL_BLK
    0x80801D68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK11OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK11OR"
    VAL_BLK
    0x80801D6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK11SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK11SCB"
    VAL_BLK
    0x80801D70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK11SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK11SCG"
    VAL_BLK
    0x80801D74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30AicSCB"
    VAL_BLK
    0x80801D78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30AicSCG"
    VAL_BLK
    0x80801D7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30OR"
    VAL_BLK
    0x80801D80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30SCB"
    VAL_BLK
    0x80801D84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30SCG"
    VAL_BLK
    0x80801D88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK30ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK30ShuntSCB"
    VAL_BLK
    0x80801D8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK31OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK31OR"
    VAL_BLK
    0x80801D90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK31SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK31SCB"
    VAL_BLK
    0x80801D94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK31SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK31SCG"
    VAL_BLK
    0x80801D98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK32OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK32OR"
    VAL_BLK
    0x80801D9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK32SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK32SCB"
    VAL_BLK
    0x80801DA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK32SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK32SCG"
    VAL_BLK
    0x80801DA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK33OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK33OR"
    VAL_BLK
    0x80801DA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK33SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK33SCB"
    VAL_BLK
    0x80801DAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK33SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK33SCG"
    VAL_BLK
    0x80801DB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK34OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK34OR"
    VAL_BLK
    0x80801DB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK34SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK34SCB"
    VAL_BLK
    0x80801DB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK34SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK34SCG"
    VAL_BLK
    0x80801DBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK35OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK35OR"
    VAL_BLK
    0x80801DC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK35SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK35SCB"
    VAL_BLK
    0x80801DC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK35SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK35SCG"
    VAL_BLK
    0x80801DC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK36OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK36OR"
    VAL_BLK
    0x80801DCC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK36SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK36SCB"
    VAL_BLK
    0x80801DD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK36SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK36SCG"
    VAL_BLK
    0x80801DD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37AicSCB"
    VAL_BLK
    0x80801DD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37AicSCG"
    VAL_BLK
    0x80801DDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37OR"
    VAL_BLK
    0x80801DE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37SCB"
    VAL_BLK
    0x80801DE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37SCG"
    VAL_BLK
    0x80801DE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK37ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK37ShuntSCB"
    VAL_BLK
    0x80801DEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38AicSCB"
    VAL_BLK
    0x80801DF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38AicSCG"
    VAL_BLK
    0x80801DF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38OR"
    VAL_BLK
    0x80801DF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38SCB"
    VAL_BLK
    0x80801DFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38SCG"
    VAL_BLK
    0x80801E00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK38ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK38ShuntSCB"
    VAL_BLK
    0x80801E04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39AicSCB"
    VAL_BLK
    0x80801E08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39AicSCG"
    VAL_BLK
    0x80801E0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39OR"
    VAL_BLK
    0x80801E10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39SCB"
    VAL_BLK
    0x80801E14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39SCG"
    VAL_BLK
    0x80801E18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK39ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK39ShuntSCB"
    VAL_BLK
    0x80801E1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40AicSCB"
    VAL_BLK
    0x80801E20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40AicSCG"
    VAL_BLK
    0x80801E24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40OR"
    VAL_BLK
    0x80801E28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40SCB"
    VAL_BLK
    0x80801E2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40SCG"
    VAL_BLK
    0x80801E30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK40ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK40ShuntSCB"
    VAL_BLK
    0x80801E34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41AicSCB"
    VAL_BLK
    0x80801E38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41AicSCG"
    VAL_BLK
    0x80801E3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41OR"
    VAL_BLK
    0x80801E40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41SCB"
    VAL_BLK
    0x80801E44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41SCG"
    VAL_BLK
    0x80801E48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK41ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK41ShuntSCB"
    VAL_BLK
    0x80801E4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42AicSCB"
    VAL_BLK
    0x80801E50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42AicSCG"
    VAL_BLK
    0x80801E54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42OR"
    VAL_BLK
    0x80801E58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42SCB"
    VAL_BLK
    0x80801E5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42SCG"
    VAL_BLK
    0x80801E60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK42ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK42ShuntSCB"
    VAL_BLK
    0x80801E64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK43OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK43OR"
    VAL_BLK
    0x80801E68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK43SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK43SCB"
    VAL_BLK
    0x80801E6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK43SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK43SCG"
    VAL_BLK
    0x80801E70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44AicSCB"
    VAL_BLK
    0x80801E74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44AicSCG"
    VAL_BLK
    0x80801E78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44OR"
    VAL_BLK
    0x80801E7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44SCB"
    VAL_BLK
    0x80801E80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44SCG"
    VAL_BLK
    0x80801E84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK44ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK44ShuntSCB"
    VAL_BLK
    0x80801E88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45AicSCB"
    VAL_BLK
    0x80801E8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45AicSCG"
    VAL_BLK
    0x80801E90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45OR"
    VAL_BLK
    0x80801E94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45SCB"
    VAL_BLK
    0x80801E98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45SCG"
    VAL_BLK
    0x80801E9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK45ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK45ShuntSCB"
    VAL_BLK
    0x80801EA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK52OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK52OR"
    VAL_BLK
    0x80801EA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK52SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK52SCB"
    VAL_BLK
    0x80801EA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK52SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK52SCG"
    VAL_BLK
    0x80801EAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK53OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK53OR"
    VAL_BLK
    0x80801EB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK53SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK53SCB"
    VAL_BLK
    0x80801EB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK53SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK53SCG"
    VAL_BLK
    0x80801EB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54AicSCB"
    VAL_BLK
    0x80801EBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54AicSCG"
    VAL_BLK
    0x80801EC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54OR"
    VAL_BLK
    0x80801EC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54SCB"
    VAL_BLK
    0x80801EC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54SCG"
    VAL_BLK
    0x80801ECC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK54ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK54ShuntSCB"
    VAL_BLK
    0x80801ED0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55AicSCB"
    VAL_BLK
    0x80801ED4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55AicSCG"
    VAL_BLK
    0x80801ED8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55OR"
    VAL_BLK
    0x80801EDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55SCB"
    VAL_BLK
    0x80801EE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55SCG"
    VAL_BLK
    0x80801EE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK55ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK55ShuntSCB"
    VAL_BLK
    0x80801EE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK56OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK56OR"
    VAL_BLK
    0x80801EEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK56SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK56SCB"
    VAL_BLK
    0x80801EF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK56SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK56SCG"
    VAL_BLK
    0x80801EF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK57OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK57OR"
    VAL_BLK
    0x80801EF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK57SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK57SCB"
    VAL_BLK
    0x80801EFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK57SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK57SCG"
    VAL_BLK
    0x80801F00
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK58OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK58OR"
    VAL_BLK
    0x80801F04
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK58SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK58SCB"
    VAL_BLK
    0x80801F08
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK58SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK58SCG"
    VAL_BLK
    0x80801F0C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK59OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK59OR"
    VAL_BLK
    0x80801F10
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK59SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK59SCB"
    VAL_BLK
    0x80801F14
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK59SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK59SCG"
    VAL_BLK
    0x80801F18
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK60OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK60OR"
    VAL_BLK
    0x80801F1C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK60SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK60SCB"
    VAL_BLK
    0x80801F20
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK60SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK60SCG"
    VAL_BLK
    0x80801F24
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61AicSCB"
    VAL_BLK
    0x80801F28
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61AicSCG"
    VAL_BLK
    0x80801F2C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61OR"
    VAL_BLK
    0x80801F30
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61SCB"
    VAL_BLK
    0x80801F34
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61SCG"
    VAL_BLK
    0x80801F38
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK61ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK61ShuntSCB"
    VAL_BLK
    0x80801F3C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK62OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK62OR"
    VAL_BLK
    0x80801F40
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK62SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK62SCB"
    VAL_BLK
    0x80801F44
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK62SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK62SCG"
    VAL_BLK
    0x80801F48
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63AicSCB"
    VAL_BLK
    0x80801F4C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63AicSCG"
    VAL_BLK
    0x80801F50
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63OR"
    VAL_BLK
    0x80801F54
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63SCB"
    VAL_BLK
    0x80801F58
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63SCG"
    VAL_BLK
    0x80801F5C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK63ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK63ShuntSCB"
    VAL_BLK
    0x80801F60
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64AicSCB"
    VAL_BLK
    0x80801F64
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64AicSCG"
    VAL_BLK
    0x80801F68
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64OR"
    VAL_BLK
    0x80801F6C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64SCB"
    VAL_BLK
    0x80801F70
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64SCG"
    VAL_BLK
    0x80801F74
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK64ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK64ShuntSCB"
    VAL_BLK
    0x80801F78
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65AicSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65AicSCB"
    VAL_BLK
    0x80801F7C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65AicSCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65AicSCG"
    VAL_BLK
    0x80801F80
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65OR"
    VAL_BLK
    0x80801F84
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65SCB"
    VAL_BLK
    0x80801F88
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65SCG"
    VAL_BLK
    0x80801F8C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK65ShuntSCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK65ShuntSCB"
    VAL_BLK
    0x80801F90
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK74OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK74OR"
    VAL_BLK
    0x80801F94
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK74SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK74SCB"
    VAL_BLK
    0x80801F98
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK74SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK74SCG"
    VAL_BLK
    0x80801F9C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK75OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK75OR"
    VAL_BLK
    0x80801FA0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK75SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK75SCB"
    VAL_BLK
    0x80801FA4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK75SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK75SCG"
    VAL_BLK
    0x80801FA8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK76OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK76OR"
    VAL_BLK
    0x80801FAC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK76SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK76SCB"
    VAL_BLK
    0x80801FB0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK76SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK76SCG"
    VAL_BLK
    0x80801FB4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK77OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK77OR"
    VAL_BLK
    0x80801FB8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK77SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK77SCB"
    VAL_BLK
    0x80801FBC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK77SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK77SCG"
    VAL_BLK
    0x80801FC0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK78OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK78OR"
    VAL_BLK
    0x80801FC4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK78SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK78SCB"
    VAL_BLK
    0x80801FC8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_inK78SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_inK78SCG"
    VAL_BLK
    0x80801FCC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_DvUBAT_FWs_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_DvUBAT_FWs"
    VAL_BLK
    0x80801FD0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OVErr_VPR6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OVErr_VPR6"
    VAL_BLK
    0x80801FD4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OVWarn_VPR6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OVWarn_VPR6"
    VAL_BLK
    0x80801FD8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VAL_BLK
    0x80801FDC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VAL_BLK
    0x80801FE0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_UBAT_MON_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_UBAT_MON"
    VAL_BLK
    0x80801FE4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_UBRM24_FLEXIN_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VAL_BLK
    0x80801FE8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_UBRM24_LOADS_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_UBRM24_LOADS"
    VAL_BLK
    0x80801FEC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_UBRM24_MON_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_UBRM24_MON"
    VAL_BLK
    0x80801FF0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VDD5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VDD5"
    VAL_BLK
    0x80801FF4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VDD5_IN_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VDD5_IN"
    VAL_BLK
    0x80801FF8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VPR6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VPR6"
    VAL_BLK
    0x80801FFC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VSS3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VSS3"
    VAL_BLK
    0x80802000
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_OV_VSS4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_OV_VSS4"
    VAL_BLK
    0x80802004
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_Temp1_HTErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_Temp1_HTErr"
    VAL_BLK
    0x80802008
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_Temp1_HTWarn_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_Temp1_HTWarn"
    VAL_BLK
    0x8080200C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_Temp2_HTErr_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_Temp2_HTErr"
    VAL_BLK
    0x80802010
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_Temp2_HTWarn_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_Temp2_HTWarn"
    VAL_BLK
    0x80802014
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VAL_BLK
    0x80802018
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VAL_BLK
    0x8080201C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VDD5_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VDD5"
    VAL_BLK
    0x80802020
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VDD5_IN_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VDD5_IN"
    VAL_BLK
    0x80802024
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VPR6_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VPR6"
    VAL_BLK
    0x80802028
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VSS3_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VSS3"
    VAL_BLK
    0x8080202C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_mo_UV_VSS4_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_mo_UV_VSS4"
    VAL_BLK
    0x80802030
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA01OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA01OL"
    VAL_BLK
    0x80802034
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA01OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA01OT"
    VAL_BLK
    0x80802038
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA01SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA01SCB"
    VAL_BLK
    0x8080203C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA01SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA01SCG"
    VAL_BLK
    0x80802040
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02OL"
    VAL_BLK
    0x80802044
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02OR"
    VAL_BLK
    0x80802048
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02OT"
    VAL_BLK
    0x8080204C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02SCB"
    VAL_BLK
    0x80802050
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA02SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA02SCG"
    VAL_BLK
    0x80802054
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03OL"
    VAL_BLK
    0x80802058
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03OT"
    VAL_BLK
    0x8080205C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03SCB"
    VAL_BLK
    0x80802060
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA03SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA03SCG"
    VAL_BLK
    0x80802064
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04OL"
    VAL_BLK
    0x80802068
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04OT"
    VAL_BLK
    0x8080206C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04SCB"
    VAL_BLK
    0x80802070
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA04SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA04SCG"
    VAL_BLK
    0x80802074
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05OL"
    VAL_BLK
    0x80802078
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05OR"
    VAL_BLK
    0x8080207C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05OT"
    VAL_BLK
    0x80802080
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05SCB"
    VAL_BLK
    0x80802084
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA05SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA05SCG"
    VAL_BLK
    0x80802088
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA06OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA06OL"
    VAL_BLK
    0x8080208C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA06OR_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA06OR"
    VAL_BLK
    0x80802090
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA06OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA06OT"
    VAL_BLK
    0x80802094
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA06SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA06SCB"
    VAL_BLK
    0x80802098
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA06SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA06SCG"
    VAL_BLK
    0x8080209C
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07OL"
    VAL_BLK
    0x808020A0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07OT"
    VAL_BLK
    0x808020A4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07SCB"
    VAL_BLK
    0x808020A8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA07SCG_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA07SCG"
    VAL_BLK
    0x808020AC
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA08OL_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08OL"
    VAL_BLK
    0x808020B0
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA08OT_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08OT"
    VAL_BLK
    0x808020B4
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_FId.DFC_rbr_outA08SCB_CA
    "inhibitable FIds / FIds to be inhibited by inhibit source DFC_rbr_outA08SCB"
    VAL_BLK
    0x808020B8
    ValA_Wu16
    24.
    DINH_FIdVerb
    0.00
    24.

    FORMAT "%2.0"
    
    MATRIX_DIM 2 

/end CHARACTERISTIC

/begin CHARACTERISTIC

