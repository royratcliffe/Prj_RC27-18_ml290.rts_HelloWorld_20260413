    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA01OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA01OL"
    VALUE
    0x80805568
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA01OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA01OT"
    VALUE
    0x8080556A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA01SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA01SCB"
    VALUE
    0x8080556C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA01SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA01SCG"
    VALUE
    0x8080556E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02OL"
    VALUE
    0x80805570
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02OR"
    VALUE
    0x80805572
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02OT"
    VALUE
    0x80805574
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02SCB"
    VALUE
    0x80805576
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02SCG"
    VALUE
    0x80805578
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03OL"
    VALUE
    0x8080557A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03OT"
    VALUE
    0x8080557C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03SCB"
    VALUE
    0x8080557E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03SCG"
    VALUE
    0x80805580
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04OL"
    VALUE
    0x80805582
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04OT"
    VALUE
    0x80805584
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04SCB"
    VALUE
    0x80805586
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04SCG"
    VALUE
    0x80805588
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05OL"
    VALUE
    0x8080558A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05OR"
    VALUE
    0x8080558C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05OT"
    VALUE
    0x8080558E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05SCB"
    VALUE
    0x80805590
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05SCG"
    VALUE
    0x80805592
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA06OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA06OL"
    VALUE
    0x80805594
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA06OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA06OR"
    VALUE
    0x80805596
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA06OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA06OT"
    VALUE
    0x80805598
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA06SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA06SCB"
    VALUE
    0x8080559A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA06SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA06SCG"
    VALUE
    0x8080559C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07OL"
    VALUE
    0x8080559E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07OT"
    VALUE
    0x808055A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07SCB"
    VALUE
    0x808055A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07SCG"
    VALUE
    0x808055A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08OL"
    VALUE
    0x808055A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08OT"
    VALUE
    0x808055A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08SCB"
    VALUE
    0x808055AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08SCG"
    VALUE
    0x808055AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09OL"
    VALUE
    0x808055AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09OR"
    VALUE
    0x808055B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09OT"
    VALUE
    0x808055B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09SCB"
    VALUE
    0x808055B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09SCG"
    VALUE
    0x808055B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10OL"
    VALUE
    0x808055B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10OT"
    VALUE
    0x808055BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10SCB"
    VALUE
    0x808055BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10SCG"
    VALUE
    0x808055BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA11OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA11OL"
    VALUE
    0x808055C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA11OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA11OT"
    VALUE
    0x808055C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA11SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA11SCB"
    VALUE
    0x808055C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA11SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA11SCG"
    VALUE
    0x808055C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA12OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA12OR"
    VALUE
    0x808055C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA12SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA12SCB"
    VALUE
    0x808055CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA12SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA12SCG"
    VALUE
    0x808055CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA16OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA16OL"
    VALUE
    0x808055CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA16OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA16OT"
    VALUE
    0x808055D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA16SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA16SCB"
    VALUE
    0x808055D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA16SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA16SCG"
    VALUE
    0x808055D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17OL"
    VALUE
    0x808055D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17OR"
    VALUE
    0x808055D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17OT"
    VALUE
    0x808055DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17SCB"
    VALUE
    0x808055DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17SCG"
    VALUE
    0x808055DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18OL"
    VALUE
    0x808055E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18OT"
    VALUE
    0x808055E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18SCB"
    VALUE
    0x808055E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18SCG"
    VALUE
    0x808055E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19OL"
    VALUE
    0x808055E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19OR"
    VALUE
    0x808055EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19OT"
    VALUE
    0x808055EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19SCB"
    VALUE
    0x808055EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19SCG"
    VALUE
    0x808055F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20OL"
    VALUE
    0x808055F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20OR"
    VALUE
    0x808055F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20OT"
    VALUE
    0x808055F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20SCB"
    VALUE
    0x808055F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20SCG"
    VALUE
    0x808055FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31OL"
    VALUE
    0x808055FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31OR"
    VALUE
    0x808055FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31OT"
    VALUE
    0x80805600
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31SCB"
    VALUE
    0x80805602
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31SCG"
    VALUE
    0x80805604
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32OL"
    VALUE
    0x80805606
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32OR"
    VALUE
    0x80805608
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32OT"
    VALUE
    0x8080560A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32SCB"
    VALUE
    0x8080560C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32SCG"
    VALUE
    0x8080560E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33OL"
    VALUE
    0x80805610
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33OR"
    VALUE
    0x80805612
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33OT"
    VALUE
    0x80805614
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33SCB"
    VALUE
    0x80805616
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33SCG"
    VALUE
    0x80805618
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34OL"
    VALUE
    0x8080561A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34OR"
    VALUE
    0x8080561C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34OT"
    VALUE
    0x8080561E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34SCB"
    VALUE
    0x80805620
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34SCG"
    VALUE
    0x80805622
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35OL"
    VALUE
    0x80805624
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35OR"
    VALUE
    0x80805626
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35OT"
    VALUE
    0x80805628
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35SCB"
    VALUE
    0x8080562A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35SCG"
    VALUE
    0x8080562C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46OL"
    VALUE
    0x8080562E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46OR"
    VALUE
    0x80805630
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46OT"
    VALUE
    0x80805632
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46SCB"
    VALUE
    0x80805634
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46SCG"
    VALUE
    0x80805636
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47OL"
    VALUE
    0x80805638
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47OR"
    VALUE
    0x8080563A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47OT"
    VALUE
    0x8080563C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47SCB"
    VALUE
    0x8080563E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47SCG"
    VALUE
    0x80805640
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48OL"
    VALUE
    0x80805642
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48OR"
    VALUE
    0x80805644
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48OT"
    VALUE
    0x80805646
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48SCB"
    VALUE
    0x80805648
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48SCG"
    VALUE
    0x8080564A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA49OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA49OL"
    VALUE
    0x8080564C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA49OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA49OT"
    VALUE
    0x8080564E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA49SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA49SCB"
    VALUE
    0x80805650
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA49SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA49SCG"
    VALUE
    0x80805652
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA50OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA50OL"
    VALUE
    0x80805654
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA50OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA50OT"
    VALUE
    0x80805656
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA50SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA50SCB"
    VALUE
    0x80805658
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA50SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA50SCG"
    VALUE
    0x8080565A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51OL"
    VALUE
    0x8080565C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51OR"
    VALUE
    0x8080565E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51OT"
    VALUE
    0x80805660
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51SCB"
    VALUE
    0x80805662
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51SCG"
    VALUE
    0x80805664
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52OL"
    VALUE
    0x80805666
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52OR"
    VALUE
    0x80805668
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52OT"
    VALUE
    0x8080566A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52SCB"
    VALUE
    0x8080566C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52SCG"
    VALUE
    0x8080566E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53OL"
    VALUE
    0x80805670
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53OR"
    VALUE
    0x80805672
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53OT"
    VALUE
    0x80805674
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53SCB"
    VALUE
    0x80805676
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53SCG"
    VALUE
    0x80805678
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54OL"
    VALUE
    0x8080567A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54OR"
    VALUE
    0x8080567C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54OT"
    VALUE
    0x8080567E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54SCB"
    VALUE
    0x80805680
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54SCG"
    VALUE
    0x80805682
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA55OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA55OL"
    VALUE
    0x80805684
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA55OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA55OT"
    VALUE
    0x80805686
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA55SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA55SCB"
    VALUE
    0x80805688
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA55SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA55SCG"
    VALUE
    0x8080568A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA56OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA56OL"
    VALUE
    0x8080568C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA56OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA56OT"
    VALUE
    0x8080568E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA56SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA56SCB"
    VALUE
    0x80805690
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA56SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA56SCG"
    VALUE
    0x80805692
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA58OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA58OL"
    VALUE
    0x80805694
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA58OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA58OT"
    VALUE
    0x80805696
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA58SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA58SCB"
    VALUE
    0x80805698
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA58SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA58SCG"
    VALUE
    0x8080569A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07OL"
    VALUE
    0x8080569C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07OR"
    VALUE
    0x8080569E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07OT"
    VALUE
    0x808056A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07SCB"
    VALUE
    0x808056A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07SCG"
    VALUE
    0x808056A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08OL"
    VALUE
    0x808056A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08OR"
    VALUE
    0x808056A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08OT"
    VALUE
    0x808056AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08SCB"
    VALUE
    0x808056AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08SCG"
    VALUE
    0x808056AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09OL"
    VALUE
    0x808056B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09OR"
    VALUE
    0x808056B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09OT"
    VALUE
    0x808056B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09SCB"
    VALUE
    0x808056B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09SCG"
    VALUE
    0x808056B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12OL"
    VALUE
    0x808056BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12OT"
    VALUE
    0x808056BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12SCB"
    VALUE
    0x808056BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12SCG"
    VALUE
    0x808056C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13OL"
    VALUE
    0x808056C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13OT"
    VALUE
    0x808056C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13SCB"
    VALUE
    0x808056C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13SCG"
    VALUE
    0x808056C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14OL"
    VALUE
    0x808056CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14OR"
    VALUE
    0x808056CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14OT"
    VALUE
    0x808056CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14SCB"
    VALUE
    0x808056D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14SCG"
    VALUE
    0x808056D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15OL"
    VALUE
    0x808056D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15OR"
    VALUE
    0x808056D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15OT"
    VALUE
    0x808056D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15SCB"
    VALUE
    0x808056DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15SCG"
    VALUE
    0x808056DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16OL"
    VALUE
    0x808056DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16OR"
    VALUE
    0x808056E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16OT"
    VALUE
    0x808056E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16SCB"
    VALUE
    0x808056E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16SCG"
    VALUE
    0x808056E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17OL"
    VALUE
    0x808056E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17OR"
    VALUE
    0x808056EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17OT"
    VALUE
    0x808056EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17SCB"
    VALUE
    0x808056EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17SCG"
    VALUE
    0x808056F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK25OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK25OR"
    VALUE
    0x808056F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK25SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK25SCB"
    VALUE
    0x808056F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK25SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK25SCG"
    VALUE
    0x808056F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29OL"
    VALUE
    0x808056F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29OR"
    VALUE
    0x808056FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29OT"
    VALUE
    0x808056FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29SCB"
    VALUE
    0x808056FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29SCG"
    VALUE
    0x80805700
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51OL"
    VALUE
    0x80805702
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51OT"
    VALUE
    0x80805704
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51SCB"
    VALUE
    0x80805706
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51SCG"
    VALUE
    0x80805708
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK62OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK62OR"
    VALUE
    0x8080570A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK62SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK62SCB"
    VALUE
    0x8080570C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK62SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK62SCG"
    VALUE
    0x8080570E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73OL"
    VALUE
    0x80805710
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73OR"
    VALUE
    0x80805712
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73OT"
    VALUE
    0x80805714
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73SCB"
    VALUE
    0x80805716
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73SCG"
    VALUE
    0x80805718
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK80OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK80OL"
    VALUE
    0x8080571A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK80OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK80OT"
    VALUE
    0x8080571C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK80SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK80SCB"
    VALUE
    0x8080571E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK80SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK80SCG"
    VALUE
    0x80805720
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK81OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK81OL"
    VALUE
    0x80805722
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK81OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK81OT"
    VALUE
    0x80805724
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK81SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK81SCB"
    VALUE
    0x80805726
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK81SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK81SCG"
    VALUE
    0x80805728
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK82OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK82OL"
    VALUE
    0x8080572A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK82OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK82OT"
    VALUE
    0x8080572C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK82SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK82SCB"
    VALUE
    0x8080572E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK82SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK82SCG"
    VALUE
    0x80805730
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK83OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK83OL"
    VALUE
    0x80805732
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK83OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK83OT"
    VALUE
    0x80805734
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK83SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK83SCB"
    VALUE
    0x80805736
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK83SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK83SCG"
    VALUE
    0x80805738
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK84OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK84OL"
    VALUE
    0x8080573A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK84OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK84OT"
    VALUE
    0x8080573C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK84SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK84SCB"
    VALUE
    0x8080573E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK84SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK84SCG"
    VALUE
    0x80805740
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK85OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK85OL"
    VALUE
    0x80805742
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK85OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK85OT"
    VALUE
    0x80805744
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK85SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK85SCB"
    VALUE
    0x80805746
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK85SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK85SCG"
    VALUE
    0x80805748
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK86OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK86OL"
    VALUE
    0x8080574A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK86OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK86OT"
    VALUE
    0x8080574C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK86SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK86SCB"
    VALUE
    0x8080574E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK86SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK86SCG"
    VALUE
    0x80805750
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK87OL_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK87OL"
    VALUE
    0x80805752
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK87OT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK87OT"
    VALUE
    0x80805754
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK87SCB_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK87SCB"
    VALUE
    0x80805756
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK87SCG_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK87SCG"
    VALUE
    0x80805758
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_DSMDummy_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_DSMDummy"
    VALUE
    0x8080575A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8000_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8000"
    VALUE
    0x8080575C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8001_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8001"
    VALUE
    0x8080575E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8002_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8002"
    VALUE
    0x80805760
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8003_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8003"
    VALUE
    0x80805762
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8004_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8004"
    VALUE
    0x80805764
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8005_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8005"
    VALUE
    0x80805766
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8006_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8006"
    VALUE
    0x80805768
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8007_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8007"
    VALUE
    0x8080576A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8008_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8008"
    VALUE
    0x8080576C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8009_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8009"
    VALUE
    0x8080576E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x800a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x800a"
    VALUE
    0x80805770
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x800b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x800b"
    VALUE
    0x80805772
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x800c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x800c"
    VALUE
    0x80805774
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x800d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x800d"
    VALUE
    0x80805776
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x800e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x800e"
    VALUE
    0x80805778
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x800f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x800f"
    VALUE
    0x8080577A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8010_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8010"
    VALUE
    0x8080577C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8011_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8011"
    VALUE
    0x8080577E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8012_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8012"
    VALUE
    0x80805780
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8013_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8013"
    VALUE
    0x80805782
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8014_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8014"
    VALUE
    0x80805784
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8015_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8015"
    VALUE
    0x80805786
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8016_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8016"
    VALUE
    0x80805788
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8017_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8017"
    VALUE
    0x8080578A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8018_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8018"
    VALUE
    0x8080578C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8019_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8019"
    VALUE
    0x8080578E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x801a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x801a"
    VALUE
    0x80805790
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x801b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x801b"
    VALUE
    0x80805792
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x801c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x801c"
    VALUE
    0x80805794
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x801d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x801d"
    VALUE
    0x80805796
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x801e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x801e"
    VALUE
    0x80805798
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x801f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x801f"
    VALUE
    0x8080579A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8020_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8020"
    VALUE
    0x8080579C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8021_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8021"
    VALUE
    0x8080579E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8022_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8022"
    VALUE
    0x808057A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8023_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8023"
    VALUE
    0x808057A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8024_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8024"
    VALUE
    0x808057A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8025_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8025"
    VALUE
    0x808057A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8026_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8026"
    VALUE
    0x808057A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8027_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8027"
    VALUE
    0x808057AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8028_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8028"
    VALUE
    0x808057AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8029_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8029"
    VALUE
    0x808057AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x802a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x802a"
    VALUE
    0x808057B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x802b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x802b"
    VALUE
    0x808057B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x802c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x802c"
    VALUE
    0x808057B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x802d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x802d"
    VALUE
    0x808057B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x802e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x802e"
    VALUE
    0x808057B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x802f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x802f"
    VALUE
    0x808057BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8030_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8030"
    VALUE
    0x808057BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8031_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8031"
    VALUE
    0x808057BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8032_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8032"
    VALUE
    0x808057C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8033_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8033"
    VALUE
    0x808057C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8034_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8034"
    VALUE
    0x808057C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8035_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8035"
    VALUE
    0x808057C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8036_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8036"
    VALUE
    0x808057C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8037_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8037"
    VALUE
    0x808057CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8038_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8038"
    VALUE
    0x808057CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8039_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8039"
    VALUE
    0x808057CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x803a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x803a"
    VALUE
    0x808057D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x803b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x803b"
    VALUE
    0x808057D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x803c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x803c"
    VALUE
    0x808057D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x803d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x803d"
    VALUE
    0x808057D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x803e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x803e"
    VALUE
    0x808057D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x803f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x803f"
    VALUE
    0x808057DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8040_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8040"
    VALUE
    0x808057DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8041_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8041"
    VALUE
    0x808057DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8042_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8042"
    VALUE
    0x808057E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8043_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8043"
    VALUE
    0x808057E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8044_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8044"
    VALUE
    0x808057E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8045_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8045"
    VALUE
    0x808057E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8046_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8046"
    VALUE
    0x808057E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8047_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8047"
    VALUE
    0x808057EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8048_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8048"
    VALUE
    0x808057EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8049_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8049"
    VALUE
    0x808057EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x804a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x804a"
    VALUE
    0x808057F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x804b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x804b"
    VALUE
    0x808057F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x804c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x804c"
    VALUE
    0x808057F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x804d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x804d"
    VALUE
    0x808057F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x804e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x804e"
    VALUE
    0x808057F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x804f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x804f"
    VALUE
    0x808057FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8050_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8050"
    VALUE
    0x808057FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8051_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8051"
    VALUE
    0x808057FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8052_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8052"
    VALUE
    0x80805800
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8053_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8053"
    VALUE
    0x80805802
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8054_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8054"
    VALUE
    0x80805804
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8055_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8055"
    VALUE
    0x80805806
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8056_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8056"
    VALUE
    0x80805808
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8057_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8057"
    VALUE
    0x8080580A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8058_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8058"
    VALUE
    0x8080580C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8059_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8059"
    VALUE
    0x8080580E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x805a_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x805a"
    VALUE
    0x80805810
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x805b_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x805b"
    VALUE
    0x80805812
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x805c_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x805c"
    VALUE
    0x80805814
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x805d_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x805d"
    VALUE
    0x80805816
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x805e_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x805e"
    VALUE
    0x80805818
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x805f_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x805f"
    VALUE
    0x8080581A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8060_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8060"
    VALUE
    0x8080581C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8061_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8061"
    VALUE
    0x8080581E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8062_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8062"
    VALUE
    0x80805820
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8C01_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8C01"
    VALUE
    0x80805822
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8C02_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8C02"
    VALUE
    0x80805824
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_bds_NoDeb0x8C03_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_bds_NoDeb0x8C03"
    VALUE
    0x80805826
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetDataNoBuf_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x80805828
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetDataParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetDataParam"
    VALUE
    0x8080582A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetDataboxNoInit_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x8080582C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x8080582E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetRxBufStatusParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80805830
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetStatusParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetStatusParam"
    VALUE
    0x80805832
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canGetTxBufStatusParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80805834
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canInitParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canInitParam"
    VALUE
    0x80805836
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canInitRxDataboxOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80805838
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canInitRxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x8080583A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canInitTxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x8080583C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canIpduGroupControl_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x8080583E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canIsDataboxFreeNoInit_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80805840
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canIsDataboxFreeParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80805842
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canIsTxEmptyParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80805844
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegBusOffCallbInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x80805846
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegBusOffCallbParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x80805848
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxBufInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x8080584A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxBufOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x8080584C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxBufParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x8080584E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxCallbInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80805850
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxCallbParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80805852
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxDataboxInvNumb_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80805854
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxDataboxInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80805856
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxDataboxOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80805858
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegRxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x8080585A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxBufInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x8080585C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxBufOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x8080585E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxBufParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80805860
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxDataboxInvNumb_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80805862
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxDataboxInvState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80805864
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxDataboxOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x80805866
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canRegTxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x80805868
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canResetTxBufParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x8080586A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canSendDataBufOvfl_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x8080586C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canSendDataParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canSendDataParam"
    VALUE
    0x8080586E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canSendDataboxNoInit_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80805870
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canSendDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80805872
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canSetTxCycleParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80805874
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canStartParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canStartParam"
    VALUE
    0x80805876
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_canStopParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_canStopParam"
    VALUE
    0x80805878
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_can_ClearIpduGroup_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x8080587A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_can_ReceiveSignal_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x8080587C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_can_SendSignal_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_can_SendSignal"
    VALUE
    0x8080587E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_can_SetIpduGroup_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80805880
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmDTCJ1939_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80805882
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmDelDTCJ1939_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80805884
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmDelErrors_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmDelErrors"
    VALUE
    0x80805886
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmGetDFES_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmGetDFES"
    VALUE
    0x80805888
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmGetDTCJ1939_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x8080588A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmGetErrors_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmGetErrors"
    VALUE
    0x8080588C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmGetNumErrors_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x8080588E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmInitQueueOverflow_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80805890
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmNumDTCJ1939_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80805892
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmTesterror_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmTesterror"
    VALUE
    0x80805894
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmUpdateDebError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80805896
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmUpdateError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmUpdateError"
    VALUE
    0x80805898
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmgetDFCStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x8080589A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_dsmtestErrorDFC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x8080589C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAi"
    VALUE
    0x8080589E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAic_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAic"
    VALUE
    0x808058A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAicCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAicCfg"
    VALUE
    0x808058A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAicGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAicGetStatus"
    VALUE
    0x808058A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAid_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAid"
    VALUE
    0x808058A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAidCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAidCfg"
    VALUE
    0x808058A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAiv_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAiv"
    VALUE
    0x808058AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAivCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAivCfg"
    VALUE
    0x808058AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inAivGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inAivGetStatus"
    VALUE
    0x808058AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inDi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inDi"
    VALUE
    0x808058B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inFi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inFi"
    VALUE
    0x808058B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inFiCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inFiCfg"
    VALUE
    0x808058B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inFiGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inFiGetStatus"
    VALUE
    0x808058B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inFi_Buffered_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inFi_Buffered"
    VALUE
    0x808058B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inPhase_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inPhase"
    VALUE
    0x808058BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inPhaseGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x808058BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inPhaseResetCounter_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x808058BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inRi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inRi"
    VALUE
    0x808058C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inRiCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inRiCfg"
    VALUE
    0x808058C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inRiCfgTemp_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x808058C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inRiGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inRiGetStatus"
    VALUE
    0x808058C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inRiGetTemp_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inRiGetTemp"
    VALUE
    0x808058C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentCopyFDFifo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x808058CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentDisable_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentDisable"
    VALUE
    0x808058CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentEnable_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentEnable"
    VALUE
    0x808058CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentGetErrorStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x808058D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentGetFD_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentGetFD"
    VALUE
    0x808058D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentGetSD_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentGetSD"
    VALUE
    0x808058D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentGetSDDatabox_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x808058D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentGetStatus"
    VALUE
    0x808058D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentInitSDDatabox_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x808058DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentRegisterCopyFDFifo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x808058DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentRegisterFDFifo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x808058DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_inSentRegisterSDDataboxes_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x808058E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusCanRxBufferOverflow_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x808058E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusGetCaAddrParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x808058E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusGetDiagnosticParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x808058E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x808058E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusGetStatusParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x808058EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitCommCaMissing_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x808058EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitCommParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x808058EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitCommState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitCommState"
    VALUE
    0x808058F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitDiagnosticParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x808058F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitFailureListParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x808058F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitRxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x808058F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusInitTxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x808058F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegRxDataboxOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x808058FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegRxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x808058FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegRxDataboxState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x808058FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegTxDataboxOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x80805900
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegTxDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x80805902
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegTxDataboxState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x80805904
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x80805906
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegisterInstancesOverlap_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x80805908
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegisterInstancesParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x8080590A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusRegisterInstancesState_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x8080590C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSendDataboxParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x8080590E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSendRequestPGNParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x80805910
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaAddrCaUsed_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80805912
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaAddrComm_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80805914
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaAddrInvCan_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80805916
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaAddrParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80805918
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaInfoParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x8080591A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSetCaNameParam_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x8080591C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_isobusSftyCanTxErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x8080591E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_ReceiveSignal_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80805920
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_SendSignal_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_SendSignal"
    VALUE
    0x80805922
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_getStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_getStatus"
    VALUE
    0x80805924
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_gotoSleep_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x80805926
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_scheduleRequest_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x80805928
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_lin_wakeUp_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_lin_wakeUp"
    VALUE
    0x8080592A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memFlsCfgShr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x8080592C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memGetStatus"
    VALUE
    0x8080592E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memMarkBlock_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memMarkBlock"
    VALUE
    0x80805930
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadApi1Error_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80805932
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadApi2Error_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80805934
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadBlock_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadBlock"
    VALUE
    0x80805936
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadCalibInputError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80805938
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadCalibOuputError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x8080593A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memReadSystemError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memReadSystemError"
    VALUE
    0x8080593C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_memWriteBlock_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_memWriteBlock"
    VALUE
    0x8080593E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_moOV_FirstConstADC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80805940
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_moOV_SecondConstADC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80805942
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_moUV_FirstConstADC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80805944
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_moUV_SecondConstADC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x80805946
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_INH_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_INH"
    VALUE
    0x80805948
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_INHLatch_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_INHLatch"
    VALUE
    0x8080594A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_adcPDD_fail_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x8080594C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_memoryProtection_err_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x8080594E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02OC"
    VALUE
    0x80805950
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA02Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA02Unintended"
    VALUE
    0x80805952
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03OC"
    VALUE
    0x80805954
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA03Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA03Unintended"
    VALUE
    0x80805956
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04OC"
    VALUE
    0x80805958
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA04Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA04Unintended"
    VALUE
    0x8080595A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05OC"
    VALUE
    0x8080595C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA05Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA05Unintended"
    VALUE
    0x8080595E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07OC"
    VALUE
    0x80805960
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA07Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA07Unintended"
    VALUE
    0x80805962
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08OC"
    VALUE
    0x80805964
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA08Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA08Unintended"
    VALUE
    0x80805966
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09OC"
    VALUE
    0x80805968
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA09Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA09Unintended"
    VALUE
    0x8080596A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10OC"
    VALUE
    0x8080596C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA10Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA10Unintended"
    VALUE
    0x8080596E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17OC"
    VALUE
    0x80805970
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA17Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA17Unintended"
    VALUE
    0x80805972
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18OC"
    VALUE
    0x80805974
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA18Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA18Unintended"
    VALUE
    0x80805976
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19OC"
    VALUE
    0x80805978
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA19Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA19Unintended"
    VALUE
    0x8080597A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20OC"
    VALUE
    0x8080597C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA20Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA20Unintended"
    VALUE
    0x8080597E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31OC"
    VALUE
    0x80805980
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA31Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA31Unintended"
    VALUE
    0x80805982
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32OC"
    VALUE
    0x80805984
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA32Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA32Unintended"
    VALUE
    0x80805986
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33OC"
    VALUE
    0x80805988
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA33Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA33Unintended"
    VALUE
    0x8080598A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34OC"
    VALUE
    0x8080598C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA34Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA34Unintended"
    VALUE
    0x8080598E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35OC"
    VALUE
    0x80805990
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA35Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA35Unintended"
    VALUE
    0x80805992
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46OC"
    VALUE
    0x80805994
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA46Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA46Unintended"
    VALUE
    0x80805996
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47OC"
    VALUE
    0x80805998
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA47Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA47Unintended"
    VALUE
    0x8080599A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48OC"
    VALUE
    0x8080599C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA48Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA48Unintended"
    VALUE
    0x8080599E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51OC"
    VALUE
    0x808059A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA51Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA51Unintended"
    VALUE
    0x808059A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52OC"
    VALUE
    0x808059A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA52Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA52Unintended"
    VALUE
    0x808059A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53OC"
    VALUE
    0x808059A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA53Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA53Unintended"
    VALUE
    0x808059AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54OC"
    VALUE
    0x808059AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outA54Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outA54Unintended"
    VALUE
    0x808059AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAov_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAov"
    VALUE
    0x808059B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAovCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAovCfg"
    VALUE
    0x808059B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAovCfgPI_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAovCfgPI"
    VALUE
    0x808059B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAovGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAovGetStatus"
    VALUE
    0x808059B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAovGetVoltage_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x808059B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outAovResetError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outAovResetError"
    VALUE
    0x808059BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDo"
    VALUE
    0x808059BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDoCfgPwrLs_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x808059BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDoDisable_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDoDisable"
    VALUE
    0x808059C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDoGetCurrent_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x808059C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDoGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDoGetStatus"
    VALUE
    0x808059C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outDoResetError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outDoResetError"
    VALUE
    0x808059C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07OC"
    VALUE
    0x808059C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK07Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK07Unintended"
    VALUE
    0x808059CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08OC"
    VALUE
    0x808059CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK08Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK08Unintended"
    VALUE
    0x808059CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09OC"
    VALUE
    0x808059D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK09Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK09Unintended"
    VALUE
    0x808059D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12OC"
    VALUE
    0x808059D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK12Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK12Unintended"
    VALUE
    0x808059D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13OC"
    VALUE
    0x808059D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK13Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK13Unintended"
    VALUE
    0x808059DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14OC"
    VALUE
    0x808059DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK14Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK14Unintended"
    VALUE
    0x808059DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15OC"
    VALUE
    0x808059E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK15Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK15Unintended"
    VALUE
    0x808059E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16OC"
    VALUE
    0x808059E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK16Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK16Unintended"
    VALUE
    0x808059E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17OC"
    VALUE
    0x808059E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK17Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK17Unintended"
    VALUE
    0x808059EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29OC"
    VALUE
    0x808059EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK29Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK29Unintended"
    VALUE
    0x808059EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51OC"
    VALUE
    0x808059F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK51Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK51Unintended"
    VALUE
    0x808059F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73OC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73OC"
    VALUE
    0x808059F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outK73Unintended_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outK73Unintended"
    VALUE
    0x808059F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPo"
    VALUE
    0x808059F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoCfg"
    VALUE
    0x808059FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoCfgPeriod_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x808059FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoCfgPwrLs_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x808059FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoDisable_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoDisable"
    VALUE
    0x80805A00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoGetCurrent_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80805A02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoGetStatus"
    VALUE
    0x80805A04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoResetError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoResetError"
    VALUE
    0x80805A06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPoc_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPoc"
    VALUE
    0x80805A08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPocCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPocCfg"
    VALUE
    0x80805A0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPocCfgDither_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPocCfgDither"
    VALUE
    0x80805A0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPocCfgPI_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPocCfgPI"
    VALUE
    0x80805A0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPod_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPod"
    VALUE
    0x80805A10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPodCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPodCfg"
    VALUE
    0x80805A12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_outPodCfgPeriod_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80805A14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_rsmFfiApiCallErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80805A16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safout_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safout"
    VALUE
    0x80805A18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutCfg"
    VALUE
    0x80805A1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl1"
    VALUE
    0x80805A1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl10"
    VALUE
    0x80805A1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl10Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80805A20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl10OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80805A22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl11"
    VALUE
    0x80805A24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl11Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x80805A26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl11OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x80805A28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl12_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl12"
    VALUE
    0x80805A2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl12Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80805A2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl12OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80805A2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl13"
    VALUE
    0x80805A30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl13Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80805A32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl13OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80805A34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl14"
    VALUE
    0x80805A36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl14Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80805A38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl14OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80805A3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl15_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl15"
    VALUE
    0x80805A3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl15Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80805A3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl15OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80805A40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl16_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl16"
    VALUE
    0x80805A42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl16Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80805A44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl16OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x80805A46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl17_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl17"
    VALUE
    0x80805A48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl17Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80805A4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl17OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80805A4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl18_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl18"
    VALUE
    0x80805A4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl18Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80805A50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl18OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80805A52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl1Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80805A54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl1OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80805A56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl2"
    VALUE
    0x80805A58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl2Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80805A5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl2OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80805A5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl3"
    VALUE
    0x80805A5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl3Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80805A60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl3OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80805A62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl4"
    VALUE
    0x80805A64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl4Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x80805A66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl4OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x80805A68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl5"
    VALUE
    0x80805A6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl5Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80805A6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl5OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80805A6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl6_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl6"
    VALUE
    0x80805A70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl6Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80805A72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl6OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80805A74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl7"
    VALUE
    0x80805A76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl7Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80805A78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl7OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80805A7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl8"
    VALUE
    0x80805A7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl8Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80805A7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl8OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80805A80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl9_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl9"
    VALUE
    0x80805A82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl9Dev_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80805A84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutChnl9OR_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x80805A86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutDevError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutDevError"
    VALUE
    0x80805A88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutGetStatus_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutGetStatus"
    VALUE
    0x80805A8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutIgnoreError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80805A8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutResetError_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutResetError"
    VALUE
    0x80805A8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safoutUnlock_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safoutUnlock"
    VALUE
    0x80805A90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_safout_cfgDiag_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80805A92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secAccessDenied_RC_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80805A94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secAccessDenied_WDBI_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80805A96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secEvalRespKey_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secEvalRespKey"
    VALUE
    0x80805A98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secFlashingFailure_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secFlashingFailure"
    VALUE
    0x80805A9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secGetLevel_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secGetLevel"
    VALUE
    0x80805A9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secGetRnd_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secGetRnd"
    VALUE
    0x80805A9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secGetSeed_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secGetSeed"
    VALUE
    0x80805AA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secInvalidPassword_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secInvalidPassword"
    VALUE
    0x80805AA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secIsRequestAllowed_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x80805AA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secResetLevel_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secResetLevel"
    VALUE
    0x80805AA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secSaveSecret_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secSaveSecret"
    VALUE
    0x80805AA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_secSetLevel_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_secSetLevel"
    VALUE
    0x80805AAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysAit_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysAit"
    VALUE
    0x80805AAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysAiv_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysAiv"
    VALUE
    0x80805AAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysDi_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysDi"
    VALUE
    0x80805AB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysDo_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysDo"
    VALUE
    0x80805AB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysGetVss_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysGetVss"
    VALUE
    0x80805AB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysInit_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysInit"
    VALUE
    0x80805AB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysOperHrIntegrityErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80805AB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysOperHrsSaturated_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80805ABA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sysSetVss_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sysSetVss"
    VALUE
    0x80805ABC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sys_coreload_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sys_coreload"
    VALUE
    0x80805ABE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_sys_taskload_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_sys_taskload"
    VALUE
    0x80805AC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VSS1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x80805AC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_OV_VSS2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x80805AC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VSS1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x80805AC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rbr_mo_UV_VSS2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x80805AC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x80805ACA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x80805ACC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x80805ACE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x80805AD0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x80805AD2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_CAN_E_TIMEOUT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x80805AD4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x80805AD6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x80805AD8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x80805ADA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x80805ADC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x80805ADE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x80805AE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_LIN_E_TIMEOUT_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x80805AE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_MultiStackTrace_Threshold_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x80805AE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_ETH_E_ACCESS_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x80805AE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x80805AE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x80805AEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_MRly_Diag_Stk_Event_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x80805AEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x80805AEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_MemDiag_MemReadErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x80805AF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_MemDiag_MemWrErr_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x80805AF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x80805AF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_T15_Diag_ComInVld_Event_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x80805AF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x80805AF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x80805AFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x80805AFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x80805AFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x80805B00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x80805B02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x80805B04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x80805B06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x80805B08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_22_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x80805B0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_23_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x80805B0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x80805B0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x80805B10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80805B12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM0_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80805B14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM10_16_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80805B16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM10_17_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80805B18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM10_21_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80805B1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80805B1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80805B1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80805B20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80805B22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80805B24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x80805B26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x80805B28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM11_9_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x80805B2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x80805B2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x80805B2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x80805B30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80805B32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80805B34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80805B36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80805B38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_22_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80805B3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_23_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80805B3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80805B3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80805B40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80805B42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM1_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80805B44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM21_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x80805B46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM21_16_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x80805B48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM21_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x80805B4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x80805B4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x80805B4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x80805B50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80805B52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80805B54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80805B56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_22_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80805B58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_23_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80805B5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80805B5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80805B5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80805B60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM2_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80805B62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80805B64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x80805B66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x80805B68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x80805B6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x80805B6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x80805B6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_22_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x80805B70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_23_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80805B72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80805B74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80805B76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80805B78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM3_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80805B7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80805B7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80805B7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_12_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80805B80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80805B82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_15_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80805B84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_17_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x80805B86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_18_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x80805B88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x80805B8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_20_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x80805B8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_21_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x80805B8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_25_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x80805B90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80805B92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_5_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80805B94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_7_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80805B96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM6_8_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80805B98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80805B9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_12_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80805B9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80805B9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_14_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80805BA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_15_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80805BA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_16_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80805BA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_17_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x80805BA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x80805BA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_20_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x80805BAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_25_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x80805BAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_26_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x80805BAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_28_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x80805BB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_29_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80805BB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_30_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80805BB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM7_31_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80805BB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80805BB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80805BBA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_10_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80805BBC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_11_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80805BBE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_12_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80805BC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_13_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80805BC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_16_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80805BC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_18_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x80805BC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x80805BC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x80805BCA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_30_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x80805BCC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_31_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x80805BCE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM8_4_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x80805BD0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM9_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80805BD2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM9_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80805BD4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM9_15_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80805BD6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MOXEMM_SMU_ALM9_3_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80805BD8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoCSOPICO_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoCSOPICO"
    VALUE
    0x80805BDA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoFVarPostBldSel_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoFVarPostBldSel"
    VALUE
    0x80805BDC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoSysCtrlReIni_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoSysCtrlReIni"
    VALUE
    0x80805BDE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTMCUFW_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80805BE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTMonBIST_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80805BE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTRegMonTest_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80805BE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x80805BE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTTempSens_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x80805BE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_MoXEMMHwLTUCBCfg_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x80805BEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_OCWDAABEActv_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_OCWDAABEActv"
    VALUE
    0x80805BEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_OCWDACom_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_OCWDACom"
    VALUE
    0x80805BEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_OCWDAErrPin_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_OCWDAErrPin"
    VALUE
    0x80805BF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_SWReset_0_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_SWReset_0"
    VALUE
    0x80805BF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_SWReset_1_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_SWReset_1"
    VALUE
    0x80805BF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCO.DFC_SWReset_2_C
    "OBD specific trouble code / OBD specific diagnostic trouble code for check DFC_SWReset_2"
    VALUE
    0x80805BF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_Unused_C
    "J1939SPN specific trouble code / "
    VALUE
    0x80805BFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80c7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80805C00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80c8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c8"
    VALUE
    0x80805C04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80c9_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c9"
    VALUE
    0x80805C08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ca_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ca"
    VALUE
    0x80805C0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80cb_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80cb"
    VALUE
    0x80805C10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80cc_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80cc"
    VALUE
    0x80805C14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80cd_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80cd"
    VALUE
    0x80805C18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ce_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ce"
    VALUE
    0x80805C1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80cf_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80cf"
    VALUE
    0x80805C20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80d0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d0"
    VALUE
    0x80805C24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80d1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d1"
    VALUE
    0x80805C28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80d2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80805C2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80d3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80805C30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80d4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80805C34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80d5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80805C38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80d6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80805C3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80d7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d7"
    VALUE
    0x80805C40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80d8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d8"
    VALUE
    0x80805C44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80d9_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80d9"
    VALUE
    0x80805C48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80da_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80da"
    VALUE
    0x80805C4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80db_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80db"
    VALUE
    0x80805C50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80dc_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80dc"
    VALUE
    0x80805C54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80dd_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80dd"
    VALUE
    0x80805C58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80de_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80de"
    VALUE
    0x80805C5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80df_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80df"
    VALUE
    0x80805C60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80e0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e0"
    VALUE
    0x80805C64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80e1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e1"
    VALUE
    0x80805C68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80e2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80805C6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80e3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80805C70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80e4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80805C74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80e5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80805C78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80e6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80805C7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80e7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e7"
    VALUE
    0x80805C80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80e8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e8"
    VALUE
    0x80805C84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80e9_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80e9"
    VALUE
    0x80805C88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ea_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ea"
    VALUE
    0x80805C8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80eb_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80eb"
    VALUE
    0x80805C90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ec_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ec"
    VALUE
    0x80805C94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ed_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ed"
    VALUE
    0x80805C98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ee_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ee"
    VALUE
    0x80805C9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ef_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ef"
    VALUE
    0x80805CA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80f0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f0"
    VALUE
    0x80805CA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80f1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f1"
    VALUE
    0x80805CA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80f2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80805CAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80f3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80805CB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80f4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80805CB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80f5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80805CB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80f6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f6"
    VALUE
    0x80805CBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80f7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f7"
    VALUE
    0x80805CC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80f8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f8"
    VALUE
    0x80805CC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80f9_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80f9"
    VALUE
    0x80805CC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80fa_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80fa"
    VALUE
    0x80805CCC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80fb_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80fb"
    VALUE
    0x80805CD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80fc_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80fc"
    VALUE
    0x80805CD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80fd_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80fd"
    VALUE
    0x80805CD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80fe_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80fe"
    VALUE
    0x80805CDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ff_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ff"
    VALUE
    0x80805CE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8100_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8100"
    VALUE
    0x80805CE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8101_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8101"
    VALUE
    0x80805CE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8102_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8102"
    VALUE
    0x80805CEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8103_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8103"
    VALUE
    0x80805CF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8104_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8104"
    VALUE
    0x80805CF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8105_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8105"
    VALUE
    0x80805CF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8106_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8106"
    VALUE
    0x80805CFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8107_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8107"
    VALUE
    0x80805D00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8108_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8108"
    VALUE
    0x80805D04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8109_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8109"
    VALUE
    0x80805D08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x810a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810a"
    VALUE
    0x80805D0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x810b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810b"
    VALUE
    0x80805D10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x810c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810c"
    VALUE
    0x80805D14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x810d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810d"
    VALUE
    0x80805D18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x810e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810e"
    VALUE
    0x80805D1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x810f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x810f"
    VALUE
    0x80805D20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8110_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8110"
    VALUE
    0x80805D24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8111_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8111"
    VALUE
    0x80805D28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8112_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8112"
    VALUE
    0x80805D2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8113_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8113"
    VALUE
    0x80805D30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8114_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8114"
    VALUE
    0x80805D34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8115_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8115"
    VALUE
    0x80805D38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8116_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8116"
    VALUE
    0x80805D3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8117_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8117"
    VALUE
    0x80805D40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8118_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8118"
    VALUE
    0x80805D44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8119_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8119"
    VALUE
    0x80805D48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x811a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811a"
    VALUE
    0x80805D4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x811b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811b"
    VALUE
    0x80805D50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x811c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811c"
    VALUE
    0x80805D54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x811d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811d"
    VALUE
    0x80805D58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x811e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811e"
    VALUE
    0x80805D5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x811f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x811f"
    VALUE
    0x80805D60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8120_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8120"
    VALUE
    0x80805D64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8121_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8121"
    VALUE
    0x80805D68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8122_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8122"
    VALUE
    0x80805D6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8123_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8123"
    VALUE
    0x80805D70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8124_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8124"
    VALUE
    0x80805D74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8125_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8125"
    VALUE
    0x80805D78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8126_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8126"
    VALUE
    0x80805D7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8127_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8127"
    VALUE
    0x80805D80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8128_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8128"
    VALUE
    0x80805D84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8129_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8129"
    VALUE
    0x80805D88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x812a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x812a"
    VALUE
    0x80805D8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_TiInRow0x8B01_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_TiInRow0x8B01"
    VALUE
    0x80805D90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_TiInRow0x8B02_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_TiInRow0x8B02"
    VALUE
    0x80805D94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_TiInRow0x8B03_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_TiInRow0x8B03"
    VALUE
    0x80805D98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_DevLibBattUHi_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_DevLibBattUHi"
    VALUE
    0x80805D9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_DevLibBattULo_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_DevLibBattULo"
    VALUE
    0x80805DA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8063_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8063"
    VALUE
    0x80805DA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8064_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8064"
    VALUE
    0x80805DA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8065_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8065"
    VALUE
    0x80805DAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8066_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8066"
    VALUE
    0x80805DB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8067_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8067"
    VALUE
    0x80805DB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8068_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8068"
    VALUE
    0x80805DB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8069_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8069"
    VALUE
    0x80805DBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x806a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806a"
    VALUE
    0x80805DC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x806b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806b"
    VALUE
    0x80805DC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x806c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806c"
    VALUE
    0x80805DC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x806d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806d"
    VALUE
    0x80805DCC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x806e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806e"
    VALUE
    0x80805DD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x806f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x806f"
    VALUE
    0x80805DD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8070_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8070"
    VALUE
    0x80805DD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8071_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8071"
    VALUE
    0x80805DDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8072_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8072"
    VALUE
    0x80805DE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8073_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8073"
    VALUE
    0x80805DE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8074_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8074"
    VALUE
    0x80805DE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8075_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8075"
    VALUE
    0x80805DEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8076_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8076"
    VALUE
    0x80805DF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8077_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8077"
    VALUE
    0x80805DF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8078_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8078"
    VALUE
    0x80805DF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8079_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8079"
    VALUE
    0x80805DFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x807a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807a"
    VALUE
    0x80805E00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x807b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807b"
    VALUE
    0x80805E04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x807c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807c"
    VALUE
    0x80805E08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x807d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807d"
    VALUE
    0x80805E0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x807e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807e"
    VALUE
    0x80805E10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x807f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x807f"
    VALUE
    0x80805E14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8080_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8080"
    VALUE
    0x80805E18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8081_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8081"
    VALUE
    0x80805E1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8082_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8082"
    VALUE
    0x80805E20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8083_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8083"
    VALUE
    0x80805E24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8084_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8084"
    VALUE
    0x80805E28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8085_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8085"
    VALUE
    0x80805E2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8086_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8086"
    VALUE
    0x80805E30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8087_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8087"
    VALUE
    0x80805E34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8088_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8088"
    VALUE
    0x80805E38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8089_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8089"
    VALUE
    0x80805E3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x808a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808a"
    VALUE
    0x80805E40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x808b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808b"
    VALUE
    0x80805E44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x808c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808c"
    VALUE
    0x80805E48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x808d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808d"
    VALUE
    0x80805E4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x808e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808e"
    VALUE
    0x80805E50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x808f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x808f"
    VALUE
    0x80805E54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8090_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8090"
    VALUE
    0x80805E58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8091_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8091"
    VALUE
    0x80805E5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8092_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8092"
    VALUE
    0x80805E60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8093_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8093"
    VALUE
    0x80805E64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8094_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8094"
    VALUE
    0x80805E68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8095_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8095"
    VALUE
    0x80805E6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8096_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8096"
    VALUE
    0x80805E70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8097_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8097"
    VALUE
    0x80805E74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8098_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8098"
    VALUE
    0x80805E78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x8099_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x8099"
    VALUE
    0x80805E7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x809a_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809a"
    VALUE
    0x80805E80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x809b_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809b"
    VALUE
    0x80805E84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x809c_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809c"
    VALUE
    0x80805E88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x809d_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809d"
    VALUE
    0x80805E8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x809e_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809e"
    VALUE
    0x80805E90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x809f_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x809f"
    VALUE
    0x80805E94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80a0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a0"
    VALUE
    0x80805E98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80a1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a1"
    VALUE
    0x80805E9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80a2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a2"
    VALUE
    0x80805EA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80a3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a3"
    VALUE
    0x80805EA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80a4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a4"
    VALUE
    0x80805EA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80a5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80805EAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80a6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a6"
    VALUE
    0x80805EB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80a7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a7"
    VALUE
    0x80805EB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80a8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a8"
    VALUE
    0x80805EB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80a9_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80a9"
    VALUE
    0x80805EBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80aa_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80aa"
    VALUE
    0x80805EC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ab_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ab"
    VALUE
    0x80805EC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ac_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ac"
    VALUE
    0x80805EC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ad_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ad"
    VALUE
    0x80805ECC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ae_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ae"
    VALUE
    0x80805ED0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80af_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80af"
    VALUE
    0x80805ED4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80b0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b0"
    VALUE
    0x80805ED8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80b1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b1"
    VALUE
    0x80805EDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80b2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b2"
    VALUE
    0x80805EE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80b3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b3"
    VALUE
    0x80805EE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80b4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b4"
    VALUE
    0x80805EE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80b5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b5"
    VALUE
    0x80805EEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80b6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b6"
    VALUE
    0x80805EF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80b7_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b7"
    VALUE
    0x80805EF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80b8_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b8"
    VALUE
    0x80805EF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80b9_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80b9"
    VALUE
    0x80805EFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80ba_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80ba"
    VALUE
    0x80805F00
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80bb_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80bb"
    VALUE
    0x80805F04
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80bc_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80bc"
    VALUE
    0x80805F08
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80bd_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80bd"
    VALUE
    0x80805F0C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80be_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80be"
    VALUE
    0x80805F10
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80bf_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80bf"
    VALUE
    0x80805F14
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80c0_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c0"
    VALUE
    0x80805F18
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80c1_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c1"
    VALUE
    0x80805F1C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80c2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c2"
    VALUE
    0x80805F20
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80c3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c3"
    VALUE
    0x80805F24
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80c4_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c4"
    VALUE
    0x80805F28
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80c5_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c5"
    VALUE
    0x80805F2C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_NoDeb0x80c6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_NoDeb0x80c6"
    VALUE
    0x80805F30
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_TiUpDwn0x8A01_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x80805F34
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_TiUpDwn0x8A02_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x80805F38
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_bds_TiUpDwn0x8A03_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x80805F3C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA13OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA13OR"
    VALUE
    0x80805F40
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA13SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA13SCB"
    VALUE
    0x80805F44
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA13SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA13SCG"
    VALUE
    0x80805F48
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA14OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA14OR"
    VALUE
    0x80805F4C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA14SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA14SCB"
    VALUE
    0x80805F50
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA14SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA14SCG"
    VALUE
    0x80805F54
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA21OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA21OR"
    VALUE
    0x80805F58
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA21SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA21SCB"
    VALUE
    0x80805F5C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA21SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA21SCG"
    VALUE
    0x80805F60
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA22OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA22OR"
    VALUE
    0x80805F64
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA22SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA22SCB"
    VALUE
    0x80805F68
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA22SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA22SCG"
    VALUE
    0x80805F6C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA23OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA23OR"
    VALUE
    0x80805F70
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA23SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA23SCB"
    VALUE
    0x80805F74
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA23SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA23SCG"
    VALUE
    0x80805F78
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA24OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA24OR"
    VALUE
    0x80805F7C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA24SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA24SCB"
    VALUE
    0x80805F80
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA24SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA24SCG"
    VALUE
    0x80805F84
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA25OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA25OR"
    VALUE
    0x80805F88
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA25SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA25SCB"
    VALUE
    0x80805F8C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA25SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA25SCG"
    VALUE
    0x80805F90
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA26OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA26OR"
    VALUE
    0x80805F94
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA26SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA26SCB"
    VALUE
    0x80805F98
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA26SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA26SCG"
    VALUE
    0x80805F9C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA27OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA27OR"
    VALUE
    0x80805FA0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA27SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA27SCB"
    VALUE
    0x80805FA4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA27SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA27SCG"
    VALUE
    0x80805FA8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA28OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA28OR"
    VALUE
    0x80805FAC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA28SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA28SCB"
    VALUE
    0x80805FB0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA28SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA28SCG"
    VALUE
    0x80805FB4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA29OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA29OR"
    VALUE
    0x80805FB8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA29SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA29SCB"
    VALUE
    0x80805FBC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA29SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA29SCG"
    VALUE
    0x80805FC0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36AicSCB"
    VALUE
    0x80805FC4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36AicSCG"
    VALUE
    0x80805FC8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36OR"
    VALUE
    0x80805FCC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36SCB"
    VALUE
    0x80805FD0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36SCG"
    VALUE
    0x80805FD4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA36ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80805FD8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37AicSCB"
    VALUE
    0x80805FDC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37AicSCG"
    VALUE
    0x80805FE0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37OR"
    VALUE
    0x80805FE4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37SCB"
    VALUE
    0x80805FE8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37SCG"
    VALUE
    0x80805FEC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA37ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80805FF0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80805FF4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38AicSCG"
    VALUE
    0x80805FF8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38OR"
    VALUE
    0x80805FFC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38SCB"
    VALUE
    0x80806000
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38SCG"
    VALUE
    0x80806004
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA38ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80806008
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39AicSCB"
    VALUE
    0x8080600C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80806010
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39OR"
    VALUE
    0x80806014
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39SCB"
    VALUE
    0x80806018
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39SCG"
    VALUE
    0x8080601C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA39ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80806020
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA40OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA40OR"
    VALUE
    0x80806024
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA40SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA40SCB"
    VALUE
    0x80806028
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA40SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA40SCG"
    VALUE
    0x8080602C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA41OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA41OR"
    VALUE
    0x80806030
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA41SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA41SCB"
    VALUE
    0x80806034
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA41SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA41SCG"
    VALUE
    0x80806038
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA42OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA42OR"
    VALUE
    0x8080603C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA42SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA42SCB"
    VALUE
    0x80806040
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA42SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA42SCG"
    VALUE
    0x80806044
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80806048
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43AicSCG"
    VALUE
    0x8080604C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43OR"
    VALUE
    0x80806050
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43SCB"
    VALUE
    0x80806054
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43SCG"
    VALUE
    0x80806058
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA43ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x8080605C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA44OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA44OL"
    VALUE
    0x80806060
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA44SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA44SCB"
    VALUE
    0x80806064
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA44SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA44SCG"
    VALUE
    0x80806068
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA57OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA57OR"
    VALUE
    0x8080606C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA57SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA57SCB"
    VALUE
    0x80806070
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA57SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA57SCG"
    VALUE
    0x80806074
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA59OL_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA59OL"
    VALUE
    0x80806078
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA59SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA59SCB"
    VALUE
    0x8080607C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inA59SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inA59SCG"
    VALUE
    0x80806080
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK10OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK10OR"
    VALUE
    0x80806084
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK10SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK10SCB"
    VALUE
    0x80806088
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK10SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK10SCG"
    VALUE
    0x8080608C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK11OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK11OR"
    VALUE
    0x80806090
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK11SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK11SCB"
    VALUE
    0x80806094
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK11SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK11SCG"
    VALUE
    0x80806098
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30AicSCB"
    VALUE
    0x8080609C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30AicSCG"
    VALUE
    0x808060A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30OR"
    VALUE
    0x808060A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30SCB"
    VALUE
    0x808060A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30SCG"
    VALUE
    0x808060AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK30ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x808060B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK31OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK31OR"
    VALUE
    0x808060B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK31SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK31SCB"
    VALUE
    0x808060B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK31SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK31SCG"
    VALUE
    0x808060BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK32OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK32OR"
    VALUE
    0x808060C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK32SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK32SCB"
    VALUE
    0x808060C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK32SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK32SCG"
    VALUE
    0x808060C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK33OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK33OR"
    VALUE
    0x808060CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK33SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK33SCB"
    VALUE
    0x808060D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK33SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK33SCG"
    VALUE
    0x808060D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK34OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK34OR"
    VALUE
    0x808060D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK34SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK34SCB"
    VALUE
    0x808060DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK34SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK34SCG"
    VALUE
    0x808060E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK35OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK35OR"
    VALUE
    0x808060E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK35SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK35SCB"
    VALUE
    0x808060E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK35SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK35SCG"
    VALUE
    0x808060EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK36OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK36OR"
    VALUE
    0x808060F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK36SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK36SCB"
    VALUE
    0x808060F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK36SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK36SCG"
    VALUE
    0x808060F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37AicSCB"
    VALUE
    0x808060FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37AicSCG"
    VALUE
    0x80806100
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37OR"
    VALUE
    0x80806104
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37SCB"
    VALUE
    0x80806108
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37SCG"
    VALUE
    0x8080610C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK37ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80806110
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80806114
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80806118
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38OR"
    VALUE
    0x8080611C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38SCB"
    VALUE
    0x80806120
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38SCG"
    VALUE
    0x80806124
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK38ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80806128
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39AicSCB"
    VALUE
    0x8080612C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80806130
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39OR"
    VALUE
    0x80806134
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39SCB"
    VALUE
    0x80806138
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39SCG"
    VALUE
    0x8080613C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK39ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80806140
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40AicSCB"
    VALUE
    0x80806144
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80806148
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40OR"
    VALUE
    0x8080614C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40SCB"
    VALUE
    0x80806150
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40SCG"
    VALUE
    0x80806154
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK40ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80806158
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41AicSCB"
    VALUE
    0x8080615C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41AicSCG"
    VALUE
    0x80806160
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41OR"
    VALUE
    0x80806164
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41SCB"
    VALUE
    0x80806168
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41SCG"
    VALUE
    0x8080616C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK41ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80806170
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42AicSCB"
    VALUE
    0x80806174
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42AicSCG"
    VALUE
    0x80806178
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42OR"
    VALUE
    0x8080617C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42SCB"
    VALUE
    0x80806180
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42SCG"
    VALUE
    0x80806184
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK42ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80806188
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK43OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK43OR"
    VALUE
    0x8080618C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK43SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK43SCB"
    VALUE
    0x80806190
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK43SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK43SCG"
    VALUE
    0x80806194
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80806198
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44AicSCG"
    VALUE
    0x8080619C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44OR"
    VALUE
    0x808061A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44SCB"
    VALUE
    0x808061A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44SCG"
    VALUE
    0x808061A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK44ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x808061AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45AicSCB"
    VALUE
    0x808061B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45AicSCG"
    VALUE
    0x808061B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45OR"
    VALUE
    0x808061B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45SCB"
    VALUE
    0x808061BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45SCG"
    VALUE
    0x808061C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK45ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x808061C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK52OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK52OR"
    VALUE
    0x808061C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK52SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK52SCB"
    VALUE
    0x808061CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK52SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK52SCG"
    VALUE
    0x808061D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK53OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK53OR"
    VALUE
    0x808061D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK53SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK53SCB"
    VALUE
    0x808061D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK53SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK53SCG"
    VALUE
    0x808061DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54AicSCB"
    VALUE
    0x808061E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54AicSCG"
    VALUE
    0x808061E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54OR"
    VALUE
    0x808061E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54SCB"
    VALUE
    0x808061EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54SCG"
    VALUE
    0x808061F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK54ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x808061F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55AicSCB"
    VALUE
    0x808061F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55AicSCG"
    VALUE
    0x808061FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55OR"
    VALUE
    0x80806200
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55SCB"
    VALUE
    0x80806204
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55SCG"
    VALUE
    0x80806208
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK55ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x8080620C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK56OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK56OR"
    VALUE
    0x80806210
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK56SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK56SCB"
    VALUE
    0x80806214
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK56SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK56SCG"
    VALUE
    0x80806218
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK57OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK57OR"
    VALUE
    0x8080621C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK57SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK57SCB"
    VALUE
    0x80806220
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK57SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK57SCG"
    VALUE
    0x80806224
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK58OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK58OR"
    VALUE
    0x80806228
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK58SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK58SCB"
    VALUE
    0x8080622C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK58SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK58SCG"
    VALUE
    0x80806230
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK59OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK59OR"
    VALUE
    0x80806234
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK59SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK59SCB"
    VALUE
    0x80806238
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK59SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK59SCG"
    VALUE
    0x8080623C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK60OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK60OR"
    VALUE
    0x80806240
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK60SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK60SCB"
    VALUE
    0x80806244
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK60SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK60SCG"
    VALUE
    0x80806248
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61AicSCB"
    VALUE
    0x8080624C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61AicSCG"
    VALUE
    0x80806250
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61OR"
    VALUE
    0x80806254
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61SCB"
    VALUE
    0x80806258
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61SCG"
    VALUE
    0x8080625C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK61ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80806260
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK62OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK62OR"
    VALUE
    0x80806264
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK62SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK62SCB"
    VALUE
    0x80806268
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK62SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK62SCG"
    VALUE
    0x8080626C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80806270
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63AicSCG"
    VALUE
    0x80806274
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63OR"
    VALUE
    0x80806278
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63SCB"
    VALUE
    0x8080627C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63SCG"
    VALUE
    0x80806280
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK63ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80806284
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64AicSCB"
    VALUE
    0x80806288
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64AicSCG"
    VALUE
    0x8080628C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64OR"
    VALUE
    0x80806290
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64SCB"
    VALUE
    0x80806294
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64SCG"
    VALUE
    0x80806298
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK64ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x8080629C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65AicSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65AicSCB"
    VALUE
    0x808062A0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65AicSCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65AicSCG"
    VALUE
    0x808062A4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65OR"
    VALUE
    0x808062A8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65SCB"
    VALUE
    0x808062AC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65SCG"
    VALUE
    0x808062B0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK65ShuntSCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x808062B4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK74OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK74OR"
    VALUE
    0x808062B8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK74SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK74SCB"
    VALUE
    0x808062BC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK74SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK74SCG"
    VALUE
    0x808062C0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK75OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK75OR"
    VALUE
    0x808062C4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK75SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK75SCB"
    VALUE
    0x808062C8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK75SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK75SCG"
    VALUE
    0x808062CC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK76OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK76OR"
    VALUE
    0x808062D0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK76SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK76SCB"
    VALUE
    0x808062D4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK76SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK76SCG"
    VALUE
    0x808062D8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK77OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK77OR"
    VALUE
    0x808062DC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK77SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK77SCB"
    VALUE
    0x808062E0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK77SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK77SCG"
    VALUE
    0x808062E4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK78OR_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK78OR"
    VALUE
    0x808062E8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK78SCB_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK78SCB"
    VALUE
    0x808062EC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_inK78SCG_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_inK78SCG"
    VALUE
    0x808062F0
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_DvUBAT_FWs_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x808062F4
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OVErr_VPR6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x808062F8
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OVWarn_VPR6_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x808062FC
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80806300
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80806304
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_UBAT_MON_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80806308
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x8080630C
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCSAE.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "J1939SPN specific trouble code / J1939SPN specific specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80806310
    Val_Wu32
    4294967295.00
    DFES_OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    

