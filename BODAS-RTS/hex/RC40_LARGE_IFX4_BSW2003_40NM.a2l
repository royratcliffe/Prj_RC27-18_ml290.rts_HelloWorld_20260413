    0x808004AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA47SCB"
    VALUE
    0x808004AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA47SCB"
    VALUE
    0x808004AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA47SCG"
    VALUE
    0x808004B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA47SCG"
    VALUE
    0x808004B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA48OL"
    VALUE
    0x808004B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA48OL"
    VALUE
    0x808004B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA48OR"
    VALUE
    0x808004B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA48OR"
    VALUE
    0x808004BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA48OT"
    VALUE
    0x808004BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA48OT"
    VALUE
    0x808004BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA48SCB"
    VALUE
    0x808004C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA48SCB"
    VALUE
    0x808004C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA48SCG"
    VALUE
    0x808004C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA48SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA48SCG"
    VALUE
    0x808004C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA49OL"
    VALUE
    0x808004C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA49OL"
    VALUE
    0x808004CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA49OT"
    VALUE
    0x808004CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA49OT"
    VALUE
    0x808004CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA49SCB"
    VALUE
    0x808004D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA49SCB"
    VALUE
    0x808004D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA49SCG"
    VALUE
    0x808004D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA49SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA49SCG"
    VALUE
    0x808004D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA50OL"
    VALUE
    0x808004D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA50OL"
    VALUE
    0x808004DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA50OT"
    VALUE
    0x808004DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA50OT"
    VALUE
    0x808004DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA50SCB"
    VALUE
    0x808004E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA50SCB"
    VALUE
    0x808004E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA50SCG"
    VALUE
    0x808004E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA50SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA50SCG"
    VALUE
    0x808004E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA51OL"
    VALUE
    0x808004E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA51OL"
    VALUE
    0x808004EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA51OR"
    VALUE
    0x808004EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA51OR"
    VALUE
    0x808004EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA51OT"
    VALUE
    0x808004F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA51OT"
    VALUE
    0x808004F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA51SCB"
    VALUE
    0x808004F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA51SCB"
    VALUE
    0x808004F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA51SCG"
    VALUE
    0x808004F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA51SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA51SCG"
    VALUE
    0x808004FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA52OL"
    VALUE
    0x808004FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA52OL"
    VALUE
    0x808004FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA52OR"
    VALUE
    0x80800500
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA52OR"
    VALUE
    0x80800502
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA52OT"
    VALUE
    0x80800504
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA52OT"
    VALUE
    0x80800506
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA52SCB"
    VALUE
    0x80800508
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA52SCB"
    VALUE
    0x8080050A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA52SCG"
    VALUE
    0x8080050C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA52SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA52SCG"
    VALUE
    0x8080050E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA53OL"
    VALUE
    0x80800510
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA53OL"
    VALUE
    0x80800512
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA53OR"
    VALUE
    0x80800514
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA53OR"
    VALUE
    0x80800516
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA53OT"
    VALUE
    0x80800518
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA53OT"
    VALUE
    0x8080051A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA53SCB"
    VALUE
    0x8080051C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA53SCB"
    VALUE
    0x8080051E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA53SCG"
    VALUE
    0x80800520
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA53SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA53SCG"
    VALUE
    0x80800522
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA54OL"
    VALUE
    0x80800524
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA54OL"
    VALUE
    0x80800526
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA54OR"
    VALUE
    0x80800528
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA54OR"
    VALUE
    0x8080052A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA54OT"
    VALUE
    0x8080052C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA54OT"
    VALUE
    0x8080052E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA54SCB"
    VALUE
    0x80800530
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA54SCB"
    VALUE
    0x80800532
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA54SCG"
    VALUE
    0x80800534
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA54SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA54SCG"
    VALUE
    0x80800536
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA55OL"
    VALUE
    0x80800538
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA55OL"
    VALUE
    0x8080053A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA55OT"
    VALUE
    0x8080053C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA55OT"
    VALUE
    0x8080053E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA55SCB"
    VALUE
    0x80800540
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA55SCB"
    VALUE
    0x80800542
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA55SCG"
    VALUE
    0x80800544
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA55SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA55SCG"
    VALUE
    0x80800546
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA56OL"
    VALUE
    0x80800548
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA56OL"
    VALUE
    0x8080054A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA56OT"
    VALUE
    0x8080054C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA56OT"
    VALUE
    0x8080054E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA56SCB"
    VALUE
    0x80800550
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA56SCB"
    VALUE
    0x80800552
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA56SCG"
    VALUE
    0x80800554
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA56SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA56SCG"
    VALUE
    0x80800556
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA58OL"
    VALUE
    0x80800558
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA58OL"
    VALUE
    0x8080055A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA58OT"
    VALUE
    0x8080055C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA58OT"
    VALUE
    0x8080055E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA58SCB"
    VALUE
    0x80800560
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA58SCB"
    VALUE
    0x80800562
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA58SCG"
    VALUE
    0x80800564
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA58SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA58SCG"
    VALUE
    0x80800566
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK14OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK14OR"
    VALUE
    0x80800568
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK14OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK14OR"
    VALUE
    0x8080056A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK15OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK15OR"
    VALUE
    0x8080056C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK15OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK15OR"
    VALUE
    0x8080056E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK16OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK16OR"
    VALUE
    0x80800570
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK16OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK16OR"
    VALUE
    0x80800572
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK17OL"
    VALUE
    0x80800574
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK17OL"
    VALUE
    0x80800576
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK17OR"
    VALUE
    0x80800578
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK17OR"
    VALUE
    0x8080057A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK17OT"
    VALUE
    0x8080057C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK17OT"
    VALUE
    0x8080057E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK17SCB"
    VALUE
    0x80800580
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK17SCB"
    VALUE
    0x80800582
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK17SCG"
    VALUE
    0x80800584
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outK17SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK17SCG"
    VALUE
    0x80800586
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattUHiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_DevLibBattUHi"
    VALUE
    0x80800588
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattUHiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_DevLibBattUHi"
    VALUE
    0x8080058A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattULoDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_DevLibBattULo"
    VALUE
    0x8080058C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattULoDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_DevLibBattULo"
    VALUE
    0x8080058E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8063DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8063"
    VALUE
    0x80800590
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8063DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8063"
    VALUE
    0x80800592
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8064DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8064"
    VALUE
    0x80800594
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8064DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8064"
    VALUE
    0x80800596
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8065DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8065"
    VALUE
    0x80800598
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8065DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8065"
    VALUE
    0x8080059A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8066DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8066"
    VALUE
    0x8080059C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8066DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8066"
    VALUE
    0x8080059E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8067DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8067"
    VALUE
    0x808005A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8067DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8067"
    VALUE
    0x808005A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8068DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8068"
    VALUE
    0x808005A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8068DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8068"
    VALUE
    0x808005A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8069DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8069"
    VALUE
    0x808005A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8069DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8069"
    VALUE
    0x808005AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806aDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x806a"
    VALUE
    0x808005AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806aDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x806a"
    VALUE
    0x808005AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806bDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x806b"
    VALUE
    0x808005B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806bDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x806b"
    VALUE
    0x808005B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806cDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x806c"
    VALUE
    0x808005B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806cDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x806c"
    VALUE
    0x808005B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806dDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x806d"
    VALUE
    0x808005B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806dDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x806d"
    VALUE
    0x808005BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806eDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x806e"
    VALUE
    0x808005BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806eDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x806e"
    VALUE
    0x808005BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806fDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x806f"
    VALUE
    0x808005C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x806fDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x806f"
    VALUE
    0x808005C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8070DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8070"
    VALUE
    0x808005C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8070DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8070"
    VALUE
    0x808005C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8071DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8071"
    VALUE
    0x808005C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8071DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8071"
    VALUE
    0x808005CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8072DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8072"
    VALUE
    0x808005CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8072DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8072"
    VALUE
    0x808005CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8073DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8073"
    VALUE
    0x808005D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8073DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8073"
    VALUE
    0x808005D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8074DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8074"
    VALUE
    0x808005D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8074DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8074"
    VALUE
    0x808005D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8075DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8075"
    VALUE
    0x808005D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8075DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8075"
    VALUE
    0x808005DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8076DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8076"
    VALUE
    0x808005DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8076DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8076"
    VALUE
    0x808005DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8077DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8077"
    VALUE
    0x808005E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8077DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8077"
    VALUE
    0x808005E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8078DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8078"
    VALUE
    0x808005E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8078DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8078"
    VALUE
    0x808005E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8079DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8079"
    VALUE
    0x808005E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8079DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8079"
    VALUE
    0x808005EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807aDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x807a"
    VALUE
    0x808005EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807aDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x807a"
    VALUE
    0x808005EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807bDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x807b"
    VALUE
    0x808005F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807bDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x807b"
    VALUE
    0x808005F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807cDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x807c"
    VALUE
    0x808005F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807cDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x807c"
    VALUE
    0x808005F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807dDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x807d"
    VALUE
    0x808005F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807dDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x807d"
    VALUE
    0x808005FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807eDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x807e"
    VALUE
    0x808005FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807eDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x807e"
    VALUE
    0x808005FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807fDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x807f"
    VALUE
    0x80800600
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x807fDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x807f"
    VALUE
    0x80800602
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8080DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8080"
    VALUE
    0x80800604
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8080DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8080"
    VALUE
    0x80800606
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8081DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8081"
    VALUE
    0x80800608
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8081DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8081"
    VALUE
    0x8080060A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8082DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8082"
    VALUE
    0x8080060C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8082DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8082"
    VALUE
    0x8080060E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8083DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8083"
    VALUE
    0x80800610
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8083DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8083"
    VALUE
    0x80800612
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8084DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8084"
    VALUE
    0x80800614
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8084DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8084"
    VALUE
    0x80800616
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8085DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8085"
    VALUE
    0x80800618
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8085DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8085"
    VALUE
    0x8080061A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8086DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8086"
    VALUE
    0x8080061C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8086DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8086"
    VALUE
    0x8080061E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8087DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8087"
    VALUE
    0x80800620
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8087DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8087"
    VALUE
    0x80800622
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8088DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8088"
    VALUE
    0x80800624
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8088DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8088"
    VALUE
    0x80800626
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8089DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8089"
    VALUE
    0x80800628
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8089DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8089"
    VALUE
    0x8080062A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808aDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x808a"
    VALUE
    0x8080062C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808aDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x808a"
    VALUE
    0x8080062E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808bDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x808b"
    VALUE
    0x80800630
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808bDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x808b"
    VALUE
    0x80800632
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808cDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x808c"
    VALUE
    0x80800634
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808cDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x808c"
    VALUE
    0x80800636
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808dDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x808d"
    VALUE
    0x80800638
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808dDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x808d"
    VALUE
    0x8080063A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808eDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x808e"
    VALUE
    0x8080063C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808eDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x808e"
    VALUE
    0x8080063E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808fDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x808f"
    VALUE
    0x80800640
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x808fDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x808f"
    VALUE
    0x80800642
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8090DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8090"
    VALUE
    0x80800644
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8090DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8090"
    VALUE
    0x80800646
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8091DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8091"
    VALUE
    0x80800648
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8091DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8091"
    VALUE
    0x8080064A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8092DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8092"
    VALUE
    0x8080064C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8092DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8092"
    VALUE
    0x8080064E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8093DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8093"
    VALUE
    0x80800650
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8093DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8093"
    VALUE
    0x80800652
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8094DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8094"
    VALUE
    0x80800654
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8094DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8094"
    VALUE
    0x80800656
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8095DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8095"
    VALUE
    0x80800658
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8095DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8095"
    VALUE
    0x8080065A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8096DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8096"
    VALUE
    0x8080065C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8096DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8096"
    VALUE
    0x8080065E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8097DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8097"
    VALUE
    0x80800660
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8097DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8097"
    VALUE
    0x80800662
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8098DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8098"
    VALUE
    0x80800664
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8098DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8098"
    VALUE
    0x80800666
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8099DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8099"
    VALUE
    0x80800668
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8099DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8099"
    VALUE
    0x8080066A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809aDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x809a"
    VALUE
    0x8080066C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809aDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x809a"
    VALUE
    0x8080066E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809bDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x809b"
    VALUE
    0x80800670
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809bDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x809b"
    VALUE
    0x80800672
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809cDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x809c"
    VALUE
    0x80800674
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809cDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x809c"
    VALUE
    0x80800676
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809dDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x809d"
    VALUE
    0x80800678
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809dDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x809d"
    VALUE
    0x8080067A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809eDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x809e"
    VALUE
    0x8080067C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809eDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x809e"
    VALUE
    0x8080067E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809fDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x809f"
    VALUE
    0x80800680
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x809fDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x809f"
    VALUE
    0x80800682
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a0DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80a0"
    VALUE
    0x80800684
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a0DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80a0"
    VALUE
    0x80800686
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a1DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80a1"
    VALUE
    0x80800688
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a1DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80a1"
    VALUE
    0x8080068A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a2DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80a2"
    VALUE
    0x8080068C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a2DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80a2"
    VALUE
    0x8080068E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80a3"
    VALUE
    0x80800690
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80a3"
    VALUE
    0x80800692
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a4DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80a4"
    VALUE
    0x80800694
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a4DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80a4"
    VALUE
    0x80800696
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a5DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80800698
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a5DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80a5"
    VALUE
    0x8080069A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80a6"
    VALUE
    0x8080069C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80a6"
    VALUE
    0x8080069E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a7DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80a7"
    VALUE
    0x808006A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a7DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80a7"
    VALUE
    0x808006A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a8DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80a8"
    VALUE
    0x808006A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a8DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80a8"
    VALUE
    0x808006A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a9DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80a9"
    VALUE
    0x808006A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80a9DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80a9"
    VALUE
    0x808006AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80aaDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80aa"
    VALUE
    0x808006AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80aaDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80aa"
    VALUE
    0x808006AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80abDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ab"
    VALUE
    0x808006B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80abDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ab"
    VALUE
    0x808006B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80acDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ac"
    VALUE
    0x808006B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80acDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ac"
    VALUE
    0x808006B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80adDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ad"
    VALUE
    0x808006B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80adDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ad"
    VALUE
    0x808006BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80aeDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ae"
    VALUE
    0x808006BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80aeDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ae"
    VALUE
    0x808006BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80afDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80af"
    VALUE
    0x808006C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80afDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80af"
    VALUE
    0x808006C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b0DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80b0"
    VALUE
    0x808006C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b0DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80b0"
    VALUE
    0x808006C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b1DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80b1"
    VALUE
    0x808006C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b1DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80b1"
    VALUE
    0x808006CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b2DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80b2"
    VALUE
    0x808006CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b2DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80b2"
    VALUE
    0x808006CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80b3"
    VALUE
    0x808006D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80b3"
    VALUE
    0x808006D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b4DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80b4"
    VALUE
    0x808006D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b4DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80b4"
    VALUE
    0x808006D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b5DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80b5"
    VALUE
    0x808006D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b5DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80b5"
    VALUE
    0x808006DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80b6"
    VALUE
    0x808006DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80b6"
    VALUE
    0x808006DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b7DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80b7"
    VALUE
    0x808006E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b7DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80b7"
    VALUE
    0x808006E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b8DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80b8"
    VALUE
    0x808006E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b8DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80b8"
    VALUE
    0x808006E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b9DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80b9"
    VALUE
    0x808006E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80b9DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80b9"
    VALUE
    0x808006EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80baDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ba"
    VALUE
    0x808006EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80baDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ba"
    VALUE
    0x808006EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80bbDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80bb"
    VALUE
    0x808006F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80bbDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80bb"
    VALUE
    0x808006F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80bcDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80bc"
    VALUE
    0x808006F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80bcDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80bc"
    VALUE
    0x808006F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80bdDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80bd"
    VALUE
    0x808006F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80bdDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80bd"
    VALUE
    0x808006FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80beDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80be"
    VALUE
    0x808006FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80beDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80be"
    VALUE
    0x808006FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80bfDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80bf"
    VALUE
    0x80800700
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80bfDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80bf"
    VALUE
    0x80800702
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c0DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80c0"
    VALUE
    0x80800704
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c0DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80c0"
    VALUE
    0x80800706
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c1DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80c1"
    VALUE
    0x80800708
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c1DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80c1"
    VALUE
    0x8080070A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c2DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80c2"
    VALUE
    0x8080070C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c2DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80c2"
    VALUE
    0x8080070E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80c3"
    VALUE
    0x80800710
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80c3"
    VALUE
    0x80800712
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c4DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80c4"
    VALUE
    0x80800714
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c4DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80c4"
    VALUE
    0x80800716
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c5DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80c5"
    VALUE
    0x80800718
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c5DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80c5"
    VALUE
    0x8080071A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80c6"
    VALUE
    0x8080071C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80c6"
    VALUE
    0x8080071E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiUpDwn0x8A01DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x80800720
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiUpDwn0x8A01DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x80800722
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiUpDwn0x8A02DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x80800724
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiUpDwn0x8A02DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x80800726
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiUpDwn0x8A03DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x80800728
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiUpDwn0x8A03DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x8080072A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tK44SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44SCB"
    VALUE
    0x8080072C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tK44SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44SCB"
    VALUE
    0x8080072E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA13OR"
    VALUE
    0x80800730
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA13OR"
    VALUE
    0x80800732
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA13SCB"
    VALUE
    0x80800734
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA13SCB"
    VALUE
    0x80800736
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA13SCG"
    VALUE
    0x80800738
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA13SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA13SCG"
    VALUE
    0x8080073A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA14OR"
    VALUE
    0x8080073C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA14OR"
    VALUE
    0x8080073E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA14SCB"
    VALUE
    0x80800740
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA14SCB"
    VALUE
    0x80800742
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA14SCG"
    VALUE
    0x80800744
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA14SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA14SCG"
    VALUE
    0x80800746
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA21OR"
    VALUE
    0x80800748
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA21OR"
    VALUE
    0x8080074A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA21SCB"
    VALUE
    0x8080074C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA21SCB"
    VALUE
    0x8080074E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA21SCG"
    VALUE
    0x80800750
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA21SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA21SCG"
    VALUE
    0x80800752
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA22OR"
    VALUE
    0x80800754
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA22OR"
    VALUE
    0x80800756
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA22SCB"
    VALUE
    0x80800758
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA22SCB"
    VALUE
    0x8080075A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA22SCG"
    VALUE
    0x8080075C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA22SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA22SCG"
    VALUE
    0x8080075E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA23OR"
    VALUE
    0x80800760
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA23OR"
    VALUE
    0x80800762
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA23SCB"
    VALUE
    0x80800764
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA23SCB"
    VALUE
    0x80800766
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA23SCG"
    VALUE
    0x80800768
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA23SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA23SCG"
    VALUE
    0x8080076A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA24OR"
    VALUE
    0x8080076C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA24OR"
    VALUE
    0x8080076E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA24SCB"
    VALUE
    0x80800770
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA24SCB"
    VALUE
    0x80800772
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA24SCG"
    VALUE
    0x80800774
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA24SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA24SCG"
    VALUE
    0x80800776
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA25OR"
    VALUE
    0x80800778
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA25OR"
    VALUE
    0x8080077A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA25SCB"
    VALUE
    0x8080077C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA25SCB"
    VALUE
    0x8080077E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA25SCG"
    VALUE
    0x80800780
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA25SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA25SCG"
    VALUE
    0x80800782
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA26OR"
    VALUE
    0x80800784
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA26OR"
    VALUE
    0x80800786
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA26SCB"
    VALUE
    0x80800788
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA26SCB"
    VALUE
    0x8080078A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA26SCG"
    VALUE
    0x8080078C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA26SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA26SCG"
    VALUE
    0x8080078E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA27OR"
    VALUE
    0x80800790
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA27OR"
    VALUE
    0x80800792
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA27SCB"
    VALUE
    0x80800794
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA27SCB"
    VALUE
    0x80800796
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA27SCG"
    VALUE
    0x80800798
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA27SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA27SCG"
    VALUE
    0x8080079A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA28OR"
    VALUE
    0x8080079C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA28OR"
    VALUE
    0x8080079E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA28SCB"
    VALUE
    0x808007A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA28SCB"
    VALUE
    0x808007A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA28SCG"
    VALUE
    0x808007A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA28SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA28SCG"
    VALUE
    0x808007A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA29OR"
    VALUE
    0x808007A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA29OR"
    VALUE
    0x808007AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA29SCB"
    VALUE
    0x808007AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA29SCB"
    VALUE
    0x808007AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA29SCG"
    VALUE
    0x808007B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA29SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA29SCG"
    VALUE
    0x808007B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36AicSCB"
    VALUE
    0x808007B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36AicSCB"
    VALUE
    0x808007B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36AicSCG"
    VALUE
    0x808007B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36AicSCG"
    VALUE
    0x808007BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36OR"
    VALUE
    0x808007BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36OR"
    VALUE
    0x808007BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36SCB"
    VALUE
    0x808007C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36SCB"
    VALUE
    0x808007C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36SCG"
    VALUE
    0x808007C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36SCG"
    VALUE
    0x808007C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x808007C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA36ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x808007CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37AicSCB"
    VALUE
    0x808007CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37AicSCB"
    VALUE
    0x808007CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37AicSCG"
    VALUE
    0x808007D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37AicSCG"
    VALUE
    0x808007D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37OR"
    VALUE
    0x808007D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37OR"
    VALUE
    0x808007D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37SCB"
    VALUE
    0x808007D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37SCB"
    VALUE
    0x808007DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37SCG"
    VALUE
    0x808007DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37SCG"
    VALUE
    0x808007DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x808007E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA37ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x808007E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38AicSCB"
    VALUE
    0x808007E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38AicSCB"
    VALUE
    0x808007E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38AicSCG"
    VALUE
    0x808007E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38AicSCG"
    VALUE
    0x808007EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38OR"
    VALUE
    0x808007EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38OR"
    VALUE
    0x808007EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38SCB"
    VALUE
    0x808007F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38SCB"
    VALUE
    0x808007F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38SCG"
    VALUE
    0x808007F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38SCG"
    VALUE
    0x808007F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x808007F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA38ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x808007FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39AicSCB"
    VALUE
    0x808007FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39AicSCB"
    VALUE
    0x808007FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80800800
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80800802
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39OR"
    VALUE
    0x80800804
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39OR"
    VALUE
    0x80800806
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39SCB"
    VALUE
    0x80800808
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39SCB"
    VALUE
    0x8080080A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39SCG"
    VALUE
    0x8080080C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39SCG"
    VALUE
    0x8080080E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80800810
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA39ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80800812
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA40OR"
    VALUE
    0x80800814
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA40OR"
    VALUE
    0x80800816
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA40SCB"
    VALUE
    0x80800818
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA40SCB"
    VALUE
    0x8080081A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA40SCG"
    VALUE
    0x8080081C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA40SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA40SCG"
    VALUE
    0x8080081E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA41OR"
    VALUE
    0x80800820
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA41OR"
    VALUE
    0x80800822
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA41SCB"
    VALUE
    0x80800824
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA41SCB"
    VALUE
    0x80800826
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA41SCG"
    VALUE
    0x80800828
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA41SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA41SCG"
    VALUE
    0x8080082A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA42OR"
    VALUE
    0x8080082C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA42OR"
    VALUE
    0x8080082E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA42SCB"
    VALUE
    0x80800830
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA42SCB"
    VALUE
    0x80800832
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA42SCG"
    VALUE
    0x80800834
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA42SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA42SCG"
    VALUE
    0x80800836
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80800838
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43AicSCB"
    VALUE
    0x8080083A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43AicSCG"
    VALUE
    0x8080083C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43AicSCG"
    VALUE
    0x8080083E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43OR"
    VALUE
    0x80800840
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43OR"
    VALUE
    0x80800842
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43SCB"
    VALUE
    0x80800844
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43SCB"
    VALUE
    0x80800846
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43SCG"
    VALUE
    0x80800848
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43SCG"
    VALUE
    0x8080084A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x8080084C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA43ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x8080084E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA44OL"
    VALUE
    0x80800850
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA44OL"
    VALUE
    0x80800852
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA44SCB"
    VALUE
    0x80800854
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA44SCB"
    VALUE
    0x80800856
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA44SCG"
    VALUE
    0x80800858
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA44SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA44SCG"
    VALUE
    0x8080085A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA57OR"
    VALUE
    0x8080085C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA57OR"
    VALUE
    0x8080085E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA57SCB"
    VALUE
    0x80800860
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA57SCB"
    VALUE
    0x80800862
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA57SCG"
    VALUE
    0x80800864
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA57SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA57SCG"
    VALUE
    0x80800866
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA59OL"
    VALUE
    0x80800868
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA59OL"
    VALUE
    0x8080086A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA59SCB"
    VALUE
    0x8080086C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA59SCB"
    VALUE
    0x8080086E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inA59SCG"
    VALUE
    0x80800870
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiA59SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inA59SCG"
    VALUE
    0x80800872
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK10OR"
    VALUE
    0x80800874
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK10OR"
    VALUE
    0x80800876
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK10SCB"
    VALUE
    0x80800878
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK10SCB"
    VALUE
    0x8080087A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK10SCG"
    VALUE
    0x8080087C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK10SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK10SCG"
    VALUE
    0x8080087E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK11OR"
    VALUE
    0x80800880
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK11OR"
    VALUE
    0x80800882
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK11SCB"
    VALUE
    0x80800884
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK11SCB"
    VALUE
    0x80800886
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK11SCG"
    VALUE
    0x80800888
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK11SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK11SCG"
    VALUE
    0x8080088A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30AicSCB"
    VALUE
    0x8080088C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30AicSCB"
    VALUE
    0x8080088E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80800890
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80800892
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30OR"
    VALUE
    0x80800894
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30OR"
    VALUE
    0x80800896
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30SCB"
    VALUE
    0x80800898
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30SCB"
    VALUE
    0x8080089A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30SCG"
    VALUE
    0x8080089C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30SCG"
    VALUE
    0x8080089E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x808008A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK30ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x808008A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK31OR"
    VALUE
    0x808008A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK31OR"
    VALUE
    0x808008A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK31SCB"
    VALUE
    0x808008A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK31SCB"
    VALUE
    0x808008AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK31SCG"
    VALUE
    0x808008AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK31SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK31SCG"
    VALUE
    0x808008AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK32OR"
    VALUE
    0x808008B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK32OR"
    VALUE
    0x808008B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK32SCB"
    VALUE
    0x808008B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK32SCB"
    VALUE
    0x808008B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK32SCG"
    VALUE
    0x808008B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK32SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK32SCG"
    VALUE
    0x808008BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK33OR"
    VALUE
    0x808008BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK33OR"
    VALUE
    0x808008BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK33SCB"
    VALUE
    0x808008C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK33SCB"
    VALUE
    0x808008C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK33SCG"
    VALUE
    0x808008C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK33SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK33SCG"
    VALUE
    0x808008C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK34OR"
    VALUE
    0x808008C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK34OR"
    VALUE
    0x808008CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK34SCB"
    VALUE
    0x808008CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK34SCB"
    VALUE
    0x808008CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK34SCG"
    VALUE
    0x808008D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK34SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK34SCG"
    VALUE
    0x808008D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK35OR"
    VALUE
    0x808008D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK35OR"
    VALUE
    0x808008D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK35SCB"
    VALUE
    0x808008D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK35SCB"
    VALUE
    0x808008DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK35SCG"
    VALUE
    0x808008DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK35SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK35SCG"
    VALUE
    0x808008DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK36OR"
    VALUE
    0x808008E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK36OR"
    VALUE
    0x808008E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK36SCB"
    VALUE
    0x808008E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK36SCB"
    VALUE
    0x808008E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK36SCG"
    VALUE
    0x808008E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK36SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK36SCG"
    VALUE
    0x808008EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37AicSCB"
    VALUE
    0x808008EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37AicSCB"
    VALUE
    0x808008EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37AicSCG"
    VALUE
    0x808008F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37AicSCG"
    VALUE
    0x808008F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37OR"
    VALUE
    0x808008F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37OR"
    VALUE
    0x808008F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37SCB"
    VALUE
    0x808008F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37SCB"
    VALUE
    0x808008FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37SCG"
    VALUE
    0x808008FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37SCG"
    VALUE
    0x808008FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80800900
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK37ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80800902
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80800904
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80800906
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80800908
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38AicSCG"
    VALUE
    0x8080090A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38OR"
    VALUE
    0x8080090C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38OR"
    VALUE
    0x8080090E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38SCB"
    VALUE
    0x80800910
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38SCB"
    VALUE
    0x80800912
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38SCG"
    VALUE
    0x80800914
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38SCG"
    VALUE
    0x80800916
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80800918
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK38ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x8080091A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39AicSCB"
    VALUE
    0x8080091C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39AicSCB"
    VALUE
    0x8080091E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80800920
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39AicSCG"
    VALUE
    0x80800922
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39OR"
    VALUE
    0x80800924
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39OR"
    VALUE
    0x80800926
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39SCB"
    VALUE
    0x80800928
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39SCB"
    VALUE
    0x8080092A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39SCG"
    VALUE
    0x8080092C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39SCG"
    VALUE
    0x8080092E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80800930
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK39ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80800932
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40AicSCB"
    VALUE
    0x80800934
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40AicSCB"
    VALUE
    0x80800936
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80800938
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40AicSCG"
    VALUE
    0x8080093A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40OR"
    VALUE
    0x8080093C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40OR"
    VALUE
    0x8080093E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40SCB"
    VALUE
    0x80800940
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40SCB"
    VALUE
    0x80800942
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40SCG"
    VALUE
    0x80800944
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40SCG"
    VALUE
    0x80800946
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80800948
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK40ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x8080094A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41AicSCB"
    VALUE
    0x8080094C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41AicSCB"
    VALUE
    0x8080094E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41AicSCG"
    VALUE
    0x80800950
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41AicSCG"
    VALUE
    0x80800952
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41OR"
    VALUE
    0x80800954
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41OR"
    VALUE
    0x80800956
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41SCB"
    VALUE
    0x80800958
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41SCB"
    VALUE
    0x8080095A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41SCG"
    VALUE
    0x8080095C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41SCG"
    VALUE
    0x8080095E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80800960
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK41ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80800962
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42AicSCB"
    VALUE
    0x80800964
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42AicSCB"
    VALUE
    0x80800966
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42AicSCG"
    VALUE
    0x80800968
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42AicSCG"
    VALUE
    0x8080096A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42OR"
    VALUE
    0x8080096C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42OR"
    VALUE
    0x8080096E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42SCB"
    VALUE
    0x80800970
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42SCB"
    VALUE
    0x80800972
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42SCG"
    VALUE
    0x80800974
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42SCG"
    VALUE
    0x80800976
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80800978
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK42ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x8080097A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK43OR"
    VALUE
    0x8080097C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK43OR"
    VALUE
    0x8080097E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK43SCB"
    VALUE
    0x80800980
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK43SCB"
    VALUE
    0x80800982
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK43SCG"
    VALUE
    0x80800984
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK43SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK43SCG"
    VALUE
    0x80800986
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80800988
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44AicSCB"
    VALUE
    0x8080098A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44AicSCG"
    VALUE
    0x8080098C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44AicSCG"
    VALUE
    0x8080098E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44OR"
    VALUE
    0x80800990
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44OR"
    VALUE
    0x80800992
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44SCG"
    VALUE
    0x80800994
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44SCG"
    VALUE
    0x80800996
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80800998
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK44ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x8080099A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45AicSCB"
    VALUE
    0x8080099C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45AicSCB"
    VALUE
    0x8080099E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45AicSCG"
    VALUE
    0x808009A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45AicSCG"
    VALUE
    0x808009A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45OR"
    VALUE
    0x808009A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45OR"
    VALUE
    0x808009A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45SCB"
    VALUE
    0x808009A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45SCB"
    VALUE
    0x808009AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45SCG"
    VALUE
    0x808009AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45SCG"
    VALUE
    0x808009AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x808009B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK45ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x808009B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK52OR"
    VALUE
    0x808009B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK52OR"
    VALUE
    0x808009B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK52SCB"
    VALUE
    0x808009B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK52SCB"
    VALUE
    0x808009BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK52SCG"
    VALUE
    0x808009BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK52SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK52SCG"
    VALUE
    0x808009BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK53OR"
    VALUE
    0x808009C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK53OR"
    VALUE
    0x808009C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK53SCB"
    VALUE
    0x808009C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK53SCB"
    VALUE
    0x808009C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK53SCG"
    VALUE
    0x808009C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK53SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK53SCG"
    VALUE
    0x808009CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54AicSCB"
    VALUE
    0x808009CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54AicSCB"
    VALUE
    0x808009CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54AicSCG"
    VALUE
    0x808009D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54AicSCG"
    VALUE
    0x808009D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54OR"
    VALUE
    0x808009D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54OR"
    VALUE
    0x808009D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54SCB"
    VALUE
    0x808009D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54SCB"
    VALUE
    0x808009DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54SCG"
    VALUE
    0x808009DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54SCG"
    VALUE
    0x808009DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x808009E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK54ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x808009E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55AicSCB"
    VALUE
    0x808009E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55AicSCB"
    VALUE
    0x808009E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55AicSCG"
    VALUE
    0x808009E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55AicSCG"
    VALUE
    0x808009EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55OR"
    VALUE
    0x808009EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55OR"
    VALUE
    0x808009EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55SCB"
    VALUE
    0x808009F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55SCB"
    VALUE
    0x808009F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55SCG"
    VALUE
    0x808009F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55SCG"
    VALUE
    0x808009F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x808009F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK55ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x808009FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK56OR"
    VALUE
    0x808009FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK56OR"
    VALUE
    0x808009FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK56SCB"
    VALUE
    0x80800A00
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK56SCB"
    VALUE
    0x80800A02
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK56SCG"
    VALUE
    0x80800A04
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK56SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK56SCG"
    VALUE
    0x80800A06
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK57OR"
    VALUE
    0x80800A08
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK57OR"
    VALUE
    0x80800A0A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK57SCB"
    VALUE
    0x80800A0C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK57SCB"
    VALUE
    0x80800A0E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK57SCG"
    VALUE
    0x80800A10
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK57SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK57SCG"
    VALUE
    0x80800A12
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK58OR"
    VALUE
    0x80800A14
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK58OR"
    VALUE
    0x80800A16
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK58SCB"
    VALUE
    0x80800A18
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK58SCB"
    VALUE
    0x80800A1A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK58SCG"
    VALUE
    0x80800A1C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK58SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK58SCG"
    VALUE
    0x80800A1E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK59OR"
    VALUE
    0x80800A20
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK59OR"
    VALUE
    0x80800A22
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK59SCB"
    VALUE
    0x80800A24
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK59SCB"
    VALUE
    0x80800A26
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK59SCG"
    VALUE
    0x80800A28
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK59SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK59SCG"
    VALUE
    0x80800A2A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK60OR"
    VALUE
    0x80800A2C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK60OR"
    VALUE
    0x80800A2E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK60SCB"
    VALUE
    0x80800A30
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK60SCB"
    VALUE
    0x80800A32
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK60SCG"
    VALUE
    0x80800A34
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK60SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK60SCG"
    VALUE
    0x80800A36
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61AicSCB"
    VALUE
    0x80800A38
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61AicSCB"
    VALUE
    0x80800A3A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61AicSCG"
    VALUE
    0x80800A3C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61AicSCG"
    VALUE
    0x80800A3E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61OR"
    VALUE
    0x80800A40
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61OR"
    VALUE
    0x80800A42
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61SCB"
    VALUE
    0x80800A44
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61SCB"
    VALUE
    0x80800A46
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61SCG"
    VALUE
    0x80800A48
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61SCG"
    VALUE
    0x80800A4A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80800A4C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK61ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80800A4E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK62OR"
    VALUE
    0x80800A50
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK62OR"
    VALUE
    0x80800A52
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK62SCB"
    VALUE
    0x80800A54
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK62SCB"
    VALUE
    0x80800A56
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK62SCG"
    VALUE
    0x80800A58
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK62SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK62SCG"
    VALUE
    0x80800A5A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80800A5C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80800A5E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63AicSCG"
    VALUE
    0x80800A60
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63AicSCG"
    VALUE
    0x80800A62
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63OR"
    VALUE
    0x80800A64
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63OR"
    VALUE
    0x80800A66
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63SCB"
    VALUE
    0x80800A68
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63SCB"
    VALUE
    0x80800A6A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63SCG"
    VALUE
    0x80800A6C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63SCG"
    VALUE
    0x80800A6E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80800A70
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK63ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80800A72
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64AicSCB"
    VALUE
    0x80800A74
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64AicSCB"
    VALUE
    0x80800A76
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64AicSCG"
    VALUE
    0x80800A78
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64AicSCG"
    VALUE
    0x80800A7A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64OR"
    VALUE
    0x80800A7C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64OR"
    VALUE
    0x80800A7E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64SCB"
    VALUE
    0x80800A80
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64SCB"
    VALUE
    0x80800A82
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64SCG"
    VALUE
    0x80800A84
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64SCG"
    VALUE
    0x80800A86
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80800A88
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK64ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80800A8A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65AicSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80800A8C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65AicSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80800A8E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65AicSCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80800A90
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65AicSCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80800A92
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65OR"
    VALUE
    0x80800A94
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65OR"
    VALUE
    0x80800A96
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65SCB"
    VALUE
    0x80800A98
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65SCB"
    VALUE
    0x80800A9A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65SCG"
    VALUE
    0x80800A9C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65SCG"
    VALUE
    0x80800A9E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65ShuntSCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80800AA0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK65ShuntSCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80800AA2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK74OR"
    VALUE
    0x80800AA4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK74OR"
    VALUE
    0x80800AA6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK74SCB"
    VALUE
    0x80800AA8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK74SCB"
    VALUE
    0x80800AAA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK74SCG"
    VALUE
    0x80800AAC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK74SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK74SCG"
    VALUE
    0x80800AAE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK75OR"
    VALUE
    0x80800AB0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK75OR"
    VALUE
    0x80800AB2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK75SCB"
    VALUE
    0x80800AB4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK75SCB"
    VALUE
    0x80800AB6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK75SCG"
    VALUE
    0x80800AB8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK75SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK75SCG"
    VALUE
    0x80800ABA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK76OR"
    VALUE
    0x80800ABC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK76OR"
    VALUE
    0x80800ABE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK76SCB"
    VALUE
    0x80800AC0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK76SCB"
    VALUE
    0x80800AC2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK76SCG"
    VALUE
    0x80800AC4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK76SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK76SCG"
    VALUE
    0x80800AC6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK77OR"
    VALUE
    0x80800AC8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK77OR"
    VALUE
    0x80800ACA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK77SCB"
    VALUE
    0x80800ACC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK77SCB"
    VALUE
    0x80800ACE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK77SCG"
    VALUE
    0x80800AD0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK77SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK77SCG"
    VALUE
    0x80800AD2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK78OR"
    VALUE
    0x80800AD4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK78OR"
    VALUE
    0x80800AD6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK78SCB"
    VALUE
    0x80800AD8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK78SCB"
    VALUE
    0x80800ADA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_inK78SCG"
    VALUE
    0x80800ADC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrIn_tiK78SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_inK78SCG"
    VALUE
    0x80800ADE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK07OL"
    VALUE
    0x80800AE0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK07OL"
    VALUE
    0x80800AE2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK07OR"
    VALUE
    0x80800AE4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK07OR"
    VALUE
    0x80800AE6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK07OT"
    VALUE
    0x80800AE8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK07OT"
    VALUE
    0x80800AEA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK07SCB"
    VALUE
    0x80800AEC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK07SCB"
    VALUE
    0x80800AEE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK07SCG"
    VALUE
    0x80800AF0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK07SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK07SCG"
    VALUE
    0x80800AF2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK08OL"
    VALUE
    0x80800AF4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK08OL"
    VALUE
    0x80800AF6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK08OR"
    VALUE
    0x80800AF8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK08OR"
    VALUE
    0x80800AFA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK08OT"
    VALUE
    0x80800AFC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK08OT"
    VALUE
    0x80800AFE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK08SCB"
    VALUE
    0x80800B00
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK08SCB"
    VALUE
    0x80800B02
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK08SCG"
    VALUE
    0x80800B04
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK08SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK08SCG"
    VALUE
    0x80800B06
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK09OL"
    VALUE
    0x80800B08
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK09OL"
    VALUE
    0x80800B0A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK09OR"
    VALUE
    0x80800B0C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK09OR"
    VALUE
    0x80800B0E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK09OT"
    VALUE
    0x80800B10
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK09OT"
    VALUE
    0x80800B12
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK09SCB"
    VALUE
    0x80800B14
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK09SCB"
    VALUE
    0x80800B16
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK09SCG"
    VALUE
    0x80800B18
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK09SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK09SCG"
    VALUE
    0x80800B1A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK12OL"
    VALUE
    0x80800B1C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK12OL"
    VALUE
    0x80800B1E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK12OT"
    VALUE
    0x80800B20
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK12OT"
    VALUE
    0x80800B22
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK12SCB"
    VALUE
    0x80800B24
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK12SCB"
    VALUE
    0x80800B26
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK12SCG"
    VALUE
    0x80800B28
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK12SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK12SCG"
    VALUE
    0x80800B2A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK13OL"
    VALUE
    0x80800B2C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK13OL"
    VALUE
    0x80800B2E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK13OT"
    VALUE
    0x80800B30
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK13OT"
    VALUE
    0x80800B32
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK13SCB"
    VALUE
    0x80800B34
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK13SCB"
    VALUE
    0x80800B36
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK13SCG"
    VALUE
    0x80800B38
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK13SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK13SCG"
    VALUE
    0x80800B3A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK14OL"
    VALUE
    0x80800B3C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK14OL"
    VALUE
    0x80800B3E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK14OT"
    VALUE
    0x80800B40
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK14OT"
    VALUE
    0x80800B42
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK14SCB"
    VALUE
    0x80800B44
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK14SCB"
    VALUE
    0x80800B46
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK14SCG"
    VALUE
    0x80800B48
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK14SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK14SCG"
    VALUE
    0x80800B4A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK15OL"
    VALUE
    0x80800B4C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK15OL"
    VALUE
    0x80800B4E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK15OT"
    VALUE
    0x80800B50
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK15OT"
    VALUE
    0x80800B52
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK15SCB"
    VALUE
    0x80800B54
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK15SCB"
    VALUE
    0x80800B56
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK15SCG"
    VALUE
    0x80800B58
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK15SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK15SCG"
    VALUE
    0x80800B5A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK16OL"
    VALUE
    0x80800B5C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK16OL"
    VALUE
    0x80800B5E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK16OT"
    VALUE
    0x80800B60
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK16OT"
    VALUE
    0x80800B62
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK16SCB"
    VALUE
    0x80800B64
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK16SCB"
    VALUE
    0x80800B66
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK16SCG"
    VALUE
    0x80800B68
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK16SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK16SCG"
    VALUE
    0x80800B6A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK25OR"
    VALUE
    0x80800B6C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK25OR"
    VALUE
    0x80800B6E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK25SCB"
    VALUE
    0x80800B70
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK25SCB"
    VALUE
    0x80800B72
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK25SCG"
    VALUE
    0x80800B74
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK25SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK25SCG"
    VALUE
    0x80800B76
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK29OL"
    VALUE
    0x80800B78
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK29OL"
    VALUE
    0x80800B7A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK29OR"
    VALUE
    0x80800B7C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK29OR"
    VALUE
    0x80800B7E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK29OT"
    VALUE
    0x80800B80
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK29OT"
    VALUE
    0x80800B82
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK29SCB"
    VALUE
    0x80800B84
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK29SCB"
    VALUE
    0x80800B86
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK29SCG"
    VALUE
    0x80800B88
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK29SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK29SCG"
    VALUE
    0x80800B8A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK51OL"
    VALUE
    0x80800B8C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK51OL"
    VALUE
    0x80800B8E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK51OT"
    VALUE
    0x80800B90
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK51OT"
    VALUE
    0x80800B92
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK51SCB"
    VALUE
    0x80800B94
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK51SCB"
    VALUE
    0x80800B96
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK51SCG"
    VALUE
    0x80800B98
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK51SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK51SCG"
    VALUE
    0x80800B9A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK62OR"
    VALUE
    0x80800B9C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK62OR"
    VALUE
    0x80800B9E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK62SCB"
    VALUE
    0x80800BA0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK62SCB"
    VALUE
    0x80800BA2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK62SCG"
    VALUE
    0x80800BA4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK62SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK62SCG"
    VALUE
    0x80800BA6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK73OL"
    VALUE
    0x80800BA8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK73OL"
    VALUE
    0x80800BAA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73ORDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK73OR"
    VALUE
    0x80800BAC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73ORDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK73OR"
    VALUE
    0x80800BAE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK73OT"
    VALUE
    0x80800BB0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK73OT"
    VALUE
    0x80800BB2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK73SCB"
    VALUE
    0x80800BB4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK73SCB"
    VALUE
    0x80800BB6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK73SCG"
    VALUE
    0x80800BB8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK73SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK73SCG"
    VALUE
    0x80800BBA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK80OL"
    VALUE
    0x80800BBC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK80OL"
    VALUE
    0x80800BBE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK80OT"
    VALUE
    0x80800BC0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK80OT"
    VALUE
    0x80800BC2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK80SCB"
    VALUE
    0x80800BC4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK80SCB"
    VALUE
    0x80800BC6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK80SCG"
    VALUE
    0x80800BC8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK80SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK80SCG"
    VALUE
    0x80800BCA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK81OL"
    VALUE
    0x80800BCC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK81OL"
    VALUE
    0x80800BCE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK81OT"
    VALUE
    0x80800BD0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK81OT"
    VALUE
    0x80800BD2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK81SCB"
    VALUE
    0x80800BD4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK81SCB"
    VALUE
    0x80800BD6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK81SCG"
    VALUE
    0x80800BD8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK81SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK81SCG"
    VALUE
    0x80800BDA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK82OL"
    VALUE
    0x80800BDC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK82OL"
    VALUE
    0x80800BDE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK82OT"
    VALUE
    0x80800BE0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK82OT"
    VALUE
    0x80800BE2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK82SCB"
    VALUE
    0x80800BE4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK82SCB"
    VALUE
    0x80800BE6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK82SCG"
    VALUE
    0x80800BE8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK82SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK82SCG"
    VALUE
    0x80800BEA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK83OL"
    VALUE
    0x80800BEC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK83OL"
    VALUE
    0x80800BEE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK83OT"
    VALUE
    0x80800BF0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK83OT"
    VALUE
    0x80800BF2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK83SCB"
    VALUE
    0x80800BF4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK83SCB"
    VALUE
    0x80800BF6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK83SCG"
    VALUE
    0x80800BF8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK83SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK83SCG"
    VALUE
    0x80800BFA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK84OL"
    VALUE
    0x80800BFC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK84OL"
    VALUE
    0x80800BFE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK84OT"
    VALUE
    0x80800C00
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK84OT"
    VALUE
    0x80800C02
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK84SCB"
    VALUE
    0x80800C04
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK84SCB"
    VALUE
    0x80800C06
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK84SCG"
    VALUE
    0x80800C08
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK84SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK84SCG"
    VALUE
    0x80800C0A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK85OL"
    VALUE
    0x80800C0C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK85OL"
    VALUE
    0x80800C0E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK85OT"
    VALUE
    0x80800C10
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK85OT"
    VALUE
    0x80800C12
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK85SCB"
    VALUE
    0x80800C14
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK85SCB"
    VALUE
    0x80800C16
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK85SCG"
    VALUE
    0x80800C18
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK85SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK85SCG"
    VALUE
    0x80800C1A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK86OL"
    VALUE
    0x80800C1C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK86OL"
    VALUE
    0x80800C1E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK86OT"
    VALUE
    0x80800C20
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK86OT"
    VALUE
    0x80800C22
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK86SCB"
    VALUE
    0x80800C24
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK86SCB"
    VALUE
    0x80800C26
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK86SCG"
    VALUE
    0x80800C28
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK86SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK86SCG"
    VALUE
    0x80800C2A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87OLDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK87OL"
    VALUE
    0x80800C2C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87OLDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK87OL"
    VALUE
    0x80800C2E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87OTDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK87OT"
    VALUE
    0x80800C30
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87OTDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK87OT"
    VALUE
    0x80800C32
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87SCBDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK87SCB"
    VALUE
    0x80800C34
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87SCBDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK87SCB"
    VALUE
    0x80800C36
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87SCGDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outK87SCG"
    VALUE
    0x80800C38
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbrOut_tiK87SCGDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outK87SCG"
    VALUE
    0x80800C3A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_DvUBAT_FWsDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80800C3C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_DvUBAT_FWsDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80800C3E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OVErr_VPR6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80800C40
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OVErr_VPR6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80800C42
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OVWarn_VPR6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80800C44
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OVWarn_VPR6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80800C46
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800C48
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800C4A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBAT_MONDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80800C4C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBAT_MONDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80800C4E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_FLEXINDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80800C50
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_FLEXINDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80800C52
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_LOADSDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80800C54
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_LOADSDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80800C56
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_MONDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80800C58
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_UBRM24_MONDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80800C5A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VDD5DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80800C5C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VDD5DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80800C5E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VDD5_INDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80800C60
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VDD5_INDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80800C62
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VPR6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80800C64
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VPR6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80800C66
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VSS3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80800C68
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VSS3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80800C6A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VSS4DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80800C6C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_OV_VSS4DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80800C6E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp1_HTErrDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80800C70
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp1_HTErrDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80800C72
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp1_HTWarnDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80800C74
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp1_HTWarnDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80800C76
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp2_HTErrDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80800C78
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp2_HTErrDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80800C7A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp2_HTWarnDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80800C7C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_Temp2_HTWarnDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80800C7E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800C80
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800C82
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VDD5DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80800C84
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VDD5DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80800C86
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VDD5_INDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80800C88
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VDD5_INDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80800C8A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VPR6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80800C8C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VPR6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80800C8E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VSS3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80800C90
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VSS3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80800C92
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VSS4DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80800C94
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.rbr_mo_UV_VSS4DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80800C96
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c7DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80800C98
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c7DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80800C9A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c8DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80c8"
    VALUE
    0x80800C9C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c8DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80c8"
    VALUE
    0x80800C9E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c9DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80c9"
    VALUE
    0x80800CA0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80c9DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80c9"
    VALUE
    0x80800CA2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80caDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ca"
    VALUE
    0x80800CA4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80caDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ca"
    VALUE
    0x80800CA6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80cbDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80cb"
    VALUE
    0x80800CA8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80cbDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80cb"
    VALUE
    0x80800CAA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ccDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80cc"
    VALUE
    0x80800CAC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ccDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80cc"
    VALUE
    0x80800CAE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80cdDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80cd"
    VALUE
    0x80800CB0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80cdDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80cd"
    VALUE
    0x80800CB2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ceDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ce"
    VALUE
    0x80800CB4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ceDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ce"
    VALUE
    0x80800CB6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80cfDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80cf"
    VALUE
    0x80800CB8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80cfDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80cf"
    VALUE
    0x80800CBA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d0DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80d0"
    VALUE
    0x80800CBC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d0DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80d0"
    VALUE
    0x80800CBE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d1DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80d1"
    VALUE
    0x80800CC0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d1DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80d1"
    VALUE
    0x80800CC2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d2DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80800CC4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d2DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80800CC6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80800CC8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80800CCA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d4DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80800CCC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d4DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80800CCE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d5DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80800CD0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d5DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80800CD2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80800CD4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80800CD6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d7DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80d7"
    VALUE
    0x80800CD8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d7DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80d7"
    VALUE
    0x80800CDA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d8DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80d8"
    VALUE
    0x80800CDC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d8DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80d8"
    VALUE
    0x80800CDE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d9DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80d9"
    VALUE
    0x80800CE0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80d9DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80d9"
    VALUE
    0x80800CE2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80daDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80da"
    VALUE
    0x80800CE4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80daDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80da"
    VALUE
    0x80800CE6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80dbDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80db"
    VALUE
    0x80800CE8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80dbDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80db"
    VALUE
    0x80800CEA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80dcDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80dc"
    VALUE
    0x80800CEC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80dcDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80dc"
    VALUE
    0x80800CEE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ddDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80dd"
    VALUE
    0x80800CF0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ddDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80dd"
    VALUE
    0x80800CF2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80deDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80de"
    VALUE
    0x80800CF4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80deDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80de"
    VALUE
    0x80800CF6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80dfDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80df"
    VALUE
    0x80800CF8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80dfDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80df"
    VALUE
    0x80800CFA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e0DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80e0"
    VALUE
    0x80800CFC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e0DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80e0"
    VALUE
    0x80800CFE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e1DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80e1"
    VALUE
    0x80800D00
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e1DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80e1"
    VALUE
    0x80800D02
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e2DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80800D04
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e2DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80800D06
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80800D08
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80800D0A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e4DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80800D0C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e4DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80800D0E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e5DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80800D10
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e5DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80800D12
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80800D14
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80800D16
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e7DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80e7"
    VALUE
    0x80800D18
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e7DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80e7"
    VALUE
    0x80800D1A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e8DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80e8"
    VALUE
    0x80800D1C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e8DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80e8"
    VALUE
    0x80800D1E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e9DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80e9"
    VALUE
    0x80800D20
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80e9DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80e9"
    VALUE
    0x80800D22
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80eaDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ea"
    VALUE
    0x80800D24
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80eaDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ea"
    VALUE
    0x80800D26
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ebDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80eb"
    VALUE
    0x80800D28
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ebDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80eb"
    VALUE
    0x80800D2A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ecDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ec"
    VALUE
    0x80800D2C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ecDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ec"
    VALUE
    0x80800D2E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80edDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ed"
    VALUE
    0x80800D30
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80edDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ed"
    VALUE
    0x80800D32
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80eeDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ee"
    VALUE
    0x80800D34
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80eeDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ee"
    VALUE
    0x80800D36
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80efDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ef"
    VALUE
    0x80800D38
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80efDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ef"
    VALUE
    0x80800D3A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f0DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80f0"
    VALUE
    0x80800D3C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f0DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80f0"
    VALUE
    0x80800D3E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f1DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80f1"
    VALUE
    0x80800D40
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f1DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80f1"
    VALUE
    0x80800D42
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f2DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80800D44
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f2DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80800D46
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80800D48
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80800D4A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f4DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80800D4C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f4DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80800D4E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f5DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80800D50
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f5DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80800D52
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f6DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80f6"
    VALUE
    0x80800D54
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f6DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80f6"
    VALUE
    0x80800D56
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f7DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80f7"
    VALUE
    0x80800D58
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f7DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80f7"
    VALUE
    0x80800D5A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f8DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80f8"
    VALUE
    0x80800D5C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f8DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80f8"
    VALUE
    0x80800D5E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f9DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80f9"
    VALUE
    0x80800D60
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80f9DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80f9"
    VALUE
    0x80800D62
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80faDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80fa"
    VALUE
    0x80800D64
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80faDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80fa"
    VALUE
    0x80800D66
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80fbDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80fb"
    VALUE
    0x80800D68
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80fbDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80fb"
    VALUE
    0x80800D6A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80fcDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80fc"
    VALUE
    0x80800D6C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80fcDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80fc"
    VALUE
    0x80800D6E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80fdDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80fd"
    VALUE
    0x80800D70
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80fdDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80fd"
    VALUE
    0x80800D72
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80feDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80fe"
    VALUE
    0x80800D74
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80feDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80fe"
    VALUE
    0x80800D76
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ffDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x80ff"
    VALUE
    0x80800D78
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x80ffDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x80ff"
    VALUE
    0x80800D7A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8100DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8100"
    VALUE
    0x80800D7C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8100DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8100"
    VALUE
    0x80800D7E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8101DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8101"
    VALUE
    0x80800D80
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8101DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8101"
    VALUE
    0x80800D82
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8102DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8102"
    VALUE
    0x80800D84
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8102DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8102"
    VALUE
    0x80800D86
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8103DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8103"
    VALUE
    0x80800D88
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8103DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8103"
    VALUE
    0x80800D8A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8104DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8104"
    VALUE
    0x80800D8C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8104DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8104"
    VALUE
    0x80800D8E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8105DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8105"
    VALUE
    0x80800D90
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8105DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8105"
    VALUE
    0x80800D92
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8106DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8106"
    VALUE
    0x80800D94
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8106DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8106"
    VALUE
    0x80800D96
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8107DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8107"
    VALUE
    0x80800D98
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8107DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8107"
    VALUE
    0x80800D9A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8108DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8108"
    VALUE
    0x80800D9C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8108DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8108"
    VALUE
    0x80800D9E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8109DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8109"
    VALUE
    0x80800DA0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8109DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8109"
    VALUE
    0x80800DA2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810aDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x810a"
    VALUE
    0x80800DA4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810aDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x810a"
    VALUE
    0x80800DA6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810bDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x810b"
    VALUE
    0x80800DA8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810bDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x810b"
    VALUE
    0x80800DAA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810cDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x810c"
    VALUE
    0x80800DAC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810cDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x810c"
    VALUE
    0x80800DAE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810dDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x810d"
    VALUE
    0x80800DB0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810dDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x810d"
    VALUE
    0x80800DB2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810eDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x810e"
    VALUE
    0x80800DB4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810eDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x810e"
    VALUE
    0x80800DB6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810fDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x810f"
    VALUE
    0x80800DB8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x810fDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x810f"
    VALUE
    0x80800DBA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8110DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8110"
    VALUE
    0x80800DBC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8110DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8110"
    VALUE
    0x80800DBE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8111DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8111"
    VALUE
    0x80800DC0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8111DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8111"
    VALUE
    0x80800DC2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8112DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8112"
    VALUE
    0x80800DC4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8112DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8112"
    VALUE
    0x80800DC6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8113DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8113"
    VALUE
    0x80800DC8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8113DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8113"
    VALUE
    0x80800DCA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8114DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8114"
    VALUE
    0x80800DCC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8114DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8114"
    VALUE
    0x80800DCE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8115DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8115"
    VALUE
    0x80800DD0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8115DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8115"
    VALUE
    0x80800DD2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8116DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8116"
    VALUE
    0x80800DD4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8116DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8116"
    VALUE
    0x80800DD6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8117DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8117"
    VALUE
    0x80800DD8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8117DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8117"
    VALUE
    0x80800DDA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8118DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8118"
    VALUE
    0x80800DDC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8118DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8118"
    VALUE
    0x80800DDE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8119DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8119"
    VALUE
    0x80800DE0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8119DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8119"
    VALUE
    0x80800DE2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811aDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x811a"
    VALUE
    0x80800DE4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811aDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x811a"
    VALUE
    0x80800DE6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811bDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x811b"
    VALUE
    0x80800DE8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811bDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x811b"
    VALUE
    0x80800DEA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811cDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x811c"
    VALUE
    0x80800DEC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811cDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x811c"
    VALUE
    0x80800DEE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811dDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x811d"
    VALUE
    0x80800DF0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811dDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x811d"
    VALUE
    0x80800DF2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811eDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x811e"
    VALUE
    0x80800DF4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811eDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x811e"
    VALUE
    0x80800DF6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811fDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x811f"
    VALUE
    0x80800DF8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x811fDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x811f"
    VALUE
    0x80800DFA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8120DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8120"
    VALUE
    0x80800DFC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8120DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8120"
    VALUE
    0x80800DFE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8121DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8121"
    VALUE
    0x80800E00
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8121DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8121"
    VALUE
    0x80800E02
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8122DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8122"
    VALUE
    0x80800E04
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8122DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8122"
    VALUE
    0x80800E06
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8123DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8123"
    VALUE
    0x80800E08
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8123DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8123"
    VALUE
    0x80800E0A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8124DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8124"
    VALUE
    0x80800E0C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8124DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8124"
    VALUE
    0x80800E0E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8125DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8125"
    VALUE
    0x80800E10
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8125DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8125"
    VALUE
    0x80800E12
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8126DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8126"
    VALUE
    0x80800E14
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8126DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8126"
    VALUE
    0x80800E16
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8127DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8127"
    VALUE
    0x80800E18
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8127DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8127"
    VALUE
    0x80800E1A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8128DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8128"
    VALUE
    0x80800E1C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8128DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8128"
    VALUE
    0x80800E1E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8129DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x8129"
    VALUE
    0x80800E20
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x8129DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x8129"
    VALUE
    0x80800E22
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x812aDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_NoDeb0x812a"
    VALUE
    0x80800E24
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_NoDeb0x812aDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_NoDeb0x812a"
    VALUE
    0x80800E26
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiInRow0x8B01DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_TiInRow0x8B01"
    VALUE
    0x80800E28
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiInRow0x8B01DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_TiInRow0x8B01"
    VALUE
    0x80800E2A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiInRow0x8B02DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_TiInRow0x8B02"
    VALUE
    0x80800E2C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiInRow0x8B02DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_TiInRow0x8B02"
    VALUE
    0x80800E2E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiInRow0x8B03DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_bds_TiInRow0x8B03"
    VALUE
    0x80800E30
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.cal_TiInRow0x8B03DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_bds_TiInRow0x8B03"
    VALUE
    0x80800E32
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80802FB0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80802FB1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA01OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA01OL"
    VALUE
    0x80802FB2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA01OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA01OT"
    VALUE
    0x80802FB3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA01SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA01SCB"
    VALUE
    0x80802FB4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA01SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA01SCG"
    VALUE
    0x80802FB5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA02OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA02OL"
    VALUE
    0x80802FB6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA02OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA02OR"
    VALUE
    0x80802FB7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA02OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA02OT"
    VALUE
    0x80802FB8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA02SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA02SCB"
    VALUE
    0x80802FB9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA02SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA02SCG"
    VALUE
    0x80802FBA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA03OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA03OL"
    VALUE
    0x80802FBB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA03OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA03OT"
    VALUE
    0x80802FBC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA03SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA03SCB"
    VALUE
    0x80802FBD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA03SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA03SCG"
    VALUE
    0x80802FBE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA04OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA04OL"
    VALUE
    0x80802FBF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA04OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA04OT"
    VALUE
    0x80802FC0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA04SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA04SCB"
    VALUE
    0x80802FC1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA04SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA04SCG"
    VALUE
    0x80802FC2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA05OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA05OL"
    VALUE
    0x80802FC3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA05OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA05OR"
    VALUE
    0x80802FC4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA05OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA05OT"
    VALUE
    0x80802FC5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA05SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA05SCB"
    VALUE
    0x80802FC6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA05SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA05SCG"
    VALUE
    0x80802FC7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA06OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA06OL"
    VALUE
    0x80802FC8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA06OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA06OR"
    VALUE
    0x80802FC9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA06OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA06OT"
    VALUE
    0x80802FCA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA06SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA06SCB"
    VALUE
    0x80802FCB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA06SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA06SCG"
    VALUE
    0x80802FCC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA07OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA07OL"
    VALUE
    0x80802FCD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA07OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA07OT"
    VALUE
    0x80802FCE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA07SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA07SCB"
    VALUE
    0x80802FCF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA07SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA07SCG"
    VALUE
    0x80802FD0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA08OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA08OL"
    VALUE
    0x80802FD1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA08OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA08OT"
    VALUE
    0x80802FD2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA08SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA08SCB"
    VALUE
    0x80802FD3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA08SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA08SCG"
    VALUE
    0x80802FD4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA09OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA09OL"
    VALUE
    0x80802FD5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA09OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA09OR"
    VALUE
    0x80802FD6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA09OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA09OT"
    VALUE
    0x80802FD7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA09SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA09SCB"
    VALUE
    0x80802FD8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA09SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA09SCG"
    VALUE
    0x80802FD9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA10OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA10OL"
    VALUE
    0x80802FDA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA10OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA10OT"
    VALUE
    0x80802FDB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA10SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA10SCB"
    VALUE
    0x80802FDC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA10SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA10SCG"
    VALUE
    0x80802FDD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA11OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA11OL"
    VALUE
    0x80802FDE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA11OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA11OT"
    VALUE
    0x80802FDF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA11SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA11SCB"
    VALUE
    0x80802FE0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA11SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA11SCG"
    VALUE
    0x80802FE1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA12OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA12OR"
    VALUE
    0x80802FE2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA12SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA12SCB"
    VALUE
    0x80802FE3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA12SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA12SCG"
    VALUE
    0x80802FE4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA16OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA16OL"
    VALUE
    0x80802FE5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA16OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA16OT"
    VALUE
    0x80802FE6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA16SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA16SCB"
    VALUE
    0x80802FE7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA16SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA16SCG"
    VALUE
    0x80802FE8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA17OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA17OL"
    VALUE
    0x80802FE9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA17OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA17OR"
    VALUE
    0x80802FEA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA17OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA17OT"
    VALUE
    0x80802FEB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA17SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA17SCB"
    VALUE
    0x80802FEC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA17SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA17SCG"
    VALUE
    0x80802FED
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA18OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA18OL"
    VALUE
    0x80802FEE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA18OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA18OT"
    VALUE
    0x80802FEF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA18SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA18SCB"
    VALUE
    0x80802FF0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA18SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA18SCG"
    VALUE
    0x80802FF1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA19OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA19OL"
    VALUE
    0x80802FF2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA19OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA19OR"
    VALUE
    0x80802FF3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA19OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA19OT"
    VALUE
    0x80802FF4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA19SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA19SCB"
    VALUE
    0x80802FF5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA19SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA19SCG"
    VALUE
    0x80802FF6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA20OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA20OL"
    VALUE
    0x80802FF7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA20OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA20OR"
    VALUE
    0x80802FF8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA20OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA20OT"
    VALUE
    0x80802FF9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA20SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA20SCB"
    VALUE
    0x80802FFA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA20SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA20SCG"
    VALUE
    0x80802FFB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA31OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA31OL"
    VALUE
    0x80802FFC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA31OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA31OR"
    VALUE
    0x80802FFD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA31OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA31OT"
    VALUE
    0x80802FFE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA31SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA31SCB"
    VALUE
    0x80802FFF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA31SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA31SCG"
    VALUE
    0x80803000
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA32OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA32OL"
    VALUE
    0x80803001
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA32OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA32OR"
    VALUE
    0x80803002
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA32OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA32OT"
    VALUE
    0x80803003
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA32SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA32SCB"
    VALUE
    0x80803004
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA32SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA32SCG"
    VALUE
    0x80803005
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA33OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA33OL"
    VALUE
    0x80803006
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA33OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA33OR"
    VALUE
    0x80803007
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA33OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA33OT"
    VALUE
    0x80803008
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA33SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA33SCB"
    VALUE
    0x80803009
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA33SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA33SCG"
    VALUE
    0x8080300A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA34OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA34OL"
    VALUE
    0x8080300B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA34OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA34OR"
    VALUE
    0x8080300C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA34OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA34OT"
    VALUE
    0x8080300D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA34SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA34SCB"
    VALUE
    0x8080300E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA34SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA34SCG"
    VALUE
    0x8080300F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA35OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA35OL"
    VALUE
    0x80803010
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA35OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA35OR"
    VALUE
    0x80803011
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA35OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA35OT"
    VALUE
    0x80803012
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA35SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA35SCB"
    VALUE
    0x80803013
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA35SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA35SCG"
    VALUE
    0x80803014
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA46OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA46OL"
    VALUE
    0x80803015
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA46OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA46OR"
    VALUE
    0x80803016
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA46OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA46OT"
    VALUE
    0x80803017
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA46SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA46SCB"
    VALUE
    0x80803018
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA46SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA46SCG"
    VALUE
    0x80803019
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA47OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA47OL"
    VALUE
    0x8080301A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA47OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA47OR"
    VALUE
    0x8080301B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA47OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA47OT"
    VALUE
    0x8080301C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA47SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA47SCB"
    VALUE
    0x8080301D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA47SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA47SCG"
    VALUE
    0x8080301E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA48OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA48OL"
    VALUE
    0x8080301F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA48OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA48OR"
    VALUE
    0x80803020
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA48OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA48OT"
    VALUE
    0x80803021
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA48SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA48SCB"
    VALUE
    0x80803022
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA48SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA48SCG"
    VALUE
    0x80803023
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA49OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA49OL"
    VALUE
    0x80803024
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA49OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA49OT"
    VALUE
    0x80803025
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA49SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA49SCB"
    VALUE
    0x80803026
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA49SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA49SCG"
    VALUE
    0x80803027
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA50OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA50OL"
    VALUE
    0x80803028
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA50OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA50OT"
    VALUE
    0x80803029
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA50SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA50SCB"
    VALUE
    0x8080302A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA50SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA50SCG"
    VALUE
    0x8080302B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA51OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA51OL"
    VALUE
    0x8080302C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA51OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA51OR"
    VALUE
    0x8080302D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA51OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA51OT"
    VALUE
    0x8080302E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA51SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA51SCB"
    VALUE
    0x8080302F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA51SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA51SCG"
    VALUE
    0x80803030
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA52OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA52OL"
    VALUE
    0x80803031
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA52OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA52OR"
    VALUE
    0x80803032
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA52OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA52OT"
    VALUE
    0x80803033
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA52SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA52SCB"
    VALUE
    0x80803034
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA52SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA52SCG"
    VALUE
    0x80803035
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA53OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA53OL"
    VALUE
    0x80803036
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA53OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA53OR"
    VALUE
    0x80803037
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA53OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA53OT"
    VALUE
    0x80803038
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA53SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA53SCB"
    VALUE
    0x80803039
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA53SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA53SCG"
    VALUE
    0x8080303A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA54OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA54OL"
    VALUE
    0x8080303B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA54OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA54OR"
    VALUE
    0x8080303C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA54OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA54OT"
    VALUE
    0x8080303D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA54SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA54SCB"
    VALUE
    0x8080303E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA54SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA54SCG"
    VALUE
    0x8080303F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA55OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA55OL"
    VALUE
    0x80803040
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA55OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA55OT"
    VALUE
    0x80803041
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA55SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA55SCB"
    VALUE
    0x80803042
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA55SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA55SCG"
    VALUE
    0x80803043
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA56OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA56OL"
    VALUE
    0x80803044
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA56OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA56OT"
    VALUE
    0x80803045
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA56SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA56SCB"
    VALUE
    0x80803046
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA56SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA56SCG"
    VALUE
    0x80803047
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA58OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA58OL"
    VALUE
    0x80803048
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA58OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA58OT"
    VALUE
    0x80803049
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA58SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA58SCB"
    VALUE
    0x8080304A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outA58SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outA58SCG"
    VALUE
    0x8080304B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK14OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK14OR"
    VALUE
    0x8080304C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK15OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK15OR"
    VALUE
    0x8080304D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK16OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK16OR"
    VALUE
    0x8080304E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK17OL_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK17OL"
    VALUE
    0x8080304F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK17OR_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK17OR"
    VALUE
    0x80803050
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK17OT_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK17OT"
    VALUE
    0x80803051
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK17SCB_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK17SCB"
    VALUE
    0x80803052
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DFC_rbr_outK17SCG_tiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK17SCG"
    VALUE
    0x80803053
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DevLib_tiBattUHiUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_DevLibBattUHi"
    VALUE
    0x80803054
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.DevLib_tiBattULoUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_DevLibBattULo"
    VALUE
    0x80803055
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8063UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8063"
    VALUE
    0x80803056
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8064UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8064"
    VALUE
    0x80803057
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

