/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadApi2Error_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadApi2Error"
    VALUE
    0x808011F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadBlock_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadBlock"
    VALUE
    0x808011F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadCalibInputError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadCalibInputError"
    VALUE
    0x808011F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadCalibOuputError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x808011F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadSystemError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadSystemError"
    VALUE
    0x808011F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memWriteBlock_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memWriteBlock"
    VALUE
    0x808011F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_moOV_FirstConstADC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x808011F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_moOV_SecondConstADC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x808011F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_moUV_FirstConstADC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x808011F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_moUV_SecondConstADC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x808011FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_INH_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_INH"
    VALUE
    0x808011FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_INHLatch_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_INHLatch"
    VALUE
    0x808011FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_adcPDD_fail_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x808011FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_memoryProtection_err_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x808011FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02OC"
    VALUE
    0x808011FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02Unintended"
    VALUE
    0x80801200
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03OC"
    VALUE
    0x80801201
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03Unintended"
    VALUE
    0x80801202
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04OC"
    VALUE
    0x80801203
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04Unintended"
    VALUE
    0x80801204
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05OC"
    VALUE
    0x80801205
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05Unintended"
    VALUE
    0x80801206
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07OC"
    VALUE
    0x80801207
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07Unintended"
    VALUE
    0x80801208
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08OC"
    VALUE
    0x80801209
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08Unintended"
    VALUE
    0x8080120A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09OC"
    VALUE
    0x8080120B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09Unintended"
    VALUE
    0x8080120C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10OC"
    VALUE
    0x8080120D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10Unintended"
    VALUE
    0x8080120E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17OC"
    VALUE
    0x8080120F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17Unintended"
    VALUE
    0x80801210
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18OC"
    VALUE
    0x80801211
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18Unintended"
    VALUE
    0x80801212
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19OC"
    VALUE
    0x80801213
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19Unintended"
    VALUE
    0x80801214
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20OC"
    VALUE
    0x80801215
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20Unintended"
    VALUE
    0x80801216
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31OC"
    VALUE
    0x80801217
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31Unintended"
    VALUE
    0x80801218
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32OC"
    VALUE
    0x80801219
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32Unintended"
    VALUE
    0x8080121A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33OC"
    VALUE
    0x8080121B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33Unintended"
    VALUE
    0x8080121C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34OC"
    VALUE
    0x8080121D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34Unintended"
    VALUE
    0x8080121E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35OC"
    VALUE
    0x8080121F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35Unintended"
    VALUE
    0x80801220
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46OC"
    VALUE
    0x80801221
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46Unintended"
    VALUE
    0x80801222
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47OC"
    VALUE
    0x80801223
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47Unintended"
    VALUE
    0x80801224
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48OC"
    VALUE
    0x80801225
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48Unintended"
    VALUE
    0x80801226
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51OC"
    VALUE
    0x80801227
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51Unintended"
    VALUE
    0x80801228
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52OC"
    VALUE
    0x80801229
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52Unintended"
    VALUE
    0x8080122A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53OC"
    VALUE
    0x8080122B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53Unintended"
    VALUE
    0x8080122C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54OC"
    VALUE
    0x8080122D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54Unintended"
    VALUE
    0x8080122E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAov_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAov"
    VALUE
    0x8080122F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAovCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAovCfg"
    VALUE
    0x80801230
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAovCfgPI_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAovCfgPI"
    VALUE
    0x80801231
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAovGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAovGetStatus"
    VALUE
    0x80801232
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAovGetVoltage_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80801233
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outAovResetError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outAovResetError"
    VALUE
    0x80801234
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDo"
    VALUE
    0x80801235
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDoCfgPwrLs_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80801236
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDoDisable_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDoDisable"
    VALUE
    0x80801237
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDoGetCurrent_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80801238
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDoGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDoGetStatus"
    VALUE
    0x80801239
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outDoResetError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outDoResetError"
    VALUE
    0x8080123A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07OC"
    VALUE
    0x8080123B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07Unintended"
    VALUE
    0x8080123C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08OC"
    VALUE
    0x8080123D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08Unintended"
    VALUE
    0x8080123E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09OC"
    VALUE
    0x8080123F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09Unintended"
    VALUE
    0x80801240
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12OC"
    VALUE
    0x80801241
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12Unintended"
    VALUE
    0x80801242
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13OC"
    VALUE
    0x80801243
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13Unintended"
    VALUE
    0x80801244
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14OC"
    VALUE
    0x80801245
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14Unintended"
    VALUE
    0x80801246
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15OC"
    VALUE
    0x80801247
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15Unintended"
    VALUE
    0x80801248
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16OC"
    VALUE
    0x80801249
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16Unintended"
    VALUE
    0x8080124A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17OC"
    VALUE
    0x8080124B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17Unintended"
    VALUE
    0x8080124C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29OC"
    VALUE
    0x8080124D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29Unintended"
    VALUE
    0x8080124E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51OC"
    VALUE
    0x8080124F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51Unintended"
    VALUE
    0x80801250
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73OC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73OC"
    VALUE
    0x80801251
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73Unintended_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73Unintended"
    VALUE
    0x80801252
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPo"
    VALUE
    0x80801253
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoCfg"
    VALUE
    0x80801254
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoCfgPeriod_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80801255
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoCfgPwrLs_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80801256
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoDisable_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoDisable"
    VALUE
    0x80801257
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoGetCurrent_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80801258
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoGetStatus"
    VALUE
    0x80801259
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoResetError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoResetError"
    VALUE
    0x8080125A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPoc_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPoc"
    VALUE
    0x8080125B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPocCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPocCfg"
    VALUE
    0x8080125C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPocCfgDither_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPocCfgDither"
    VALUE
    0x8080125D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPocCfgPI_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPocCfgPI"
    VALUE
    0x8080125E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPod_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPod"
    VALUE
    0x8080125F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPodCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPodCfg"
    VALUE
    0x80801260
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outPodCfgPeriod_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80801261
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_rsmFfiApiCallErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80801262
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safout_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safout"
    VALUE
    0x80801263
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutCfg"
    VALUE
    0x80801264
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl1_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl1"
    VALUE
    0x80801265
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl10_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl10"
    VALUE
    0x80801266
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl10Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80801267
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl10OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80801268
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl11_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl11"
    VALUE
    0x80801269
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl11Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x8080126A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl11OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl11OR"
    VALUE
    0x8080126B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl12_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl12"
    VALUE
    0x8080126C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl12Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x8080126D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl12OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl12OR"
    VALUE
    0x8080126E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl13_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl13"
    VALUE
    0x8080126F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl13Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80801270
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl13OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80801271
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl14_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl14"
    VALUE
    0x80801272
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl14Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80801273
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl14OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80801274
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl15_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl15"
    VALUE
    0x80801275
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl15Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80801276
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl15OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80801277
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl16_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl16"
    VALUE
    0x80801278
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl16Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80801279
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl16OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl16OR"
    VALUE
    0x8080127A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl17_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl17"
    VALUE
    0x8080127B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl17Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x8080127C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl17OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl17OR"
    VALUE
    0x8080127D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl18_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl18"
    VALUE
    0x8080127E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl18Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x8080127F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl18OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80801280
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl1Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80801281
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl1OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80801282
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl2_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl2"
    VALUE
    0x80801283
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl2Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80801284
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl2OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80801285
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl3_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl3"
    VALUE
    0x80801286
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl3Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x80801287
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl3OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl3OR"
    VALUE
    0x80801288
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl4_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl4"
    VALUE
    0x80801289
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl4Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x8080128A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl4OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl4OR"
    VALUE
    0x8080128B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl5_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl5"
    VALUE
    0x8080128C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl5Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x8080128D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl5OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl5OR"
    VALUE
    0x8080128E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl6_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl6"
    VALUE
    0x8080128F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl6Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80801290
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl6OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80801291
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl7_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl7"
    VALUE
    0x80801292
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl7Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80801293
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl7OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80801294
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl8_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl8"
    VALUE
    0x80801295
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl8Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x80801296
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl8OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl8OR"
    VALUE
    0x80801297
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl9_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl9"
    VALUE
    0x80801298
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl9Dev_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x80801299
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutChnl9OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutChnl9OR"
    VALUE
    0x8080129A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutDevError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutDevError"
    VALUE
    0x8080129B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutGetStatus"
    VALUE
    0x8080129C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutIgnoreError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutIgnoreError"
    VALUE
    0x8080129D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutResetError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutResetError"
    VALUE
    0x8080129E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safoutUnlock_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safoutUnlock"
    VALUE
    0x8080129F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_safout_cfgDiag_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_safout_cfgDiag"
    VALUE
    0x808012A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secAccessDenied_RC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x808012A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secAccessDenied_WDBI_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x808012A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secEvalRespKey_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secEvalRespKey"
    VALUE
    0x808012A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secFlashingFailure_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secFlashingFailure"
    VALUE
    0x808012A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secGetLevel_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secGetLevel"
    VALUE
    0x808012A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secGetRnd_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secGetRnd"
    VALUE
    0x808012A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secGetSeed_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secGetSeed"
    VALUE
    0x808012A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secInvalidPassword_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secInvalidPassword"
    VALUE
    0x808012A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secIsRequestAllowed_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x808012A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secResetLevel_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secResetLevel"
    VALUE
    0x808012AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secSaveSecret_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secSaveSecret"
    VALUE
    0x808012AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_secSetLevel_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_secSetLevel"
    VALUE
    0x808012AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysAit_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysAit"
    VALUE
    0x808012AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysAiv_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysAiv"
    VALUE
    0x808012AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysDi_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysDi"
    VALUE
    0x808012AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysDo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysDo"
    VALUE
    0x808012B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysGetVss_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysGetVss"
    VALUE
    0x808012B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysInit_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysInit"
    VALUE
    0x808012B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysOperHrIntegrityErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x808012B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysOperHrsSaturated_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x808012B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sysSetVss_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sysSetVss"
    VALUE
    0x808012B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sys_coreload_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sys_coreload"
    VALUE
    0x808012B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_sys_taskload_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_sys_taskload"
    VALUE
    0x808012B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VSS1_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x808012B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VSS2_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x808012B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VSS1_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x808012BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VSS2_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x808012BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x808012BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x808012BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x808012BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x808012BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x808012C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_CAN_E_TIMEOUT_C
    "Behaviour control mask / Behaviour control masks of check DFC_CAN_E_TIMEOUT"
    VALUE
    0x808012C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x808012C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x808012C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x808012C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x808012C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x808012C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x808012C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_LIN_E_TIMEOUT_C
    "Behaviour control mask / Behaviour control masks of check DFC_LIN_E_TIMEOUT"
    VALUE
    0x808012C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_MultiStackTrace_Threshold_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x808012C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_ETH_E_ACCESS_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_ETH_E_ACCESS_0"
    VALUE
    0x808012CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "Behaviour control mask / Behaviour control masks of check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x808012CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "Behaviour control mask / Behaviour control masks of check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x808012CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_MRly_Diag_Stk_Event_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x808012CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x808012CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_MemDiag_MemReadErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x808012CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_MemDiag_MemWrErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x808012D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x808012D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_T15_Diag_ComInVld_Event_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x808012D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x808012D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "Behaviour control mask / Behaviour control masks of check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x808012D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x808012D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x808012D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_10_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x808012D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x808012D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x808012D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x808012DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x808012DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_22_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x808012DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_23_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x808012DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x808012DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x808012DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_7_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x808012E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM0_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x808012E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM10_16_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x808012E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM10_17_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x808012E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM10_21_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x808012E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x808012E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x808012E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x808012E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x808012E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x808012E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x808012EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x808012EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM11_9_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x808012EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x808012ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x808012EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_10_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x808012EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x808012F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x808012F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x808012F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x808012F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_22_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x808012F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_23_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x808012F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x808012F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x808012F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_7_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x808012F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM1_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x808012F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM21_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x808012FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM21_16_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x808012FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM21_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x808012FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x808012FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_10_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x808012FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x808012FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80801300
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80801301
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80801302
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_22_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80801303
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_23_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80801304
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80801305
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80801306
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_7_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80801307
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM2_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80801308
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80801309
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_10_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x8080130A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x8080130B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x8080130C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x8080130D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x8080130E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_22_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x8080130F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_23_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80801310
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80801311
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80801312
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_7_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80801313
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM3_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80801314
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80801315
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80801316
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_12_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80801317
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80801318
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_15_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80801319
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_17_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x8080131A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_18_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x8080131B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x8080131C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_20_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x8080131D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_21_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x8080131E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_25_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x8080131F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80801320
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_5_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80801321
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_7_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80801322
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM6_8_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80801323
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80801324
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_12_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80801325
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80801326
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_14_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80801327
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_15_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80801328
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_16_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80801329
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_17_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x8080132A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x8080132B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_20_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x8080132C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_25_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x8080132D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_26_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x8080132E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_28_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x8080132F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_29_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80801330
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_30_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80801331
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM7_31_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80801332
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80801333
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80801334
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_10_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80801335
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_11_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80801336
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_12_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80801337
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_13_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80801338
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_16_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80801339
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_18_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x8080133A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x8080133B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x8080133C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_30_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x8080133D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_31_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x8080133E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM8_4_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x8080133F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM9_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80801340
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM9_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80801341
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM9_15_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80801342
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MOXEMM_SMU_ALM9_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80801343
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoCSOPICO_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoCSOPICO"
    VALUE
    0x80801344
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoFVarPostBldSel_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoFVarPostBldSel"
    VALUE
    0x80801345
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoSysCtrlReIni_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoSysCtrlReIni"
    VALUE
    0x80801346
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTMCUFW_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80801347
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTMonBIST_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80801348
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTRegMonTest_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80801349
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x8080134A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTTempSens_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x8080134B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_MoXEMMHwLTUCBCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x8080134C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_OCWDAABEActv_C
    "Behaviour control mask / Behaviour control masks of check DFC_OCWDAABEActv"
    VALUE
    0x8080134D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_OCWDACom_C
    "Behaviour control mask / Behaviour control masks of check DFC_OCWDACom"
    VALUE
    0x8080134E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_OCWDAErrPin_C
    "Behaviour control mask / Behaviour control masks of check DFC_OCWDAErrPin"
    VALUE
    0x8080134F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_SWReset_0_C
    "Behaviour control mask / Behaviour control masks of check DFC_SWReset_0"
    VALUE
    0x80801350
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_SWReset_1_C
    "Behaviour control mask / Behaviour control masks of check DFC_SWReset_1"
    VALUE
    0x80801351
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_SWReset_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_SWReset_2"
    VALUE
    0x80801352
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_Unused_C
    "disable mask / "
    VALUE
    0x80803218
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80c7_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80803219
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80c8_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80c8"
    VALUE
    0x8080321A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80c9_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80c9"
    VALUE
    0x8080321B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ca_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ca"
    VALUE
    0x8080321C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80cb_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80cb"
    VALUE
    0x8080321D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80cc_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80cc"
    VALUE
    0x8080321E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80cd_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80cd"
    VALUE
    0x8080321F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ce_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ce"
    VALUE
    0x80803220
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80cf_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80cf"
    VALUE
    0x80803221
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80d0_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80d0"
    VALUE
    0x80803222
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80d1_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80d1"
    VALUE
    0x80803223
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80d2_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80803224
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80d3_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80803225
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80d4_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80803226
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80d5_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80803227
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80d6_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80803228
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80d7_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80d7"
    VALUE
    0x80803229
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80d8_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80d8"
    VALUE
    0x8080322A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80d9_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80d9"
    VALUE
    0x8080322B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80da_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80da"
    VALUE
    0x8080322C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80db_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80db"
    VALUE
    0x8080322D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80dc_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80dc"
    VALUE
    0x8080322E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80dd_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80dd"
    VALUE
    0x8080322F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80de_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80de"
    VALUE
    0x80803230
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80df_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80df"
    VALUE
    0x80803231
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80e0_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80e0"
    VALUE
    0x80803232
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80e1_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80e1"
    VALUE
    0x80803233
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80e2_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80803234
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80e3_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80803235
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80e4_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80803236
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80e5_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80803237
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80e6_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80803238
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80e7_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80e7"
    VALUE
    0x80803239
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80e8_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80e8"
    VALUE
    0x8080323A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80e9_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80e9"
    VALUE
    0x8080323B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ea_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ea"
    VALUE
    0x8080323C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80eb_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80eb"
    VALUE
    0x8080323D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ec_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ec"
    VALUE
    0x8080323E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ed_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ed"
    VALUE
    0x8080323F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ee_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ee"
    VALUE
    0x80803240
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ef_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ef"
    VALUE
    0x80803241
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80f0_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80f0"
    VALUE
    0x80803242
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80f1_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80f1"
    VALUE
    0x80803243
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80f2_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80803244
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80f3_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80803245
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80f4_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80803246
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80f5_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80803247
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80f6_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80f6"
    VALUE
    0x80803248
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80f7_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80f7"
    VALUE
    0x80803249
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80f8_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80f8"
    VALUE
    0x8080324A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80f9_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80f9"
    VALUE
    0x8080324B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80fa_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80fa"
    VALUE
    0x8080324C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80fb_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80fb"
    VALUE
    0x8080324D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80fc_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80fc"
    VALUE
    0x8080324E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80fd_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80fd"
    VALUE
    0x8080324F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80fe_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80fe"
    VALUE
    0x80803250
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ff_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ff"
    VALUE
    0x80803251
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8100_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8100"
    VALUE
    0x80803252
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8101_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8101"
    VALUE
    0x80803253
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8102_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8102"
    VALUE
    0x80803254
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8103_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8103"
    VALUE
    0x80803255
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8104_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8104"
    VALUE
    0x80803256
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8105_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8105"
    VALUE
    0x80803257
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8106_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8106"
    VALUE
    0x80803258
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8107_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8107"
    VALUE
    0x80803259
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8108_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8108"
    VALUE
    0x8080325A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8109_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8109"
    VALUE
    0x8080325B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x810a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x810a"
    VALUE
    0x8080325C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x810b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x810b"
    VALUE
    0x8080325D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x810c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x810c"
    VALUE
    0x8080325E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x810d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x810d"
    VALUE
    0x8080325F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x810e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x810e"
    VALUE
    0x80803260
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x810f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x810f"
    VALUE
    0x80803261
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8110_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8110"
    VALUE
    0x80803262
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8111_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8111"
    VALUE
    0x80803263
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8112_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8112"
    VALUE
    0x80803264
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8113_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8113"
    VALUE
    0x80803265
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8114_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8114"
    VALUE
    0x80803266
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8115_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8115"
    VALUE
    0x80803267
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8116_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8116"
    VALUE
    0x80803268
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8117_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8117"
    VALUE
    0x80803269
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8118_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8118"
    VALUE
    0x8080326A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8119_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8119"
    VALUE
    0x8080326B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x811a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x811a"
    VALUE
    0x8080326C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x811b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x811b"
    VALUE
    0x8080326D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x811c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x811c"
    VALUE
    0x8080326E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x811d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x811d"
    VALUE
    0x8080326F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x811e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x811e"
    VALUE
    0x80803270
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x811f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x811f"
    VALUE
    0x80803271
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8120_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8120"
    VALUE
    0x80803272
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8121_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8121"
    VALUE
    0x80803273
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8122_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8122"
    VALUE
    0x80803274
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8123_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8123"
    VALUE
    0x80803275
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8124_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8124"
    VALUE
    0x80803276
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8125_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8125"
    VALUE
    0x80803277
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8126_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8126"
    VALUE
    0x80803278
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8127_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8127"
    VALUE
    0x80803279
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8128_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8128"
    VALUE
    0x8080327A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8129_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8129"
    VALUE
    0x8080327B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x812a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x812a"
    VALUE
    0x8080327C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_TiInRow0x8B01_C
    "disable mask / Disable masks of check DFC_bds_TiInRow0x8B01"
    VALUE
    0x8080327D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_TiInRow0x8B02_C
    "disable mask / Disable masks of check DFC_bds_TiInRow0x8B02"
    VALUE
    0x8080327E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_TiInRow0x8B03_C
    "disable mask / Disable masks of check DFC_bds_TiInRow0x8B03"
    VALUE
    0x8080327F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_DevLibBattUHi_C
    "disable mask / Disable masks of check DFC_DevLibBattUHi"
    VALUE
    0x80803280
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_DevLibBattULo_C
    "disable mask / Disable masks of check DFC_DevLibBattULo"
    VALUE
    0x80803281
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8063_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8063"
    VALUE
    0x80803282
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8064_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8064"
    VALUE
    0x80803283
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8065_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8065"
    VALUE
    0x80803284
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8066_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8066"
    VALUE
    0x80803285
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8067_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8067"
    VALUE
    0x80803286
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8068_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8068"
    VALUE
    0x80803287
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8069_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8069"
    VALUE
    0x80803288
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x806a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x806a"
    VALUE
    0x80803289
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x806b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x806b"
    VALUE
    0x8080328A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x806c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x806c"
    VALUE
    0x8080328B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x806d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x806d"
    VALUE
    0x8080328C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x806e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x806e"
    VALUE
    0x8080328D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x806f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x806f"
    VALUE
    0x8080328E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8070_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8070"
    VALUE
    0x8080328F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8071_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8071"
    VALUE
    0x80803290
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8072_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8072"
    VALUE
    0x80803291
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8073_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8073"
    VALUE
    0x80803292
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8074_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8074"
    VALUE
    0x80803293
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8075_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8075"
    VALUE
    0x80803294
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8076_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8076"
    VALUE
    0x80803295
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8077_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8077"
    VALUE
    0x80803296
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8078_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8078"
    VALUE
    0x80803297
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8079_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8079"
    VALUE
    0x80803298
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x807a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x807a"
    VALUE
    0x80803299
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x807b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x807b"
    VALUE
    0x8080329A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x807c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x807c"
    VALUE
    0x8080329B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x807d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x807d"
    VALUE
    0x8080329C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x807e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x807e"
    VALUE
    0x8080329D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x807f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x807f"
    VALUE
    0x8080329E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8080_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8080"
    VALUE
    0x8080329F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8081_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8081"
    VALUE
    0x808032A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8082_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8082"
    VALUE
    0x808032A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8083_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8083"
    VALUE
    0x808032A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8084_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8084"
    VALUE
    0x808032A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8085_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8085"
    VALUE
    0x808032A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8086_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8086"
    VALUE
    0x808032A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8087_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8087"
    VALUE
    0x808032A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8088_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8088"
    VALUE
    0x808032A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8089_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8089"
    VALUE
    0x808032A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x808a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x808a"
    VALUE
    0x808032A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x808b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x808b"
    VALUE
    0x808032AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x808c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x808c"
    VALUE
    0x808032AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x808d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x808d"
    VALUE
    0x808032AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x808e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x808e"
    VALUE
    0x808032AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x808f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x808f"
    VALUE
    0x808032AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8090_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8090"
    VALUE
    0x808032AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8091_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8091"
    VALUE
    0x808032B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8092_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8092"
    VALUE
    0x808032B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8093_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8093"
    VALUE
    0x808032B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8094_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8094"
    VALUE
    0x808032B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8095_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8095"
    VALUE
    0x808032B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8096_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8096"
    VALUE
    0x808032B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8097_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8097"
    VALUE
    0x808032B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8098_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8098"
    VALUE
    0x808032B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8099_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8099"
    VALUE
    0x808032B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x809a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x809a"
    VALUE
    0x808032B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x809b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x809b"
    VALUE
    0x808032BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x809c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x809c"
    VALUE
    0x808032BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x809d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x809d"
    VALUE
    0x808032BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x809e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x809e"
    VALUE
    0x808032BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x809f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x809f"
    VALUE
    0x808032BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80a0_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80a0"
    VALUE
    0x808032BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80a1_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80a1"
    VALUE
    0x808032C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80a2_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80a2"
    VALUE
    0x808032C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80a3_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80a3"
    VALUE
    0x808032C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80a4_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80a4"
    VALUE
    0x808032C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80a5_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80a5"
    VALUE
    0x808032C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80a6_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80a6"
    VALUE
    0x808032C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80a7_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80a7"
    VALUE
    0x808032C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80a8_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80a8"
    VALUE
    0x808032C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80a9_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80a9"
    VALUE
    0x808032C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80aa_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80aa"
    VALUE
    0x808032C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ab_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ab"
    VALUE
    0x808032CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ac_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ac"
    VALUE
    0x808032CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ad_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ad"
    VALUE
    0x808032CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ae_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ae"
    VALUE
    0x808032CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80af_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80af"
    VALUE
    0x808032CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80b0_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80b0"
    VALUE
    0x808032CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80b1_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80b1"
    VALUE
    0x808032D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80b2_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80b2"
    VALUE
    0x808032D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80b3_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80b3"
    VALUE
    0x808032D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80b4_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80b4"
    VALUE
    0x808032D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80b5_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80b5"
    VALUE
    0x808032D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80b6_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80b6"
    VALUE
    0x808032D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80b7_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80b7"
    VALUE
    0x808032D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80b8_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80b8"
    VALUE
    0x808032D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80b9_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80b9"
    VALUE
    0x808032D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80ba_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80ba"
    VALUE
    0x808032D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80bb_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80bb"
    VALUE
    0x808032DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80bc_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80bc"
    VALUE
    0x808032DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80bd_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80bd"
    VALUE
    0x808032DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80be_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80be"
    VALUE
    0x808032DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80bf_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80bf"
    VALUE
    0x808032DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80c0_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80c0"
    VALUE
    0x808032DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80c1_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80c1"
    VALUE
    0x808032E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80c2_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80c2"
    VALUE
    0x808032E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80c3_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80c3"
    VALUE
    0x808032E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80c4_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80c4"
    VALUE
    0x808032E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80c5_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80c5"
    VALUE
    0x808032E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x80c6_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x80c6"
    VALUE
    0x808032E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_TiUpDwn0x8A01_C
    "disable mask / Disable masks of check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x808032E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_TiUpDwn0x8A02_C
    "disable mask / Disable masks of check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x808032E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_TiUpDwn0x8A03_C
    "disable mask / Disable masks of check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x808032E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA13OR_C
    "disable mask / Disable masks of check DFC_rbr_inA13OR"
    VALUE
    0x808032E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA13SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA13SCB"
    VALUE
    0x808032EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA13SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA13SCG"
    VALUE
    0x808032EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA14OR_C
    "disable mask / Disable masks of check DFC_rbr_inA14OR"
    VALUE
    0x808032EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA14SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA14SCB"
    VALUE
    0x808032ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA14SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA14SCG"
    VALUE
    0x808032EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA21OR_C
    "disable mask / Disable masks of check DFC_rbr_inA21OR"
    VALUE
    0x808032EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA21SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA21SCB"
    VALUE
    0x808032F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA21SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA21SCG"
    VALUE
    0x808032F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA22OR_C
    "disable mask / Disable masks of check DFC_rbr_inA22OR"
    VALUE
    0x808032F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA22SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA22SCB"
    VALUE
    0x808032F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA22SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA22SCG"
    VALUE
    0x808032F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA23OR_C
    "disable mask / Disable masks of check DFC_rbr_inA23OR"
    VALUE
    0x808032F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA23SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA23SCB"
    VALUE
    0x808032F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA23SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA23SCG"
    VALUE
    0x808032F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA24OR_C
    "disable mask / Disable masks of check DFC_rbr_inA24OR"
    VALUE
    0x808032F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA24SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA24SCB"
    VALUE
    0x808032F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA24SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA24SCG"
    VALUE
    0x808032FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA25OR_C
    "disable mask / Disable masks of check DFC_rbr_inA25OR"
    VALUE
    0x808032FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA25SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA25SCB"
    VALUE
    0x808032FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA25SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA25SCG"
    VALUE
    0x808032FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA26OR_C
    "disable mask / Disable masks of check DFC_rbr_inA26OR"
    VALUE
    0x808032FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA26SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA26SCB"
    VALUE
    0x808032FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA26SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA26SCG"
    VALUE
    0x80803300
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA27OR_C
    "disable mask / Disable masks of check DFC_rbr_inA27OR"
    VALUE
    0x80803301
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA27SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA27SCB"
    VALUE
    0x80803302
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA27SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA27SCG"
    VALUE
    0x80803303
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA28OR_C
    "disable mask / Disable masks of check DFC_rbr_inA28OR"
    VALUE
    0x80803304
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA28SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA28SCB"
    VALUE
    0x80803305
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA28SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA28SCG"
    VALUE
    0x80803306
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA29OR_C
    "disable mask / Disable masks of check DFC_rbr_inA29OR"
    VALUE
    0x80803307
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA29SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA29SCB"
    VALUE
    0x80803308
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA29SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA29SCG"
    VALUE
    0x80803309
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA36AicSCB"
    VALUE
    0x8080330A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inA36AicSCG"
    VALUE
    0x8080330B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36OR_C
    "disable mask / Disable masks of check DFC_rbr_inA36OR"
    VALUE
    0x8080330C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA36SCB"
    VALUE
    0x8080330D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA36SCG"
    VALUE
    0x8080330E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA36ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x8080330F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA37AicSCB"
    VALUE
    0x80803310
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inA37AicSCG"
    VALUE
    0x80803311
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37OR_C
    "disable mask / Disable masks of check DFC_rbr_inA37OR"
    VALUE
    0x80803312
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA37SCB"
    VALUE
    0x80803313
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA37SCG"
    VALUE
    0x80803314
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA37ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80803315
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA38AicSCB"
    VALUE
    0x80803316
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inA38AicSCG"
    VALUE
    0x80803317
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38OR_C
    "disable mask / Disable masks of check DFC_rbr_inA38OR"
    VALUE
    0x80803318
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA38SCB"
    VALUE
    0x80803319
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA38SCG"
    VALUE
    0x8080331A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA38ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x8080331B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA39AicSCB"
    VALUE
    0x8080331C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inA39AicSCG"
    VALUE
    0x8080331D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39OR_C
    "disable mask / Disable masks of check DFC_rbr_inA39OR"
    VALUE
    0x8080331E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA39SCB"
    VALUE
    0x8080331F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA39SCG"
    VALUE
    0x80803320
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA39ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80803321
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA40OR_C
    "disable mask / Disable masks of check DFC_rbr_inA40OR"
    VALUE
    0x80803322
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA40SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA40SCB"
    VALUE
    0x80803323
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA40SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA40SCG"
    VALUE
    0x80803324
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA41OR_C
    "disable mask / Disable masks of check DFC_rbr_inA41OR"
    VALUE
    0x80803325
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA41SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA41SCB"
    VALUE
    0x80803326
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA41SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA41SCG"
    VALUE
    0x80803327
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA42OR_C
    "disable mask / Disable masks of check DFC_rbr_inA42OR"
    VALUE
    0x80803328
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA42SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA42SCB"
    VALUE
    0x80803329
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA42SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA42SCG"
    VALUE
    0x8080332A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA43AicSCB"
    VALUE
    0x8080332B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inA43AicSCG"
    VALUE
    0x8080332C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43OR_C
    "disable mask / Disable masks of check DFC_rbr_inA43OR"
    VALUE
    0x8080332D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA43SCB"
    VALUE
    0x8080332E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA43SCG"
    VALUE
    0x8080332F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA43ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80803330
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA44OL_C
    "disable mask / Disable masks of check DFC_rbr_inA44OL"
    VALUE
    0x80803331
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA44SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA44SCB"
    VALUE
    0x80803332
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA44SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA44SCG"
    VALUE
    0x80803333
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA57OR_C
    "disable mask / Disable masks of check DFC_rbr_inA57OR"
    VALUE
    0x80803334
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA57SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA57SCB"
    VALUE
    0x80803335
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA57SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA57SCG"
    VALUE
    0x80803336
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA59OL_C
    "disable mask / Disable masks of check DFC_rbr_inA59OL"
    VALUE
    0x80803337
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA59SCB_C
    "disable mask / Disable masks of check DFC_rbr_inA59SCB"
    VALUE
    0x80803338
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inA59SCG_C
    "disable mask / Disable masks of check DFC_rbr_inA59SCG"
    VALUE
    0x80803339
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK10OR_C
    "disable mask / Disable masks of check DFC_rbr_inK10OR"
    VALUE
    0x8080333A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK10SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK10SCB"
    VALUE
    0x8080333B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK10SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK10SCG"
    VALUE
    0x8080333C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK11OR_C
    "disable mask / Disable masks of check DFC_rbr_inK11OR"
    VALUE
    0x8080333D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK11SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK11SCB"
    VALUE
    0x8080333E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK11SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK11SCG"
    VALUE
    0x8080333F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK30AicSCB"
    VALUE
    0x80803340
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK30AicSCG"
    VALUE
    0x80803341
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30OR_C
    "disable mask / Disable masks of check DFC_rbr_inK30OR"
    VALUE
    0x80803342
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK30SCB"
    VALUE
    0x80803343
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK30SCG"
    VALUE
    0x80803344
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK30ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80803345
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK31OR_C
    "disable mask / Disable masks of check DFC_rbr_inK31OR"
    VALUE
    0x80803346
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK31SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK31SCB"
    VALUE
    0x80803347
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK31SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK31SCG"
    VALUE
    0x80803348
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK32OR_C
    "disable mask / Disable masks of check DFC_rbr_inK32OR"
    VALUE
    0x80803349
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK32SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK32SCB"
    VALUE
    0x8080334A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK32SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK32SCG"
    VALUE
    0x8080334B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK33OR_C
    "disable mask / Disable masks of check DFC_rbr_inK33OR"
    VALUE
    0x8080334C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK33SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK33SCB"
    VALUE
    0x8080334D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK33SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK33SCG"
    VALUE
    0x8080334E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK34OR_C
    "disable mask / Disable masks of check DFC_rbr_inK34OR"
    VALUE
    0x8080334F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK34SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK34SCB"
    VALUE
    0x80803350
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK34SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK34SCG"
    VALUE
    0x80803351
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK35OR_C
    "disable mask / Disable masks of check DFC_rbr_inK35OR"
    VALUE
    0x80803352
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK35SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK35SCB"
    VALUE
    0x80803353
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK35SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK35SCG"
    VALUE
    0x80803354
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK36OR_C
    "disable mask / Disable masks of check DFC_rbr_inK36OR"
    VALUE
    0x80803355
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK36SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK36SCB"
    VALUE
    0x80803356
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK36SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK36SCG"
    VALUE
    0x80803357
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK37AicSCB"
    VALUE
    0x80803358
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK37AicSCG"
    VALUE
    0x80803359
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37OR_C
    "disable mask / Disable masks of check DFC_rbr_inK37OR"
    VALUE
    0x8080335A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK37SCB"
    VALUE
    0x8080335B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK37SCG"
    VALUE
    0x8080335C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK37ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x8080335D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK38AicSCB"
    VALUE
    0x8080335E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK38AicSCG"
    VALUE
    0x8080335F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38OR_C
    "disable mask / Disable masks of check DFC_rbr_inK38OR"
    VALUE
    0x80803360
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK38SCB"
    VALUE
    0x80803361
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK38SCG"
    VALUE
    0x80803362
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK38ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80803363
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK39AicSCB"
    VALUE
    0x80803364
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK39AicSCG"
    VALUE
    0x80803365
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39OR_C
    "disable mask / Disable masks of check DFC_rbr_inK39OR"
    VALUE
    0x80803366
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK39SCB"
    VALUE
    0x80803367
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK39SCG"
    VALUE
    0x80803368
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK39ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80803369
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK40AicSCB"
    VALUE
    0x8080336A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK40AicSCG"
    VALUE
    0x8080336B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40OR_C
    "disable mask / Disable masks of check DFC_rbr_inK40OR"
    VALUE
    0x8080336C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK40SCB"
    VALUE
    0x8080336D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK40SCG"
    VALUE
    0x8080336E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK40ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x8080336F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK41AicSCB"
    VALUE
    0x80803370
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK41AicSCG"
    VALUE
    0x80803371
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41OR_C
    "disable mask / Disable masks of check DFC_rbr_inK41OR"
    VALUE
    0x80803372
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK41SCB"
    VALUE
    0x80803373
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK41SCG"
    VALUE
    0x80803374
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK41ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80803375
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK42AicSCB"
    VALUE
    0x80803376
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK42AicSCG"
    VALUE
    0x80803377
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42OR_C
    "disable mask / Disable masks of check DFC_rbr_inK42OR"
    VALUE
    0x80803378
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK42SCB"
    VALUE
    0x80803379
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK42SCG"
    VALUE
    0x8080337A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK42ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x8080337B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK43OR_C
    "disable mask / Disable masks of check DFC_rbr_inK43OR"
    VALUE
    0x8080337C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK43SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK43SCB"
    VALUE
    0x8080337D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK43SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK43SCG"
    VALUE
    0x8080337E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK44AicSCB"
    VALUE
    0x8080337F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK44AicSCG"
    VALUE
    0x80803380
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44OR_C
    "disable mask / Disable masks of check DFC_rbr_inK44OR"
    VALUE
    0x80803381
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK44SCB"
    VALUE
    0x80803382
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK44SCG"
    VALUE
    0x80803383
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK44ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80803384
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK45AicSCB"
    VALUE
    0x80803385
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK45AicSCG"
    VALUE
    0x80803386
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45OR_C
    "disable mask / Disable masks of check DFC_rbr_inK45OR"
    VALUE
    0x80803387
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK45SCB"
    VALUE
    0x80803388
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK45SCG"
    VALUE
    0x80803389
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK45ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x8080338A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK52OR_C
    "disable mask / Disable masks of check DFC_rbr_inK52OR"
    VALUE
    0x8080338B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK52SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK52SCB"
    VALUE
    0x8080338C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK52SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK52SCG"
    VALUE
    0x8080338D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK53OR_C
    "disable mask / Disable masks of check DFC_rbr_inK53OR"
    VALUE
    0x8080338E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK53SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK53SCB"
    VALUE
    0x8080338F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK53SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK53SCG"
    VALUE
    0x80803390
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK54AicSCB"
    VALUE
    0x80803391
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK54AicSCG"
    VALUE
    0x80803392
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54OR_C
    "disable mask / Disable masks of check DFC_rbr_inK54OR"
    VALUE
    0x80803393
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK54SCB"
    VALUE
    0x80803394
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK54SCG"
    VALUE
    0x80803395
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK54ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80803396
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK55AicSCB"
    VALUE
    0x80803397
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK55AicSCG"
    VALUE
    0x80803398
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55OR_C
    "disable mask / Disable masks of check DFC_rbr_inK55OR"
    VALUE
    0x80803399
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK55SCB"
    VALUE
    0x8080339A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK55SCG"
    VALUE
    0x8080339B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK55ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x8080339C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK56OR_C
    "disable mask / Disable masks of check DFC_rbr_inK56OR"
    VALUE
    0x8080339D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK56SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK56SCB"
    VALUE
    0x8080339E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK56SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK56SCG"
    VALUE
    0x8080339F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK57OR_C
    "disable mask / Disable masks of check DFC_rbr_inK57OR"
    VALUE
    0x808033A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK57SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK57SCB"
    VALUE
    0x808033A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK57SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK57SCG"
    VALUE
    0x808033A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK58OR_C
    "disable mask / Disable masks of check DFC_rbr_inK58OR"
    VALUE
    0x808033A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK58SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK58SCB"
    VALUE
    0x808033A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK58SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK58SCG"
    VALUE
    0x808033A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK59OR_C
    "disable mask / Disable masks of check DFC_rbr_inK59OR"
    VALUE
    0x808033A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK59SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK59SCB"
    VALUE
    0x808033A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK59SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK59SCG"
    VALUE
    0x808033A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK60OR_C
    "disable mask / Disable masks of check DFC_rbr_inK60OR"
    VALUE
    0x808033A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK60SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK60SCB"
    VALUE
    0x808033AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK60SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK60SCG"
    VALUE
    0x808033AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK61AicSCB"
    VALUE
    0x808033AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK61AicSCG"
    VALUE
    0x808033AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61OR_C
    "disable mask / Disable masks of check DFC_rbr_inK61OR"
    VALUE
    0x808033AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK61SCB"
    VALUE
    0x808033AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK61SCG"
    VALUE
    0x808033B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK61ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x808033B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK62OR_C
    "disable mask / Disable masks of check DFC_rbr_inK62OR"
    VALUE
    0x808033B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK62SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK62SCB"
    VALUE
    0x808033B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK62SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK62SCG"
    VALUE
    0x808033B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK63AicSCB"
    VALUE
    0x808033B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK63AicSCG"
    VALUE
    0x808033B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63OR_C
    "disable mask / Disable masks of check DFC_rbr_inK63OR"
    VALUE
    0x808033B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK63SCB"
    VALUE
    0x808033B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK63SCG"
    VALUE
    0x808033B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK63ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x808033BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK64AicSCB"
    VALUE
    0x808033BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK64AicSCG"
    VALUE
    0x808033BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64OR_C
    "disable mask / Disable masks of check DFC_rbr_inK64OR"
    VALUE
    0x808033BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK64SCB"
    VALUE
    0x808033BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK64SCG"
    VALUE
    0x808033BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK64ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x808033C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65AicSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK65AicSCB"
    VALUE
    0x808033C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65AicSCG_C
    "disable mask / Disable masks of check DFC_rbr_inK65AicSCG"
    VALUE
    0x808033C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65OR_C
    "disable mask / Disable masks of check DFC_rbr_inK65OR"
    VALUE
    0x808033C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK65SCB"
    VALUE
    0x808033C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK65SCG"
    VALUE
    0x808033C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK65ShuntSCB_C
    "disable mask / Disable masks of check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x808033C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK74OR_C
    "disable mask / Disable masks of check DFC_rbr_inK74OR"
    VALUE
    0x808033C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK74SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK74SCB"
    VALUE
    0x808033C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK74SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK74SCG"
    VALUE
    0x808033C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK75OR_C
    "disable mask / Disable masks of check DFC_rbr_inK75OR"
    VALUE
    0x808033CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK75SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK75SCB"
    VALUE
    0x808033CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK75SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK75SCG"
    VALUE
    0x808033CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK76OR_C
    "disable mask / Disable masks of check DFC_rbr_inK76OR"
    VALUE
    0x808033CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK76SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK76SCB"
    VALUE
    0x808033CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK76SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK76SCG"
    VALUE
    0x808033CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK77OR_C
    "disable mask / Disable masks of check DFC_rbr_inK77OR"
    VALUE
    0x808033D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK77SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK77SCB"
    VALUE
    0x808033D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK77SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK77SCG"
    VALUE
    0x808033D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK78OR_C
    "disable mask / Disable masks of check DFC_rbr_inK78OR"
    VALUE
    0x808033D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK78SCB_C
    "disable mask / Disable masks of check DFC_rbr_inK78SCB"
    VALUE
    0x808033D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inK78SCG_C
    "disable mask / Disable masks of check DFC_rbr_inK78SCG"
    VALUE
    0x808033D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_DvUBAT_FWs_C
    "disable mask / Disable masks of check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x808033D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OVErr_VPR6_C
    "disable mask / Disable masks of check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x808033D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OVWarn_VPR6_C
    "disable mask / Disable masks of check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x808033D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808033D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x808033DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_UBAT_MON_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x808033DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x808033DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x808033DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_UBRM24_MON_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x808033DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VDD5_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x808033DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VDD5_IN_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x808033E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VPR6_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x808033E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VSS3_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x808033E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VSS4_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x808033E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_Temp1_HTErr_C
    "disable mask / Disable masks of check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x808033E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_Temp1_HTWarn_C
    "disable mask / Disable masks of check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x808033E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_Temp2_HTErr_C
    "disable mask / Disable masks of check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x808033E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_Temp2_HTWarn_C
    "disable mask / Disable masks of check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x808033E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808033E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x808033E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VDD5_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x808033EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VDD5_IN_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x808033EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VPR6_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x808033EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VSS3_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x808033ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VSS4_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x808033EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA01OL_C
    "disable mask / Disable masks of check DFC_rbr_outA01OL"
    VALUE
    0x808033EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA01OT_C
    "disable mask / Disable masks of check DFC_rbr_outA01OT"
    VALUE
    0x808033F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA01SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA01SCB"
    VALUE
    0x808033F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA01SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA01SCG"
    VALUE
    0x808033F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02OL_C
    "disable mask / Disable masks of check DFC_rbr_outA02OL"
    VALUE
    0x808033F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02OR_C
    "disable mask / Disable masks of check DFC_rbr_outA02OR"
    VALUE
    0x808033F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02OT_C
    "disable mask / Disable masks of check DFC_rbr_outA02OT"
    VALUE
    0x808033F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA02SCB"
    VALUE
    0x808033F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA02SCG"
    VALUE
    0x808033F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03OL_C
    "disable mask / Disable masks of check DFC_rbr_outA03OL"
    VALUE
    0x808033F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03OT_C
    "disable mask / Disable masks of check DFC_rbr_outA03OT"
    VALUE
    0x808033F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA03SCB"
    VALUE
    0x808033FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA03SCG"
    VALUE
    0x808033FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04OL_C
    "disable mask / Disable masks of check DFC_rbr_outA04OL"
    VALUE
    0x808033FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04OT_C
    "disable mask / Disable masks of check DFC_rbr_outA04OT"
    VALUE
    0x808033FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA04SCB"
    VALUE
    0x808033FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA04SCG"
    VALUE
    0x808033FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05OL_C
    "disable mask / Disable masks of check DFC_rbr_outA05OL"
    VALUE
    0x80803400
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05OR_C
    "disable mask / Disable masks of check DFC_rbr_outA05OR"
    VALUE
    0x80803401
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05OT_C
    "disable mask / Disable masks of check DFC_rbr_outA05OT"
    VALUE
    0x80803402
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA05SCB"
    VALUE
    0x80803403
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA05SCG"
    VALUE
    0x80803404
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA06OL_C
    "disable mask / Disable masks of check DFC_rbr_outA06OL"
    VALUE
    0x80803405
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA06OR_C
    "disable mask / Disable masks of check DFC_rbr_outA06OR"
    VALUE
    0x80803406
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA06OT_C
    "disable mask / Disable masks of check DFC_rbr_outA06OT"
    VALUE
    0x80803407
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA06SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA06SCB"
    VALUE
    0x80803408
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA06SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA06SCG"
    VALUE
    0x80803409
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07OL_C
    "disable mask / Disable masks of check DFC_rbr_outA07OL"
    VALUE
    0x8080340A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07OT_C
    "disable mask / Disable masks of check DFC_rbr_outA07OT"
    VALUE
    0x8080340B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA07SCB"
    VALUE
    0x8080340C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA07SCG"
    VALUE
    0x8080340D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08OL_C
    "disable mask / Disable masks of check DFC_rbr_outA08OL"
    VALUE
    0x8080340E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08OT_C
    "disable mask / Disable masks of check DFC_rbr_outA08OT"
    VALUE
    0x8080340F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA08SCB"
    VALUE
    0x80803410
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA08SCG"
    VALUE
    0x80803411
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09OL_C
    "disable mask / Disable masks of check DFC_rbr_outA09OL"
    VALUE
    0x80803412
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09OR_C
    "disable mask / Disable masks of check DFC_rbr_outA09OR"
    VALUE
    0x80803413
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09OT_C
    "disable mask / Disable masks of check DFC_rbr_outA09OT"
    VALUE
    0x80803414
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA09SCB"
    VALUE
    0x80803415
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA09SCG"
    VALUE
    0x80803416
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10OL_C
    "disable mask / Disable masks of check DFC_rbr_outA10OL"
    VALUE
    0x80803417
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10OT_C
    "disable mask / Disable masks of check DFC_rbr_outA10OT"
    VALUE
    0x80803418
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA10SCB"
    VALUE
    0x80803419
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA10SCG"
    VALUE
    0x8080341A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA11OL_C
    "disable mask / Disable masks of check DFC_rbr_outA11OL"
    VALUE
    0x8080341B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA11OT_C
    "disable mask / Disable masks of check DFC_rbr_outA11OT"
    VALUE
    0x8080341C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA11SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA11SCB"
    VALUE
    0x8080341D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA11SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA11SCG"
    VALUE
    0x8080341E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA12OR_C
    "disable mask / Disable masks of check DFC_rbr_outA12OR"
    VALUE
    0x8080341F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA12SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA12SCB"
    VALUE
    0x80803420
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA12SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA12SCG"
    VALUE
    0x80803421
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA16OL_C
    "disable mask / Disable masks of check DFC_rbr_outA16OL"
    VALUE
    0x80803422
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA16OT_C
    "disable mask / Disable masks of check DFC_rbr_outA16OT"
    VALUE
    0x80803423
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA16SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA16SCB"
    VALUE
    0x80803424
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA16SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA16SCG"
    VALUE
    0x80803425
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17OL_C
    "disable mask / Disable masks of check DFC_rbr_outA17OL"
    VALUE
    0x80803426
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17OR_C
    "disable mask / Disable masks of check DFC_rbr_outA17OR"
    VALUE
    0x80803427
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17OT_C
    "disable mask / Disable masks of check DFC_rbr_outA17OT"
    VALUE
    0x80803428
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA17SCB"
    VALUE
    0x80803429
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA17SCG"
    VALUE
    0x8080342A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18OL_C
    "disable mask / Disable masks of check DFC_rbr_outA18OL"
    VALUE
    0x8080342B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18OT_C
    "disable mask / Disable masks of check DFC_rbr_outA18OT"
    VALUE
    0x8080342C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA18SCB"
    VALUE
    0x8080342D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA18SCG"
    VALUE
    0x8080342E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19OL_C
    "disable mask / Disable masks of check DFC_rbr_outA19OL"
    VALUE
    0x8080342F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19OR_C
    "disable mask / Disable masks of check DFC_rbr_outA19OR"
    VALUE
    0x80803430
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19OT_C
    "disable mask / Disable masks of check DFC_rbr_outA19OT"
    VALUE
    0x80803431
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA19SCB"
    VALUE
    0x80803432
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA19SCG"
    VALUE
    0x80803433
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20OL_C
    "disable mask / Disable masks of check DFC_rbr_outA20OL"
    VALUE
    0x80803434
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20OR_C
    "disable mask / Disable masks of check DFC_rbr_outA20OR"
    VALUE
    0x80803435
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20OT_C
    "disable mask / Disable masks of check DFC_rbr_outA20OT"
    VALUE
    0x80803436
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA20SCB"
    VALUE
    0x80803437
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA20SCG"
    VALUE
    0x80803438
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31OL_C
    "disable mask / Disable masks of check DFC_rbr_outA31OL"
    VALUE
    0x80803439
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31OR_C
    "disable mask / Disable masks of check DFC_rbr_outA31OR"
    VALUE
    0x8080343A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31OT_C
    "disable mask / Disable masks of check DFC_rbr_outA31OT"
    VALUE
    0x8080343B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA31SCB"
    VALUE
    0x8080343C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA31SCG"
    VALUE
    0x8080343D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32OL_C
    "disable mask / Disable masks of check DFC_rbr_outA32OL"
    VALUE
    0x8080343E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32OR_C
    "disable mask / Disable masks of check DFC_rbr_outA32OR"
    VALUE
    0x8080343F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32OT_C
    "disable mask / Disable masks of check DFC_rbr_outA32OT"
    VALUE
    0x80803440
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA32SCB"
    VALUE
    0x80803441
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA32SCG"
    VALUE
    0x80803442
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33OL_C
    "disable mask / Disable masks of check DFC_rbr_outA33OL"
    VALUE
    0x80803443
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33OR_C
    "disable mask / Disable masks of check DFC_rbr_outA33OR"
    VALUE
    0x80803444
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33OT_C
    "disable mask / Disable masks of check DFC_rbr_outA33OT"
    VALUE
    0x80803445
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA33SCB"
    VALUE
    0x80803446
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA33SCG"
    VALUE
    0x80803447
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34OL_C
    "disable mask / Disable masks of check DFC_rbr_outA34OL"
    VALUE
    0x80803448
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34OR_C
    "disable mask / Disable masks of check DFC_rbr_outA34OR"
    VALUE
    0x80803449
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34OT_C
    "disable mask / Disable masks of check DFC_rbr_outA34OT"
    VALUE
    0x8080344A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA34SCB"
    VALUE
    0x8080344B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA34SCG"
    VALUE
    0x8080344C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35OL_C
    "disable mask / Disable masks of check DFC_rbr_outA35OL"
    VALUE
    0x8080344D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35OR_C
    "disable mask / Disable masks of check DFC_rbr_outA35OR"
    VALUE
    0x8080344E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35OT_C
    "disable mask / Disable masks of check DFC_rbr_outA35OT"
    VALUE
    0x8080344F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA35SCB"
    VALUE
    0x80803450
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA35SCG"
    VALUE
    0x80803451
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46OL_C
    "disable mask / Disable masks of check DFC_rbr_outA46OL"
    VALUE
    0x80803452
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46OR_C
    "disable mask / Disable masks of check DFC_rbr_outA46OR"
    VALUE
    0x80803453
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46OT_C
    "disable mask / Disable masks of check DFC_rbr_outA46OT"
    VALUE
    0x80803454
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA46SCB"
    VALUE
    0x80803455
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA46SCG"
    VALUE
    0x80803456
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47OL_C
    "disable mask / Disable masks of check DFC_rbr_outA47OL"
    VALUE
    0x80803457
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47OR_C
    "disable mask / Disable masks of check DFC_rbr_outA47OR"
    VALUE
    0x80803458
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47OT_C
    "disable mask / Disable masks of check DFC_rbr_outA47OT"
    VALUE
    0x80803459
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA47SCB"
    VALUE
    0x8080345A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA47SCG"
    VALUE
    0x8080345B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48OL_C
    "disable mask / Disable masks of check DFC_rbr_outA48OL"
    VALUE
    0x8080345C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48OR_C
    "disable mask / Disable masks of check DFC_rbr_outA48OR"
    VALUE
    0x8080345D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48OT_C
    "disable mask / Disable masks of check DFC_rbr_outA48OT"
    VALUE
    0x8080345E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA48SCB"
    VALUE
    0x8080345F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA48SCG"
    VALUE
    0x80803460
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA49OL_C
    "disable mask / Disable masks of check DFC_rbr_outA49OL"
    VALUE
    0x80803461
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA49OT_C
    "disable mask / Disable masks of check DFC_rbr_outA49OT"
    VALUE
    0x80803462
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA49SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA49SCB"
    VALUE
    0x80803463
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA49SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA49SCG"
    VALUE
    0x80803464
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA50OL_C
    "disable mask / Disable masks of check DFC_rbr_outA50OL"
    VALUE
    0x80803465
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA50OT_C
    "disable mask / Disable masks of check DFC_rbr_outA50OT"
    VALUE
    0x80803466
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA50SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA50SCB"
    VALUE
    0x80803467
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA50SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA50SCG"
    VALUE
    0x80803468
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51OL_C
    "disable mask / Disable masks of check DFC_rbr_outA51OL"
    VALUE
    0x80803469
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51OR_C
    "disable mask / Disable masks of check DFC_rbr_outA51OR"
    VALUE
    0x8080346A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51OT_C
    "disable mask / Disable masks of check DFC_rbr_outA51OT"
    VALUE
    0x8080346B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA51SCB"
    VALUE
    0x8080346C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA51SCG"
    VALUE
    0x8080346D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52OL_C
    "disable mask / Disable masks of check DFC_rbr_outA52OL"
    VALUE
    0x8080346E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52OR_C
    "disable mask / Disable masks of check DFC_rbr_outA52OR"
    VALUE
    0x8080346F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52OT_C
    "disable mask / Disable masks of check DFC_rbr_outA52OT"
    VALUE
    0x80803470
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA52SCB"
    VALUE
    0x80803471
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA52SCG"
    VALUE
    0x80803472
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53OL_C
    "disable mask / Disable masks of check DFC_rbr_outA53OL"
    VALUE
    0x80803473
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53OR_C
    "disable mask / Disable masks of check DFC_rbr_outA53OR"
    VALUE
    0x80803474
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53OT_C
    "disable mask / Disable masks of check DFC_rbr_outA53OT"
    VALUE
    0x80803475
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA53SCB"
    VALUE
    0x80803476
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA53SCG"
    VALUE
    0x80803477
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54OL_C
    "disable mask / Disable masks of check DFC_rbr_outA54OL"
    VALUE
    0x80803478
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54OR_C
    "disable mask / Disable masks of check DFC_rbr_outA54OR"
    VALUE
    0x80803479
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54OT_C
    "disable mask / Disable masks of check DFC_rbr_outA54OT"
    VALUE
    0x8080347A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA54SCB"
    VALUE
    0x8080347B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA54SCG"
    VALUE
    0x8080347C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA55OL_C
    "disable mask / Disable masks of check DFC_rbr_outA55OL"
    VALUE
    0x8080347D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA55OT_C
    "disable mask / Disable masks of check DFC_rbr_outA55OT"
    VALUE
    0x8080347E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA55SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA55SCB"
    VALUE
    0x8080347F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA55SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA55SCG"
    VALUE
    0x80803480
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA56OL_C
    "disable mask / Disable masks of check DFC_rbr_outA56OL"
    VALUE
    0x80803481
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA56OT_C
    "disable mask / Disable masks of check DFC_rbr_outA56OT"
    VALUE
    0x80803482
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA56SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA56SCB"
    VALUE
    0x80803483
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA56SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA56SCG"
    VALUE
    0x80803484
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA58OL_C
    "disable mask / Disable masks of check DFC_rbr_outA58OL"
    VALUE
    0x80803485
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA58OT_C
    "disable mask / Disable masks of check DFC_rbr_outA58OT"
    VALUE
    0x80803486
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA58SCB_C
    "disable mask / Disable masks of check DFC_rbr_outA58SCB"
    VALUE
    0x80803487
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA58SCG_C
    "disable mask / Disable masks of check DFC_rbr_outA58SCG"
    VALUE
    0x80803488
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07OL_C
    "disable mask / Disable masks of check DFC_rbr_outK07OL"
    VALUE
    0x80803489
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07OR_C
    "disable mask / Disable masks of check DFC_rbr_outK07OR"
    VALUE
    0x8080348A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07OT_C
    "disable mask / Disable masks of check DFC_rbr_outK07OT"
    VALUE
    0x8080348B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK07SCB"
    VALUE
    0x8080348C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK07SCG"
    VALUE
    0x8080348D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08OL_C
    "disable mask / Disable masks of check DFC_rbr_outK08OL"
    VALUE
    0x8080348E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08OR_C
    "disable mask / Disable masks of check DFC_rbr_outK08OR"
    VALUE
    0x8080348F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08OT_C
    "disable mask / Disable masks of check DFC_rbr_outK08OT"
    VALUE
    0x80803490
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK08SCB"
    VALUE
    0x80803491
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK08SCG"
    VALUE
    0x80803492
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09OL_C
    "disable mask / Disable masks of check DFC_rbr_outK09OL"
    VALUE
    0x80803493
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09OR_C
    "disable mask / Disable masks of check DFC_rbr_outK09OR"
    VALUE
    0x80803494
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09OT_C
    "disable mask / Disable masks of check DFC_rbr_outK09OT"
    VALUE
    0x80803495
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK09SCB"
    VALUE
    0x80803496
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK09SCG"
    VALUE
    0x80803497
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12OL_C
    "disable mask / Disable masks of check DFC_rbr_outK12OL"
    VALUE
    0x80803498
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12OT_C
    "disable mask / Disable masks of check DFC_rbr_outK12OT"
    VALUE
    0x80803499
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK12SCB"
    VALUE
    0x8080349A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK12SCG"
    VALUE
    0x8080349B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13OL_C
    "disable mask / Disable masks of check DFC_rbr_outK13OL"
    VALUE
    0x8080349C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13OT_C
    "disable mask / Disable masks of check DFC_rbr_outK13OT"
    VALUE
    0x8080349D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK13SCB"
    VALUE
    0x8080349E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK13SCG"
    VALUE
    0x8080349F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14OL_C
    "disable mask / Disable masks of check DFC_rbr_outK14OL"
    VALUE
    0x808034A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14OR_C
    "disable mask / Disable masks of check DFC_rbr_outK14OR"
    VALUE
    0x808034A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14OT_C
    "disable mask / Disable masks of check DFC_rbr_outK14OT"
    VALUE
    0x808034A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK14SCB"
    VALUE
    0x808034A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK14SCG"
    VALUE
    0x808034A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15OL_C
    "disable mask / Disable masks of check DFC_rbr_outK15OL"
    VALUE
    0x808034A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15OR_C
    "disable mask / Disable masks of check DFC_rbr_outK15OR"
    VALUE
    0x808034A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15OT_C
    "disable mask / Disable masks of check DFC_rbr_outK15OT"
    VALUE
    0x808034A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK15SCB"
    VALUE
    0x808034A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK15SCG"
    VALUE
    0x808034A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16OL_C
    "disable mask / Disable masks of check DFC_rbr_outK16OL"
    VALUE
    0x808034AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16OR_C
    "disable mask / Disable masks of check DFC_rbr_outK16OR"
    VALUE
    0x808034AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16OT_C
    "disable mask / Disable masks of check DFC_rbr_outK16OT"
    VALUE
    0x808034AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK16SCB"
    VALUE
    0x808034AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK16SCG"
    VALUE
    0x808034AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17OL_C
    "disable mask / Disable masks of check DFC_rbr_outK17OL"
    VALUE
    0x808034AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17OR_C
    "disable mask / Disable masks of check DFC_rbr_outK17OR"
    VALUE
    0x808034B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17OT_C
    "disable mask / Disable masks of check DFC_rbr_outK17OT"
    VALUE
    0x808034B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK17SCB"
    VALUE
    0x808034B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK17SCG"
    VALUE
    0x808034B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK25OR_C
    "disable mask / Disable masks of check DFC_rbr_outK25OR"
    VALUE
    0x808034B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK25SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK25SCB"
    VALUE
    0x808034B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK25SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK25SCG"
    VALUE
    0x808034B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29OL_C
    "disable mask / Disable masks of check DFC_rbr_outK29OL"
    VALUE
    0x808034B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29OR_C
    "disable mask / Disable masks of check DFC_rbr_outK29OR"
    VALUE
    0x808034B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29OT_C
    "disable mask / Disable masks of check DFC_rbr_outK29OT"
    VALUE
    0x808034B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK29SCB"
    VALUE
    0x808034BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK29SCG"
    VALUE
    0x808034BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51OL_C
    "disable mask / Disable masks of check DFC_rbr_outK51OL"
    VALUE
    0x808034BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51OT_C
    "disable mask / Disable masks of check DFC_rbr_outK51OT"
    VALUE
    0x808034BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK51SCB"
    VALUE
    0x808034BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK51SCG"
    VALUE
    0x808034BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK62OR_C
    "disable mask / Disable masks of check DFC_rbr_outK62OR"
    VALUE
    0x808034C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK62SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK62SCB"
    VALUE
    0x808034C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK62SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK62SCG"
    VALUE
    0x808034C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73OL_C
    "disable mask / Disable masks of check DFC_rbr_outK73OL"
    VALUE
    0x808034C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73OR_C
    "disable mask / Disable masks of check DFC_rbr_outK73OR"
    VALUE
    0x808034C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73OT_C
    "disable mask / Disable masks of check DFC_rbr_outK73OT"
    VALUE
    0x808034C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK73SCB"
    VALUE
    0x808034C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK73SCG"
    VALUE
    0x808034C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK80OL_C
    "disable mask / Disable masks of check DFC_rbr_outK80OL"
    VALUE
    0x808034C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK80OT_C
    "disable mask / Disable masks of check DFC_rbr_outK80OT"
    VALUE
    0x808034C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK80SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK80SCB"
    VALUE
    0x808034CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK80SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK80SCG"
    VALUE
    0x808034CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK81OL_C
    "disable mask / Disable masks of check DFC_rbr_outK81OL"
    VALUE
    0x808034CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK81OT_C
    "disable mask / Disable masks of check DFC_rbr_outK81OT"
    VALUE
    0x808034CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK81SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK81SCB"
    VALUE
    0x808034CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK81SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK81SCG"
    VALUE
    0x808034CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK82OL_C
    "disable mask / Disable masks of check DFC_rbr_outK82OL"
    VALUE
    0x808034D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK82OT_C
    "disable mask / Disable masks of check DFC_rbr_outK82OT"
    VALUE
    0x808034D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK82SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK82SCB"
    VALUE
    0x808034D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK82SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK82SCG"
    VALUE
    0x808034D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK83OL_C
    "disable mask / Disable masks of check DFC_rbr_outK83OL"
    VALUE
    0x808034D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK83OT_C
    "disable mask / Disable masks of check DFC_rbr_outK83OT"
    VALUE
    0x808034D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK83SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK83SCB"
    VALUE
    0x808034D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK83SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK83SCG"
    VALUE
    0x808034D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK84OL_C
    "disable mask / Disable masks of check DFC_rbr_outK84OL"
    VALUE
    0x808034D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK84OT_C
    "disable mask / Disable masks of check DFC_rbr_outK84OT"
    VALUE
    0x808034D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK84SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK84SCB"
    VALUE
    0x808034DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK84SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK84SCG"
    VALUE
    0x808034DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK85OL_C
    "disable mask / Disable masks of check DFC_rbr_outK85OL"
    VALUE
    0x808034DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK85OT_C
    "disable mask / Disable masks of check DFC_rbr_outK85OT"
    VALUE
    0x808034DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK85SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK85SCB"
    VALUE
    0x808034DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK85SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK85SCG"
    VALUE
    0x808034DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK86OL_C
    "disable mask / Disable masks of check DFC_rbr_outK86OL"
    VALUE
    0x808034E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK86OT_C
    "disable mask / Disable masks of check DFC_rbr_outK86OT"
    VALUE
    0x808034E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK86SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK86SCB"
    VALUE
    0x808034E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK86SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK86SCG"
    VALUE
    0x808034E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK87OL_C
    "disable mask / Disable masks of check DFC_rbr_outK87OL"
    VALUE
    0x808034E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK87OT_C
    "disable mask / Disable masks of check DFC_rbr_outK87OT"
    VALUE
    0x808034E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK87SCB_C
    "disable mask / Disable masks of check DFC_rbr_outK87SCB"
    VALUE
    0x808034E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK87SCG_C
    "disable mask / Disable masks of check DFC_rbr_outK87SCG"
    VALUE
    0x808034E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_DSMDummy_C
    "disable mask / Disable masks of check DFC_DSMDummy"
    VALUE
    0x808034E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8000_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8000"
    VALUE
    0x808034E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8001_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8001"
    VALUE
    0x808034EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8002_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8002"
    VALUE
    0x808034EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8003_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8003"
    VALUE
    0x808034EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8004_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8004"
    VALUE
    0x808034ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8005_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8005"
    VALUE
    0x808034EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8006_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8006"
    VALUE
    0x808034EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8007_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8007"
    VALUE
    0x808034F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8008_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8008"
    VALUE
    0x808034F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8009_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8009"
    VALUE
    0x808034F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x800a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x800a"
    VALUE
    0x808034F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x800b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x800b"
    VALUE
    0x808034F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x800c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x800c"
    VALUE
    0x808034F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x800d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x800d"
    VALUE
    0x808034F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x800e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x800e"
    VALUE
    0x808034F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x800f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x800f"
    VALUE
    0x808034F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8010_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8010"
    VALUE
    0x808034F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8011_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8011"
    VALUE
    0x808034FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8012_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8012"
    VALUE
    0x808034FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8013_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8013"
    VALUE
    0x808034FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8014_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8014"
    VALUE
    0x808034FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8015_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8015"
    VALUE
    0x808034FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8016_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8016"
    VALUE
    0x808034FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8017_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8017"
    VALUE
    0x80803500
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8018_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8018"
    VALUE
    0x80803501
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8019_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8019"
    VALUE
    0x80803502
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x801a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x801a"
    VALUE
    0x80803503
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x801b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x801b"
    VALUE
    0x80803504
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x801c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x801c"
    VALUE
    0x80803505
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x801d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x801d"
    VALUE
    0x80803506
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x801e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x801e"
    VALUE
    0x80803507
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x801f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x801f"
    VALUE
    0x80803508
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8020_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8020"
    VALUE
    0x80803509
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8021_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8021"
    VALUE
    0x8080350A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8022_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8022"
    VALUE
    0x8080350B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8023_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8023"
    VALUE
    0x8080350C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8024_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8024"
    VALUE
    0x8080350D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8025_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8025"
    VALUE
    0x8080350E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8026_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8026"
    VALUE
    0x8080350F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8027_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8027"
    VALUE
    0x80803510
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8028_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8028"
    VALUE
    0x80803511
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8029_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8029"
    VALUE
    0x80803512
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x802a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x802a"
    VALUE
    0x80803513
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x802b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x802b"
    VALUE
    0x80803514
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x802c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x802c"
    VALUE
    0x80803515
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x802d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x802d"
    VALUE
    0x80803516
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x802e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x802e"
    VALUE
    0x80803517
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x802f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x802f"
    VALUE
    0x80803518
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8030_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8030"
    VALUE
    0x80803519
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8031_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8031"
    VALUE
    0x8080351A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8032_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8032"
    VALUE
    0x8080351B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8033_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8033"
    VALUE
    0x8080351C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8034_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8034"
    VALUE
    0x8080351D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8035_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8035"
    VALUE
    0x8080351E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8036_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8036"
    VALUE
    0x8080351F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8037_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8037"
    VALUE
    0x80803520
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8038_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8038"
    VALUE
    0x80803521
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8039_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8039"
    VALUE
    0x80803522
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x803a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x803a"
    VALUE
    0x80803523
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x803b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x803b"
    VALUE
    0x80803524
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x803c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x803c"
    VALUE
    0x80803525
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x803d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x803d"
    VALUE
    0x80803526
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x803e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x803e"
    VALUE
    0x80803527
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x803f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x803f"
    VALUE
    0x80803528
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8040_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8040"
    VALUE
    0x80803529
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8041_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8041"
    VALUE
    0x8080352A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8042_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8042"
    VALUE
    0x8080352B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8043_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8043"
    VALUE
    0x8080352C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8044_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8044"
    VALUE
    0x8080352D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8045_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8045"
    VALUE
    0x8080352E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8046_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8046"
    VALUE
    0x8080352F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8047_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8047"
    VALUE
    0x80803530
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8048_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8048"
    VALUE
    0x80803531
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8049_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8049"
    VALUE
    0x80803532
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x804a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x804a"
    VALUE
    0x80803533
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x804b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x804b"
    VALUE
    0x80803534
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x804c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x804c"
    VALUE
    0x80803535
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x804d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x804d"
    VALUE
    0x80803536
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x804e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x804e"
    VALUE
    0x80803537
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x804f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x804f"
    VALUE
    0x80803538
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8050_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8050"
    VALUE
    0x80803539
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8051_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8051"
    VALUE
    0x8080353A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8052_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8052"
    VALUE
    0x8080353B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8053_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8053"
    VALUE
    0x8080353C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8054_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8054"
    VALUE
    0x8080353D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8055_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8055"
    VALUE
    0x8080353E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8056_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8056"
    VALUE
    0x8080353F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8057_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8057"
    VALUE
    0x80803540
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8058_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8058"
    VALUE
    0x80803541
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8059_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8059"
    VALUE
    0x80803542
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x805a_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x805a"
    VALUE
    0x80803543
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x805b_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x805b"
    VALUE
    0x80803544
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x805c_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x805c"
    VALUE
    0x80803545
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x805d_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x805d"
    VALUE
    0x80803546
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x805e_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x805e"
    VALUE
    0x80803547
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x805f_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x805f"
    VALUE
    0x80803548
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8060_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8060"
    VALUE
    0x80803549
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8061_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8061"
    VALUE
    0x8080354A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8062_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8062"
    VALUE
    0x8080354B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8C01_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8C01"
    VALUE
    0x8080354C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8C02_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8C02"
    VALUE
    0x8080354D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_bds_NoDeb0x8C03_C
    "disable mask / Disable masks of check DFC_bds_NoDeb0x8C03"
    VALUE
    0x8080354E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetDataNoBuf_C
    "disable mask / Disable masks of check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x8080354F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetDataParam_C
    "disable mask / Disable masks of check DFC_rbr_canGetDataParam"
    VALUE
    0x80803550
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetDataboxNoInit_C
    "disable mask / Disable masks of check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x80803551
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canGetDataboxParam"
    VALUE
    0x80803552
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetRxBufStatusParam_C
    "disable mask / Disable masks of check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x80803553
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetStatusParam_C
    "disable mask / Disable masks of check DFC_rbr_canGetStatusParam"
    VALUE
    0x80803554
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canGetTxBufStatusParam_C
    "disable mask / Disable masks of check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80803555
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canInitParam_C
    "disable mask / Disable masks of check DFC_rbr_canInitParam"
    VALUE
    0x80803556
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canInitRxDataboxOverlap_C
    "disable mask / Disable masks of check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80803557
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canInitRxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80803558
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canInitTxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80803559
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canIpduGroupControl_C
    "disable mask / Disable masks of check DFC_rbr_canIpduGroupControl"
    VALUE
    0x8080355A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canIsDataboxFreeNoInit_C
    "disable mask / Disable masks of check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x8080355B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canIsDataboxFreeParam_C
    "disable mask / Disable masks of check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x8080355C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canIsTxEmptyParam_C
    "disable mask / Disable masks of check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x8080355D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegBusOffCallbInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x8080355E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegBusOffCallbParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x8080355F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxBufInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x80803560
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxBufOverlap_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x80803561
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxBufParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxBufParam"
    VALUE
    0x80803562
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxCallbInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x80803563
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxCallbParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80803564
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxDataboxInvNumb_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80803565
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxDataboxInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80803566
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxDataboxOverlap_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80803567
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegRxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80803568
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxBufInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80803569
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxBufOverlap_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x8080356A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxBufParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxBufParam"
    VALUE
    0x8080356B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxDataboxInvNumb_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x8080356C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxDataboxInvState_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x8080356D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxDataboxOverlap_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x8080356E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canRegTxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x8080356F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canResetTxBufParam_C
    "disable mask / Disable masks of check DFC_rbr_canResetTxBufParam"
    VALUE
    0x80803570
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canSendDataBufOvfl_C
    "disable mask / Disable masks of check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x80803571
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canSendDataParam_C
    "disable mask / Disable masks of check DFC_rbr_canSendDataParam"
    VALUE
    0x80803572
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canSendDataboxNoInit_C
    "disable mask / Disable masks of check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x80803573
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canSendDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80803574
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canSetTxCycleParam_C
    "disable mask / Disable masks of check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80803575
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canStartParam_C
    "disable mask / Disable masks of check DFC_rbr_canStartParam"
    VALUE
    0x80803576
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_canStopParam_C
    "disable mask / Disable masks of check DFC_rbr_canStopParam"
    VALUE
    0x80803577
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_can_ClearIpduGroup_C
    "disable mask / Disable masks of check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80803578
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_can_ReceiveSignal_C
    "disable mask / Disable masks of check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80803579
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_can_SendSignal_C
    "disable mask / Disable masks of check DFC_rbr_can_SendSignal"
    VALUE
    0x8080357A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_can_SetIpduGroup_C
    "disable mask / Disable masks of check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x8080357B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmDTCJ1939_C
    "disable mask / Disable masks of check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x8080357C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmDelDTCJ1939_C
    "disable mask / Disable masks of check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x8080357D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmDelErrors_C
    "disable mask / Disable masks of check DFC_rbr_dsmDelErrors"
    VALUE
    0x8080357E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmGetDFES_C
    "disable mask / Disable masks of check DFC_rbr_dsmGetDFES"
    VALUE
    0x8080357F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmGetDTCJ1939_C
    "disable mask / Disable masks of check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x80803580
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmGetErrors_C
    "disable mask / Disable masks of check DFC_rbr_dsmGetErrors"
    VALUE
    0x80803581
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmGetNumErrors_C
    "disable mask / Disable masks of check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x80803582
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmInitQueueOverflow_C
    "disable mask / Disable masks of check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x80803583
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmNumDTCJ1939_C
    "disable mask / Disable masks of check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x80803584
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmTesterror_C
    "disable mask / Disable masks of check DFC_rbr_dsmTesterror"
    VALUE
    0x80803585
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmUpdateDebError_C
    "disable mask / Disable masks of check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x80803586
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmUpdateError_C
    "disable mask / Disable masks of check DFC_rbr_dsmUpdateError"
    VALUE
    0x80803587
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmgetDFCStatus_C
    "disable mask / Disable masks of check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x80803588
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_dsmtestErrorDFC_C
    "disable mask / Disable masks of check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x80803589
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAi_C
    "disable mask / Disable masks of check DFC_rbr_inAi"
    VALUE
    0x8080358A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAic_C
    "disable mask / Disable masks of check DFC_rbr_inAic"
    VALUE
    0x8080358B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAicCfg_C
    "disable mask / Disable masks of check DFC_rbr_inAicCfg"
    VALUE
    0x8080358C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAicGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inAicGetStatus"
    VALUE
    0x8080358D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAid_C
    "disable mask / Disable masks of check DFC_rbr_inAid"
    VALUE
    0x8080358E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAidCfg_C
    "disable mask / Disable masks of check DFC_rbr_inAidCfg"
    VALUE
    0x8080358F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAiv_C
    "disable mask / Disable masks of check DFC_rbr_inAiv"
    VALUE
    0x80803590
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAivCfg_C
    "disable mask / Disable masks of check DFC_rbr_inAivCfg"
    VALUE
    0x80803591
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inAivGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inAivGetStatus"
    VALUE
    0x80803592
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inDi_C
    "disable mask / Disable masks of check DFC_rbr_inDi"
    VALUE
    0x80803593
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inFi_C
    "disable mask / Disable masks of check DFC_rbr_inFi"
    VALUE
    0x80803594
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inFiCfg_C
    "disable mask / Disable masks of check DFC_rbr_inFiCfg"
    VALUE
    0x80803595
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inFiGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inFiGetStatus"
    VALUE
    0x80803596
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inFi_Buffered_C
    "disable mask / Disable masks of check DFC_rbr_inFi_Buffered"
    VALUE
    0x80803597
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inPhase_C
    "disable mask / Disable masks of check DFC_rbr_inPhase"
    VALUE
    0x80803598
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inPhaseGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x80803599
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inPhaseResetCounter_C
    "disable mask / Disable masks of check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x8080359A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inRi_C
    "disable mask / Disable masks of check DFC_rbr_inRi"
    VALUE
    0x8080359B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inRiCfg_C
    "disable mask / Disable masks of check DFC_rbr_inRiCfg"
    VALUE
    0x8080359C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inRiCfgTemp_C
    "disable mask / Disable masks of check DFC_rbr_inRiCfgTemp"
    VALUE
    0x8080359D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inRiGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inRiGetStatus"
    VALUE
    0x8080359E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inRiGetTemp_C
    "disable mask / Disable masks of check DFC_rbr_inRiGetTemp"
    VALUE
    0x8080359F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentCopyFDFifo_C
    "disable mask / Disable masks of check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x808035A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentDisable_C
    "disable mask / Disable masks of check DFC_rbr_inSentDisable"
    VALUE
    0x808035A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentEnable_C
    "disable mask / Disable masks of check DFC_rbr_inSentEnable"
    VALUE
    0x808035A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentGetErrorStatus_C
    "disable mask / Disable masks of check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x808035A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentGetFD_C
    "disable mask / Disable masks of check DFC_rbr_inSentGetFD"
    VALUE
    0x808035A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentGetSD_C
    "disable mask / Disable masks of check DFC_rbr_inSentGetSD"
    VALUE
    0x808035A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentGetSDDatabox_C
    "disable mask / Disable masks of check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x808035A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_inSentGetStatus"
    VALUE
    0x808035A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentInitSDDatabox_C
    "disable mask / Disable masks of check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x808035A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentRegisterCopyFDFifo_C
    "disable mask / Disable masks of check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x808035A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentRegisterFDFifo_C
    "disable mask / Disable masks of check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x808035AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_inSentRegisterSDDataboxes_C
    "disable mask / Disable masks of check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x808035AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusCanRxBufferOverflow_C
    "disable mask / Disable masks of check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x808035AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusGetCaAddrParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x808035AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusGetDiagnosticParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x808035AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x808035AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusGetStatusParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x808035B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitCommCaMissing_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x808035B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitCommParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitCommParam"
    VALUE
    0x808035B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitCommState_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitCommState"
    VALUE
    0x808035B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitDiagnosticParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x808035B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitFailureListParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x808035B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitRxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x808035B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusInitTxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x808035B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegRxDataboxOverlap_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x808035B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegRxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x808035B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegRxDataboxState_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x808035BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegTxDataboxOverlap_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x808035BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegTxDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x808035BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegTxDataboxState_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x808035BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x808035BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegisterInstancesOverlap_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x808035BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegisterInstancesParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x808035C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusRegisterInstancesState_C
    "disable mask / Disable masks of check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x808035C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSendDataboxParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x808035C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSendRequestPGNParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x808035C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaAddrCaUsed_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x808035C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaAddrComm_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x808035C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaAddrInvCan_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x808035C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaAddrParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x808035C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaInfoParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x808035C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSetCaNameParam_C
    "disable mask / Disable masks of check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x808035C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_isobusSftyCanTxErr_C
    "disable mask / Disable masks of check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x808035CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_ReceiveSignal_C
    "disable mask / Disable masks of check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x808035CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_SendSignal_C
    "disable mask / Disable masks of check DFC_rbr_lin_SendSignal"
    VALUE
    0x808035CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_getStatus_C
    "disable mask / Disable masks of check DFC_rbr_lin_getStatus"
    VALUE
    0x808035CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_gotoSleep_C
    "disable mask / Disable masks of check DFC_rbr_lin_gotoSleep"
    VALUE
    0x808035CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_scheduleRequest_C
    "disable mask / Disable masks of check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x808035CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_lin_wakeUp_C
    "disable mask / Disable masks of check DFC_rbr_lin_wakeUp"
    VALUE
    0x808035D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memFlsCfgShr_C
    "disable mask / Disable masks of check DFC_rbr_memFlsCfgShr"
    VALUE
    0x808035D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_memGetStatus"
    VALUE
    0x808035D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memMarkBlock_C
    "disable mask / Disable masks of check DFC_rbr_memMarkBlock"
    VALUE
    0x808035D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadApi1Error_C
    "disable mask / Disable masks of check DFC_rbr_memReadApi1Error"
    VALUE
    0x808035D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadApi2Error_C
    "disable mask / Disable masks of check DFC_rbr_memReadApi2Error"
    VALUE
    0x808035D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadBlock_C
    "disable mask / Disable masks of check DFC_rbr_memReadBlock"
    VALUE
    0x808035D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadCalibInputError_C
    "disable mask / Disable masks of check DFC_rbr_memReadCalibInputError"
    VALUE
    0x808035D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadCalibOuputError_C
    "disable mask / Disable masks of check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x808035D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memReadSystemError_C
    "disable mask / Disable masks of check DFC_rbr_memReadSystemError"
    VALUE
    0x808035D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_memWriteBlock_C
    "disable mask / Disable masks of check DFC_rbr_memWriteBlock"
    VALUE
    0x808035DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_moOV_FirstConstADC_C
    "disable mask / Disable masks of check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x808035DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_moOV_SecondConstADC_C
    "disable mask / Disable masks of check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x808035DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_moUV_FirstConstADC_C
    "disable mask / Disable masks of check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x808035DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_moUV_SecondConstADC_C
    "disable mask / Disable masks of check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x808035DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_INH_C
    "disable mask / Disable masks of check DFC_rbr_mo_INH"
    VALUE
    0x808035DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_INHLatch_C
    "disable mask / Disable masks of check DFC_rbr_mo_INHLatch"
    VALUE
    0x808035E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_adcPDD_fail_C
    "disable mask / Disable masks of check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x808035E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_memoryProtection_err_C
    "disable mask / Disable masks of check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x808035E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02OC_C
    "disable mask / Disable masks of check DFC_rbr_outA02OC"
    VALUE
    0x808035E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA02Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA02Unintended"
    VALUE
    0x808035E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03OC_C
    "disable mask / Disable masks of check DFC_rbr_outA03OC"
    VALUE
    0x808035E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA03Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA03Unintended"
    VALUE
    0x808035E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04OC_C
    "disable mask / Disable masks of check DFC_rbr_outA04OC"
    VALUE
    0x808035E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA04Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA04Unintended"
    VALUE
    0x808035E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05OC_C
    "disable mask / Disable masks of check DFC_rbr_outA05OC"
    VALUE
    0x808035E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA05Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA05Unintended"
    VALUE
    0x808035EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07OC_C
    "disable mask / Disable masks of check DFC_rbr_outA07OC"
    VALUE
    0x808035EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA07Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA07Unintended"
    VALUE
    0x808035EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08OC_C
    "disable mask / Disable masks of check DFC_rbr_outA08OC"
    VALUE
    0x808035ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA08Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA08Unintended"
    VALUE
    0x808035EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09OC_C
    "disable mask / Disable masks of check DFC_rbr_outA09OC"
    VALUE
    0x808035EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA09Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA09Unintended"
    VALUE
    0x808035F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10OC_C
    "disable mask / Disable masks of check DFC_rbr_outA10OC"
    VALUE
    0x808035F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA10Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA10Unintended"
    VALUE
    0x808035F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17OC_C
    "disable mask / Disable masks of check DFC_rbr_outA17OC"
    VALUE
    0x808035F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA17Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA17Unintended"
    VALUE
    0x808035F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18OC_C
    "disable mask / Disable masks of check DFC_rbr_outA18OC"
    VALUE
    0x808035F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA18Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA18Unintended"
    VALUE
    0x808035F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19OC_C
    "disable mask / Disable masks of check DFC_rbr_outA19OC"
    VALUE
    0x808035F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA19Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA19Unintended"
    VALUE
    0x808035F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20OC_C
    "disable mask / Disable masks of check DFC_rbr_outA20OC"
    VALUE
    0x808035F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA20Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA20Unintended"
    VALUE
    0x808035FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31OC_C
    "disable mask / Disable masks of check DFC_rbr_outA31OC"
    VALUE
    0x808035FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA31Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA31Unintended"
    VALUE
    0x808035FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32OC_C
    "disable mask / Disable masks of check DFC_rbr_outA32OC"
    VALUE
    0x808035FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA32Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA32Unintended"
    VALUE
    0x808035FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33OC_C
    "disable mask / Disable masks of check DFC_rbr_outA33OC"
    VALUE
    0x808035FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA33Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA33Unintended"
    VALUE
    0x80803600
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34OC_C
    "disable mask / Disable masks of check DFC_rbr_outA34OC"
    VALUE
    0x80803601
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA34Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA34Unintended"
    VALUE
    0x80803602
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35OC_C
    "disable mask / Disable masks of check DFC_rbr_outA35OC"
    VALUE
    0x80803603
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA35Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA35Unintended"
    VALUE
    0x80803604
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46OC_C
    "disable mask / Disable masks of check DFC_rbr_outA46OC"
    VALUE
    0x80803605
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA46Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA46Unintended"
    VALUE
    0x80803606
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47OC_C
    "disable mask / Disable masks of check DFC_rbr_outA47OC"
    VALUE
    0x80803607
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA47Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA47Unintended"
    VALUE
    0x80803608
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48OC_C
    "disable mask / Disable masks of check DFC_rbr_outA48OC"
    VALUE
    0x80803609
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA48Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA48Unintended"
    VALUE
    0x8080360A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51OC_C
    "disable mask / Disable masks of check DFC_rbr_outA51OC"
    VALUE
    0x8080360B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA51Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA51Unintended"
    VALUE
    0x8080360C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52OC_C
    "disable mask / Disable masks of check DFC_rbr_outA52OC"
    VALUE
    0x8080360D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA52Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA52Unintended"
    VALUE
    0x8080360E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53OC_C
    "disable mask / Disable masks of check DFC_rbr_outA53OC"
    VALUE
    0x8080360F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA53Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA53Unintended"
    VALUE
    0x80803610
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54OC_C
    "disable mask / Disable masks of check DFC_rbr_outA54OC"
    VALUE
    0x80803611
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outA54Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outA54Unintended"
    VALUE
    0x80803612
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAov_C
    "disable mask / Disable masks of check DFC_rbr_outAov"
    VALUE
    0x80803613
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAovCfg_C
    "disable mask / Disable masks of check DFC_rbr_outAovCfg"
    VALUE
    0x80803614
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAovCfgPI_C
    "disable mask / Disable masks of check DFC_rbr_outAovCfgPI"
    VALUE
    0x80803615
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAovGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_outAovGetStatus"
    VALUE
    0x80803616
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAovGetVoltage_C
    "disable mask / Disable masks of check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80803617
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outAovResetError_C
    "disable mask / Disable masks of check DFC_rbr_outAovResetError"
    VALUE
    0x80803618
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDo_C
    "disable mask / Disable masks of check DFC_rbr_outDo"
    VALUE
    0x80803619
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDoCfgPwrLs_C
    "disable mask / Disable masks of check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x8080361A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDoDisable_C
    "disable mask / Disable masks of check DFC_rbr_outDoDisable"
    VALUE
    0x8080361B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDoGetCurrent_C
    "disable mask / Disable masks of check DFC_rbr_outDoGetCurrent"
    VALUE
    0x8080361C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDoGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_outDoGetStatus"
    VALUE
    0x8080361D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outDoResetError_C
    "disable mask / Disable masks of check DFC_rbr_outDoResetError"
    VALUE
    0x8080361E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07OC_C
    "disable mask / Disable masks of check DFC_rbr_outK07OC"
    VALUE
    0x8080361F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK07Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK07Unintended"
    VALUE
    0x80803620
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08OC_C
    "disable mask / Disable masks of check DFC_rbr_outK08OC"
    VALUE
    0x80803621
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK08Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK08Unintended"
    VALUE
    0x80803622
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09OC_C
    "disable mask / Disable masks of check DFC_rbr_outK09OC"
    VALUE
    0x80803623
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK09Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK09Unintended"
    VALUE
    0x80803624
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12OC_C
    "disable mask / Disable masks of check DFC_rbr_outK12OC"
    VALUE
    0x80803625
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK12Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK12Unintended"
    VALUE
    0x80803626
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13OC_C
    "disable mask / Disable masks of check DFC_rbr_outK13OC"
    VALUE
    0x80803627
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK13Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK13Unintended"
    VALUE
    0x80803628
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14OC_C
    "disable mask / Disable masks of check DFC_rbr_outK14OC"
    VALUE
    0x80803629
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK14Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK14Unintended"
    VALUE
    0x8080362A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15OC_C
    "disable mask / Disable masks of check DFC_rbr_outK15OC"
    VALUE
    0x8080362B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK15Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK15Unintended"
    VALUE
    0x8080362C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16OC_C
    "disable mask / Disable masks of check DFC_rbr_outK16OC"
    VALUE
    0x8080362D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK16Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK16Unintended"
    VALUE
    0x8080362E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17OC_C
    "disable mask / Disable masks of check DFC_rbr_outK17OC"
    VALUE
    0x8080362F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK17Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK17Unintended"
    VALUE
    0x80803630
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29OC_C
    "disable mask / Disable masks of check DFC_rbr_outK29OC"
    VALUE
    0x80803631
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK29Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK29Unintended"
    VALUE
    0x80803632
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51OC_C
    "disable mask / Disable masks of check DFC_rbr_outK51OC"
    VALUE
    0x80803633
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK51Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK51Unintended"
    VALUE
    0x80803634
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73OC_C
    "disable mask / Disable masks of check DFC_rbr_outK73OC"
    VALUE
    0x80803635
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outK73Unintended_C
    "disable mask / Disable masks of check DFC_rbr_outK73Unintended"
    VALUE
    0x80803636
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPo_C
    "disable mask / Disable masks of check DFC_rbr_outPo"
    VALUE
    0x80803637
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoCfg_C
    "disable mask / Disable masks of check DFC_rbr_outPoCfg"
    VALUE
    0x80803638
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoCfgPeriod_C
    "disable mask / Disable masks of check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80803639
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoCfgPwrLs_C
    "disable mask / Disable masks of check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x8080363A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoDisable_C
    "disable mask / Disable masks of check DFC_rbr_outPoDisable"
    VALUE
    0x8080363B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoGetCurrent_C
    "disable mask / Disable masks of check DFC_rbr_outPoGetCurrent"
    VALUE
    0x8080363C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_outPoGetStatus"
    VALUE
    0x8080363D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoResetError_C
    "disable mask / Disable masks of check DFC_rbr_outPoResetError"
    VALUE
    0x8080363E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPoc_C
    "disable mask / Disable masks of check DFC_rbr_outPoc"
    VALUE
    0x8080363F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPocCfg_C
    "disable mask / Disable masks of check DFC_rbr_outPocCfg"
    VALUE
    0x80803640
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPocCfgDither_C
    "disable mask / Disable masks of check DFC_rbr_outPocCfgDither"
    VALUE
    0x80803641
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPocCfgPI_C
    "disable mask / Disable masks of check DFC_rbr_outPocCfgPI"
    VALUE
    0x80803642
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPod_C
    "disable mask / Disable masks of check DFC_rbr_outPod"
    VALUE
    0x80803643
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPodCfg_C
    "disable mask / Disable masks of check DFC_rbr_outPodCfg"
    VALUE
    0x80803644
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_outPodCfgPeriod_C
    "disable mask / Disable masks of check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80803645
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_rsmFfiApiCallErr_C
    "disable mask / Disable masks of check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80803646
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safout_C
    "disable mask / Disable masks of check DFC_rbr_safout"
    VALUE
    0x80803647
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutCfg_C
    "disable mask / Disable masks of check DFC_rbr_safoutCfg"
    VALUE
    0x80803648
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl1_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl1"
    VALUE
    0x80803649
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl10_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl10"
    VALUE
    0x8080364A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl10Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x8080364B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl10OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl10OR"
    VALUE
    0x8080364C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl11_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl11"
    VALUE
    0x8080364D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl11Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x8080364E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl11OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl11OR"
    VALUE
    0x8080364F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl12_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl12"
    VALUE
    0x80803650
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl12Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x80803651
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl12OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl12OR"
    VALUE
    0x80803652
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl13_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl13"
    VALUE
    0x80803653
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl13Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80803654
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl13OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80803655
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl14_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl14"
    VALUE
    0x80803656
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl14Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80803657
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl14OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80803658
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl15_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl15"
    VALUE
    0x80803659
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl15Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x8080365A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl15OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl15OR"
    VALUE
    0x8080365B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl16_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl16"
    VALUE
    0x8080365C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl16Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x8080365D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl16OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl16OR"
    VALUE
    0x8080365E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl17_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl17"
    VALUE
    0x8080365F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl17Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x80803660
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl17OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl17OR"
    VALUE
    0x80803661
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl18_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl18"
    VALUE
    0x80803662
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl18Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x80803663
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl18OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl18OR"
    VALUE
    0x80803664
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl1Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x80803665
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl1OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl1OR"
    VALUE
    0x80803666
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl2_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl2"
    VALUE
    0x80803667
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl2Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x80803668
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl2OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl2OR"
    VALUE
    0x80803669
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl3_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl3"
    VALUE
    0x8080366A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl3Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x8080366B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl3OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl3OR"
    VALUE
    0x8080366C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl4_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl4"
    VALUE
    0x8080366D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl4Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x8080366E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl4OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl4OR"
    VALUE
    0x8080366F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl5_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl5"
    VALUE
    0x80803670
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl5Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x80803671
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl5OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl5OR"
    VALUE
    0x80803672
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl6_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl6"
    VALUE
    0x80803673
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl6Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x80803674
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl6OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl6OR"
    VALUE
    0x80803675
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl7_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl7"
    VALUE
    0x80803676
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl7Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x80803677
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl7OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl7OR"
    VALUE
    0x80803678
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl8_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl8"
    VALUE
    0x80803679
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl8Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x8080367A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl8OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl8OR"
    VALUE
    0x8080367B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl9_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl9"
    VALUE
    0x8080367C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl9Dev_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x8080367D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutChnl9OR_C
    "disable mask / Disable masks of check DFC_rbr_safoutChnl9OR"
    VALUE
    0x8080367E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutDevError_C
    "disable mask / Disable masks of check DFC_rbr_safoutDevError"
    VALUE
    0x8080367F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutGetStatus_C
    "disable mask / Disable masks of check DFC_rbr_safoutGetStatus"
    VALUE
    0x80803680
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutIgnoreError_C
    "disable mask / Disable masks of check DFC_rbr_safoutIgnoreError"
    VALUE
    0x80803681
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutResetError_C
    "disable mask / Disable masks of check DFC_rbr_safoutResetError"
    VALUE
    0x80803682
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safoutUnlock_C
    "disable mask / Disable masks of check DFC_rbr_safoutUnlock"
    VALUE
    0x80803683
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_safout_cfgDiag_C
    "disable mask / Disable masks of check DFC_rbr_safout_cfgDiag"
    VALUE
    0x80803684
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secAccessDenied_RC_C
    "disable mask / Disable masks of check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x80803685
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secAccessDenied_WDBI_C
    "disable mask / Disable masks of check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x80803686
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secEvalRespKey_C
    "disable mask / Disable masks of check DFC_rbr_secEvalRespKey"
    VALUE
    0x80803687
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secFlashingFailure_C
    "disable mask / Disable masks of check DFC_rbr_secFlashingFailure"
    VALUE
    0x80803688
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secGetLevel_C
    "disable mask / Disable masks of check DFC_rbr_secGetLevel"
    VALUE
    0x80803689
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secGetRnd_C
    "disable mask / Disable masks of check DFC_rbr_secGetRnd"
    VALUE
    0x8080368A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secGetSeed_C
    "disable mask / Disable masks of check DFC_rbr_secGetSeed"
    VALUE
    0x8080368B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secInvalidPassword_C
    "disable mask / Disable masks of check DFC_rbr_secInvalidPassword"
    VALUE
    0x8080368C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secIsRequestAllowed_C
    "disable mask / Disable masks of check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x8080368D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secResetLevel_C
    "disable mask / Disable masks of check DFC_rbr_secResetLevel"
    VALUE
    0x8080368E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secSaveSecret_C
    "disable mask / Disable masks of check DFC_rbr_secSaveSecret"
    VALUE
    0x8080368F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_secSetLevel_C
    "disable mask / Disable masks of check DFC_rbr_secSetLevel"
    VALUE
    0x80803690
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysAit_C
    "disable mask / Disable masks of check DFC_rbr_sysAit"
    VALUE
    0x80803691
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysAiv_C
    "disable mask / Disable masks of check DFC_rbr_sysAiv"
    VALUE
    0x80803692
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysDi_C
    "disable mask / Disable masks of check DFC_rbr_sysDi"
    VALUE
    0x80803693
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysDo_C
    "disable mask / Disable masks of check DFC_rbr_sysDo"
    VALUE
    0x80803694
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysGetVss_C
    "disable mask / Disable masks of check DFC_rbr_sysGetVss"
    VALUE
    0x80803695
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysInit_C
    "disable mask / Disable masks of check DFC_rbr_sysInit"
    VALUE
    0x80803696
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysOperHrIntegrityErr_C
    "disable mask / Disable masks of check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x80803697
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysOperHrsSaturated_C
    "disable mask / Disable masks of check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x80803698
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sysSetVss_C
    "disable mask / Disable masks of check DFC_rbr_sysSetVss"
    VALUE
    0x80803699
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sys_coreload_C
    "disable mask / Disable masks of check DFC_rbr_sys_coreload"
    VALUE
    0x8080369A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_sys_taskload_C
    "disable mask / Disable masks of check DFC_rbr_sys_taskload"
    VALUE
    0x8080369B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VSS1_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x8080369C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_OV_VSS2_C
    "disable mask / Disable masks of check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x8080369D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VSS1_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x8080369E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_rbr_mo_UV_VSS2_C
    "disable mask / Disable masks of check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x8080369F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "disable mask / Disable masks of check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x808036A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "disable mask / Disable masks of check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x808036A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "disable mask / Disable masks of check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x808036A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "disable mask / Disable masks of check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x808036A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "disable mask / Disable masks of check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x808036A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_CAN_E_TIMEOUT_C
    "disable mask / Disable masks of check DFC_CAN_E_TIMEOUT"
    VALUE
    0x808036A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x808036A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x808036A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "disable mask / Disable masks of check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x808036A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_DisblMsk2.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
