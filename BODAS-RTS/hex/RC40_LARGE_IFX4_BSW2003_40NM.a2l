    "fault class per DFC / Fault class for check DFC_rbr_inK44SCG"
    VALUE
    0x808014BF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK44ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x808014C0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45AicSCB"
    VALUE
    0x808014C1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45AicSCG"
    VALUE
    0x808014C2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45OR"
    VALUE
    0x808014C3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45SCB"
    VALUE
    0x808014C4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45SCG"
    VALUE
    0x808014C5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK45ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x808014C6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK52OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK52OR"
    VALUE
    0x808014C7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK52SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK52SCB"
    VALUE
    0x808014C8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK52SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK52SCG"
    VALUE
    0x808014C9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK53OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK53OR"
    VALUE
    0x808014CA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK53SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK53SCB"
    VALUE
    0x808014CB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK53SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK53SCG"
    VALUE
    0x808014CC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54AicSCB"
    VALUE
    0x808014CD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54AicSCG"
    VALUE
    0x808014CE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54OR"
    VALUE
    0x808014CF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54SCB"
    VALUE
    0x808014D0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54SCG"
    VALUE
    0x808014D1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK54ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x808014D2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55AicSCB"
    VALUE
    0x808014D3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55AicSCG"
    VALUE
    0x808014D4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55OR"
    VALUE
    0x808014D5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55SCB"
    VALUE
    0x808014D6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55SCG"
    VALUE
    0x808014D7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK55ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x808014D8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK56OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK56OR"
    VALUE
    0x808014D9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK56SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK56SCB"
    VALUE
    0x808014DA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK56SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK56SCG"
    VALUE
    0x808014DB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK57OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK57OR"
    VALUE
    0x808014DC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK57SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK57SCB"
    VALUE
    0x808014DD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK57SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK57SCG"
    VALUE
    0x808014DE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK58OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK58OR"
    VALUE
    0x808014DF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK58SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK58SCB"
    VALUE
    0x808014E0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK58SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK58SCG"
    VALUE
    0x808014E1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK59OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK59OR"
    VALUE
    0x808014E2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK59SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK59SCB"
    VALUE
    0x808014E3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK59SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK59SCG"
    VALUE
    0x808014E4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK60OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK60OR"
    VALUE
    0x808014E5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK60SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK60SCB"
    VALUE
    0x808014E6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK60SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK60SCG"
    VALUE
    0x808014E7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61AicSCB"
    VALUE
    0x808014E8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61AicSCG"
    VALUE
    0x808014E9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61OR"
    VALUE
    0x808014EA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61SCB"
    VALUE
    0x808014EB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61SCG"
    VALUE
    0x808014EC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK61ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x808014ED
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK62OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK62OR"
    VALUE
    0x808014EE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK62SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK62SCB"
    VALUE
    0x808014EF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK62SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK62SCG"
    VALUE
    0x808014F0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63AicSCB"
    VALUE
    0x808014F1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63AicSCG"
    VALUE
    0x808014F2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63OR"
    VALUE
    0x808014F3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63SCB"
    VALUE
    0x808014F4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63SCG"
    VALUE
    0x808014F5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK63ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x808014F6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64AicSCB"
    VALUE
    0x808014F7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64AicSCG"
    VALUE
    0x808014F8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64OR"
    VALUE
    0x808014F9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64SCB"
    VALUE
    0x808014FA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64SCG"
    VALUE
    0x808014FB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK64ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x808014FC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65AicSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65AicSCB"
    VALUE
    0x808014FD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65AicSCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65AicSCG"
    VALUE
    0x808014FE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65OR"
    VALUE
    0x808014FF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65SCB"
    VALUE
    0x80801500
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65SCG"
    VALUE
    0x80801501
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK65ShuntSCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80801502
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK74OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK74OR"
    VALUE
    0x80801503
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK74SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK74SCB"
    VALUE
    0x80801504
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK74SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK74SCG"
    VALUE
    0x80801505
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK75OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK75OR"
    VALUE
    0x80801506
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK75SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK75SCB"
    VALUE
    0x80801507
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK75SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK75SCG"
    VALUE
    0x80801508
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK76OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK76OR"
    VALUE
    0x80801509
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK76SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK76SCB"
    VALUE
    0x8080150A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK76SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK76SCG"
    VALUE
    0x8080150B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK77OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK77OR"
    VALUE
    0x8080150C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK77SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK77SCB"
    VALUE
    0x8080150D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK77SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK77SCG"
    VALUE
    0x8080150E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK78OR_C
    "fault class per DFC / Fault class for check DFC_rbr_inK78OR"
    VALUE
    0x8080150F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK78SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_inK78SCB"
    VALUE
    0x80801510
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inK78SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_inK78SCG"
    VALUE
    0x80801511
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_DvUBAT_FWs_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80801512
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OVErr_VPR6_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80801513
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OVWarn_VPR6_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80801514
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80801515
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80801516
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_UBAT_MON_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80801517
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80801518
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80801519
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_UBRM24_MON_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x8080151A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VDD5_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x8080151B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VDD5_IN_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x8080151C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VPR6_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x8080151D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VSS3_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x8080151E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VSS4_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x8080151F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_Temp1_HTErr_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80801520
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_Temp1_HTWarn_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80801521
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_Temp2_HTErr_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80801522
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_Temp2_HTWarn_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80801523
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80801524
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80801525
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VDD5_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80801526
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VDD5_IN_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80801527
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VPR6_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80801528
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VSS3_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80801529
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VSS4_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x8080152A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA01OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA01OL"
    VALUE
    0x8080152B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA01OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA01OT"
    VALUE
    0x8080152C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA01SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA01SCB"
    VALUE
    0x8080152D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA01SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA01SCG"
    VALUE
    0x8080152E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02OL"
    VALUE
    0x8080152F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02OR"
    VALUE
    0x80801530
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02OT"
    VALUE
    0x80801531
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02SCB"
    VALUE
    0x80801532
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02SCG"
    VALUE
    0x80801533
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03OL"
    VALUE
    0x80801534
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03OT"
    VALUE
    0x80801535
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03SCB"
    VALUE
    0x80801536
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03SCG"
    VALUE
    0x80801537
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04OL"
    VALUE
    0x80801538
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04OT"
    VALUE
    0x80801539
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04SCB"
    VALUE
    0x8080153A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04SCG"
    VALUE
    0x8080153B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05OL"
    VALUE
    0x8080153C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05OR"
    VALUE
    0x8080153D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05OT"
    VALUE
    0x8080153E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05SCB"
    VALUE
    0x8080153F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05SCG"
    VALUE
    0x80801540
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA06OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA06OL"
    VALUE
    0x80801541
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA06OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA06OR"
    VALUE
    0x80801542
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA06OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA06OT"
    VALUE
    0x80801543
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA06SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA06SCB"
    VALUE
    0x80801544
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA06SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA06SCG"
    VALUE
    0x80801545
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07OL"
    VALUE
    0x80801546
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07OT"
    VALUE
    0x80801547
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07SCB"
    VALUE
    0x80801548
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07SCG"
    VALUE
    0x80801549
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08OL"
    VALUE
    0x8080154A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08OT"
    VALUE
    0x8080154B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08SCB"
    VALUE
    0x8080154C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08SCG"
    VALUE
    0x8080154D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09OL"
    VALUE
    0x8080154E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09OR"
    VALUE
    0x8080154F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09OT"
    VALUE
    0x80801550
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09SCB"
    VALUE
    0x80801551
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09SCG"
    VALUE
    0x80801552
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10OL"
    VALUE
    0x80801553
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10OT"
    VALUE
    0x80801554
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10SCB"
    VALUE
    0x80801555
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10SCG"
    VALUE
    0x80801556
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA11OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA11OL"
    VALUE
    0x80801557
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA11OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA11OT"
    VALUE
    0x80801558
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA11SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA11SCB"
    VALUE
    0x80801559
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA11SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA11SCG"
    VALUE
    0x8080155A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA12OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA12OR"
    VALUE
    0x8080155B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA12SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA12SCB"
    VALUE
    0x8080155C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA12SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA12SCG"
    VALUE
    0x8080155D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA16OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA16OL"
    VALUE
    0x8080155E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA16OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA16OT"
    VALUE
    0x8080155F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA16SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA16SCB"
    VALUE
    0x80801560
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA16SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA16SCG"
    VALUE
    0x80801561
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17OL"
    VALUE
    0x80801562
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17OR"
    VALUE
    0x80801563
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17OT"
    VALUE
    0x80801564
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17SCB"
    VALUE
    0x80801565
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17SCG"
    VALUE
    0x80801566
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18OL"
    VALUE
    0x80801567
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18OT"
    VALUE
    0x80801568
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18SCB"
    VALUE
    0x80801569
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18SCG"
    VALUE
    0x8080156A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19OL"
    VALUE
    0x8080156B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19OR"
    VALUE
    0x8080156C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19OT"
    VALUE
    0x8080156D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19SCB"
    VALUE
    0x8080156E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19SCG"
    VALUE
    0x8080156F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20OL"
    VALUE
    0x80801570
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20OR"
    VALUE
    0x80801571
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20OT"
    VALUE
    0x80801572
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20SCB"
    VALUE
    0x80801573
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20SCG"
    VALUE
    0x80801574
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31OL"
    VALUE
    0x80801575
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31OR"
    VALUE
    0x80801576
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31OT"
    VALUE
    0x80801577
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31SCB"
    VALUE
    0x80801578
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31SCG"
    VALUE
    0x80801579
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32OL"
    VALUE
    0x8080157A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32OR"
    VALUE
    0x8080157B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32OT"
    VALUE
    0x8080157C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32SCB"
    VALUE
    0x8080157D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32SCG"
    VALUE
    0x8080157E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33OL"
    VALUE
    0x8080157F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33OR"
    VALUE
    0x80801580
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33OT"
    VALUE
    0x80801581
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33SCB"
    VALUE
    0x80801582
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33SCG"
    VALUE
    0x80801583
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34OL"
    VALUE
    0x80801584
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34OR"
    VALUE
    0x80801585
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34OT"
    VALUE
    0x80801586
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34SCB"
    VALUE
    0x80801587
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34SCG"
    VALUE
    0x80801588
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35OL"
    VALUE
    0x80801589
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35OR"
    VALUE
    0x8080158A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35OT"
    VALUE
    0x8080158B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35SCB"
    VALUE
    0x8080158C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35SCG"
    VALUE
    0x8080158D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46OL"
    VALUE
    0x8080158E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46OR"
    VALUE
    0x8080158F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46OT"
    VALUE
    0x80801590
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46SCB"
    VALUE
    0x80801591
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46SCG"
    VALUE
    0x80801592
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47OL"
    VALUE
    0x80801593
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47OR"
    VALUE
    0x80801594
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47OT"
    VALUE
    0x80801595
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47SCB"
    VALUE
    0x80801596
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47SCG"
    VALUE
    0x80801597
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48OL"
    VALUE
    0x80801598
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48OR"
    VALUE
    0x80801599
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48OT"
    VALUE
    0x8080159A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48SCB"
    VALUE
    0x8080159B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48SCG"
    VALUE
    0x8080159C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA49OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA49OL"
    VALUE
    0x8080159D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA49OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA49OT"
    VALUE
    0x8080159E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA49SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA49SCB"
    VALUE
    0x8080159F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA49SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA49SCG"
    VALUE
    0x808015A0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA50OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA50OL"
    VALUE
    0x808015A1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA50OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA50OT"
    VALUE
    0x808015A2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA50SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA50SCB"
    VALUE
    0x808015A3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA50SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA50SCG"
    VALUE
    0x808015A4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51OL"
    VALUE
    0x808015A5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51OR"
    VALUE
    0x808015A6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51OT"
    VALUE
    0x808015A7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51SCB"
    VALUE
    0x808015A8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51SCG"
    VALUE
    0x808015A9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52OL"
    VALUE
    0x808015AA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52OR"
    VALUE
    0x808015AB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52OT"
    VALUE
    0x808015AC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52SCB"
    VALUE
    0x808015AD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52SCG"
    VALUE
    0x808015AE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53OL"
    VALUE
    0x808015AF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53OR"
    VALUE
    0x808015B0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53OT"
    VALUE
    0x808015B1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53SCB"
    VALUE
    0x808015B2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53SCG"
    VALUE
    0x808015B3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54OL"
    VALUE
    0x808015B4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54OR"
    VALUE
    0x808015B5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54OT"
    VALUE
    0x808015B6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54SCB"
    VALUE
    0x808015B7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54SCG"
    VALUE
    0x808015B8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA55OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA55OL"
    VALUE
    0x808015B9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA55OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA55OT"
    VALUE
    0x808015BA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA55SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA55SCB"
    VALUE
    0x808015BB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA55SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA55SCG"
    VALUE
    0x808015BC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA56OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA56OL"
    VALUE
    0x808015BD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA56OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA56OT"
    VALUE
    0x808015BE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA56SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA56SCB"
    VALUE
    0x808015BF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA56SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA56SCG"
    VALUE
    0x808015C0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA58OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outA58OL"
    VALUE
    0x808015C1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA58OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outA58OT"
    VALUE
    0x808015C2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA58SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outA58SCB"
    VALUE
    0x808015C3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA58SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outA58SCG"
    VALUE
    0x808015C4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07OL"
    VALUE
    0x808015C5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07OR"
    VALUE
    0x808015C6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07OT"
    VALUE
    0x808015C7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07SCB"
    VALUE
    0x808015C8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07SCG"
    VALUE
    0x808015C9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08OL"
    VALUE
    0x808015CA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08OR"
    VALUE
    0x808015CB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08OT"
    VALUE
    0x808015CC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08SCB"
    VALUE
    0x808015CD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08SCG"
    VALUE
    0x808015CE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09OL"
    VALUE
    0x808015CF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09OR"
    VALUE
    0x808015D0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09OT"
    VALUE
    0x808015D1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09SCB"
    VALUE
    0x808015D2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09SCG"
    VALUE
    0x808015D3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12OL"
    VALUE
    0x808015D4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12OT"
    VALUE
    0x808015D5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12SCB"
    VALUE
    0x808015D6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12SCG"
    VALUE
    0x808015D7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13OL"
    VALUE
    0x808015D8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13OT"
    VALUE
    0x808015D9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13SCB"
    VALUE
    0x808015DA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13SCG"
    VALUE
    0x808015DB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14OL"
    VALUE
    0x808015DC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14OR"
    VALUE
    0x808015DD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14OT"
    VALUE
    0x808015DE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14SCB"
    VALUE
    0x808015DF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14SCG"
    VALUE
    0x808015E0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15OL"
    VALUE
    0x808015E1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15OR"
    VALUE
    0x808015E2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15OT"
    VALUE
    0x808015E3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15SCB"
    VALUE
    0x808015E4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15SCG"
    VALUE
    0x808015E5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16OL"
    VALUE
    0x808015E6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16OR"
    VALUE
    0x808015E7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16OT"
    VALUE
    0x808015E8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16SCB"
    VALUE
    0x808015E9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16SCG"
    VALUE
    0x808015EA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17OL"
    VALUE
    0x808015EB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17OR"
    VALUE
    0x808015EC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17OT"
    VALUE
    0x808015ED
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17SCB"
    VALUE
    0x808015EE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17SCG"
    VALUE
    0x808015EF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK25OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK25OR"
    VALUE
    0x808015F0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK25SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK25SCB"
    VALUE
    0x808015F1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK25SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK25SCG"
    VALUE
    0x808015F2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29OL"
    VALUE
    0x808015F3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29OR"
    VALUE
    0x808015F4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29OT"
    VALUE
    0x808015F5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29SCB"
    VALUE
    0x808015F6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29SCG"
    VALUE
    0x808015F7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51OL"
    VALUE
    0x808015F8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51OT"
    VALUE
    0x808015F9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51SCB"
    VALUE
    0x808015FA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51SCG"
    VALUE
    0x808015FB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK62OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK62OR"
    VALUE
    0x808015FC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK62SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK62SCB"
    VALUE
    0x808015FD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK62SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK62SCG"
    VALUE
    0x808015FE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73OL"
    VALUE
    0x808015FF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73OR_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73OR"
    VALUE
    0x80801600
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73OT"
    VALUE
    0x80801601
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73SCB"
    VALUE
    0x80801602
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73SCG"
    VALUE
    0x80801603
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK80OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK80OL"
    VALUE
    0x80801604
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK80OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK80OT"
    VALUE
    0x80801605
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK80SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK80SCB"
    VALUE
    0x80801606
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK80SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK80SCG"
    VALUE
    0x80801607
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK81OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK81OL"
    VALUE
    0x80801608
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK81OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK81OT"
    VALUE
    0x80801609
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK81SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK81SCB"
    VALUE
    0x8080160A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK81SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK81SCG"
    VALUE
    0x8080160B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK82OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK82OL"
    VALUE
    0x8080160C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK82OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK82OT"
    VALUE
    0x8080160D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK82SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK82SCB"
    VALUE
    0x8080160E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK82SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK82SCG"
    VALUE
    0x8080160F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK83OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK83OL"
    VALUE
    0x80801610
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK83OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK83OT"
    VALUE
    0x80801611
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK83SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK83SCB"
    VALUE
    0x80801612
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK83SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK83SCG"
    VALUE
    0x80801613
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK84OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK84OL"
    VALUE
    0x80801614
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK84OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK84OT"
    VALUE
    0x80801615
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK84SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK84SCB"
    VALUE
    0x80801616
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK84SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK84SCG"
    VALUE
    0x80801617
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK85OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK85OL"
    VALUE
    0x80801618
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK85OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK85OT"
    VALUE
    0x80801619
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK85SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK85SCB"
    VALUE
    0x8080161A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK85SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK85SCG"
    VALUE
    0x8080161B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK86OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK86OL"
    VALUE
    0x8080161C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK86OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK86OT"
    VALUE
    0x8080161D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK86SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK86SCB"
    VALUE
    0x8080161E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK86SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK86SCG"
    VALUE
    0x8080161F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK87OL_C
    "fault class per DFC / Fault class for check DFC_rbr_outK87OL"
    VALUE
    0x80801620
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK87OT_C
    "fault class per DFC / Fault class for check DFC_rbr_outK87OT"
    VALUE
    0x80801621
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK87SCB_C
    "fault class per DFC / Fault class for check DFC_rbr_outK87SCB"
    VALUE
    0x80801622
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK87SCG_C
    "fault class per DFC / Fault class for check DFC_rbr_outK87SCG"
    VALUE
    0x80801623
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_DSMDummy_C
    "fault class per DFC / Fault class for check DFC_DSMDummy"
    VALUE
    0x80801624
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8000_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8000"
    VALUE
    0x80801625
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8001_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8001"
    VALUE
    0x80801626
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8002_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8002"
    VALUE
    0x80801627
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8003_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8003"
    VALUE
    0x80801628
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8004_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8004"
    VALUE
    0x80801629
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8005_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8005"
    VALUE
    0x8080162A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8006_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8006"
    VALUE
    0x8080162B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8007_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8007"
    VALUE
    0x8080162C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8008_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8008"
    VALUE
    0x8080162D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8009_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8009"
    VALUE
    0x8080162E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x800a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x800a"
    VALUE
    0x8080162F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x800b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x800b"
    VALUE
    0x80801630
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x800c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x800c"
    VALUE
    0x80801631
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x800d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x800d"
    VALUE
    0x80801632
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x800e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x800e"
    VALUE
    0x80801633
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x800f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x800f"
    VALUE
    0x80801634
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8010_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8010"
    VALUE
    0x80801635
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8011_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8011"
    VALUE
    0x80801636
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8012_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8012"
    VALUE
    0x80801637
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8013_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8013"
    VALUE
    0x80801638
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8014_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8014"
    VALUE
    0x80801639
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8015_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8015"
    VALUE
    0x8080163A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8016_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8016"
    VALUE
    0x8080163B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8017_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8017"
    VALUE
    0x8080163C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8018_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8018"
    VALUE
    0x8080163D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8019_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8019"
    VALUE
    0x8080163E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x801a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x801a"
    VALUE
    0x8080163F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x801b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x801b"
    VALUE
    0x80801640
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x801c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x801c"
    VALUE
    0x80801641
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x801d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x801d"
    VALUE
    0x80801642
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x801e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x801e"
    VALUE
    0x80801643
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x801f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x801f"
    VALUE
    0x80801644
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8020_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8020"
    VALUE
    0x80801645
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8021_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8021"
    VALUE
    0x80801646
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8022_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8022"
    VALUE
    0x80801647
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8023_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8023"
    VALUE
    0x80801648
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8024_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8024"
    VALUE
    0x80801649
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8025_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8025"
    VALUE
    0x8080164A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8026_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8026"
    VALUE
    0x8080164B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8027_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8027"
    VALUE
    0x8080164C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8028_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8028"
    VALUE
    0x8080164D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8029_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8029"
    VALUE
    0x8080164E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x802a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x802a"
    VALUE
    0x8080164F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x802b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x802b"
    VALUE
    0x80801650
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x802c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x802c"
    VALUE
    0x80801651
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x802d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x802d"
    VALUE
    0x80801652
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x802e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x802e"
    VALUE
    0x80801653
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x802f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x802f"
    VALUE
    0x80801654
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8030_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8030"
    VALUE
    0x80801655
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8031_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8031"
    VALUE
    0x80801656
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8032_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8032"
    VALUE
    0x80801657
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8033_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8033"
    VALUE
    0x80801658
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8034_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8034"
    VALUE
    0x80801659
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8035_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8035"
    VALUE
    0x8080165A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8036_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8036"
    VALUE
    0x8080165B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8037_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8037"
    VALUE
    0x8080165C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8038_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8038"
    VALUE
    0x8080165D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8039_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8039"
    VALUE
    0x8080165E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x803a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x803a"
    VALUE
    0x8080165F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x803b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x803b"
    VALUE
    0x80801660
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x803c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x803c"
    VALUE
    0x80801661
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x803d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x803d"
    VALUE
    0x80801662
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x803e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x803e"
    VALUE
    0x80801663
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x803f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x803f"
    VALUE
    0x80801664
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8040_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8040"
    VALUE
    0x80801665
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8041_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8041"
    VALUE
    0x80801666
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8042_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8042"
    VALUE
    0x80801667
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8043_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8043"
    VALUE
    0x80801668
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8044_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8044"
    VALUE
    0x80801669
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8045_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8045"
    VALUE
    0x8080166A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8046_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8046"
    VALUE
    0x8080166B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8047_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8047"
    VALUE
    0x8080166C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8048_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8048"
    VALUE
    0x8080166D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8049_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8049"
    VALUE
    0x8080166E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x804a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x804a"
    VALUE
    0x8080166F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x804b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x804b"
    VALUE
    0x80801670
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x804c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x804c"
    VALUE
    0x80801671
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x804d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x804d"
    VALUE
    0x80801672
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x804e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x804e"
    VALUE
    0x80801673
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x804f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x804f"
    VALUE
    0x80801674
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8050_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8050"
    VALUE
    0x80801675
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8051_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8051"
    VALUE
    0x80801676
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8052_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8052"
    VALUE
    0x80801677
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8053_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8053"
    VALUE
    0x80801678
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8054_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8054"
    VALUE
    0x80801679
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8055_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8055"
    VALUE
    0x8080167A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8056_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8056"
    VALUE
    0x8080167B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8057_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8057"
    VALUE
    0x8080167C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8058_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8058"
    VALUE
    0x8080167D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8059_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8059"
    VALUE
    0x8080167E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x805a_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x805a"
    VALUE
    0x8080167F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x805b_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x805b"
    VALUE
    0x80801680
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x805c_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x805c"
    VALUE
    0x80801681
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x805d_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x805d"
    VALUE
    0x80801682
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x805e_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x805e"
    VALUE
    0x80801683
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x805f_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x805f"
    VALUE
    0x80801684
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8060_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8060"
    VALUE
    0x80801685
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8061_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8061"
    VALUE
    0x80801686
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8062_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8062"
    VALUE
    0x80801687
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8C01_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8C01"
    VALUE
    0x80801688
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8C02_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8C02"
    VALUE
    0x80801689
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_bds_NoDeb0x8C03_C
    "fault class per DFC / Fault class for check DFC_bds_NoDeb0x8C03"
    VALUE
    0x8080168A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetDataNoBuf_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x8080168B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetDataParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetDataParam"
    VALUE
    0x8080168C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetDataboxNoInit_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x8080168D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetDataboxParam"
    VALUE
    0x8080168E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetRxBufStatusParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x8080168F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetStatusParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetStatusParam"
    VALUE
    0x80801690
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canGetTxBufStatusParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80801691
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canInitParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canInitParam"
    VALUE
    0x80801692
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canInitRxDataboxOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80801693
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canInitRxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80801694
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canInitTxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80801695
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canIpduGroupControl_C
    "fault class per DFC / Fault class for check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80801696
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canIsDataboxFreeNoInit_C
    "fault class per DFC / Fault class for check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80801697
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canIsDataboxFreeParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80801698
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canIsTxEmptyParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80801699
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegBusOffCallbInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x8080169A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegBusOffCallbParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x8080169B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxBufInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x8080169C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxBufOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x8080169D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxBufParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxBufParam"
    VALUE
    0x8080169E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxCallbInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x8080169F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxCallbParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x808016A0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxDataboxInvNumb_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x808016A1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxDataboxInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x808016A2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxDataboxOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x808016A3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegRxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x808016A4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxBufInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x808016A5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxBufOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x808016A6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxBufParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxBufParam"
    VALUE
    0x808016A7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxDataboxInvNumb_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x808016A8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxDataboxInvState_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x808016A9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxDataboxOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x808016AA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canRegTxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x808016AB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canResetTxBufParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canResetTxBufParam"
    VALUE
    0x808016AC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canSendDataBufOvfl_C
    "fault class per DFC / Fault class for check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x808016AD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canSendDataParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canSendDataParam"
    VALUE
    0x808016AE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canSendDataboxNoInit_C
    "fault class per DFC / Fault class for check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x808016AF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canSendDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canSendDataboxParam"
    VALUE
    0x808016B0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canSetTxCycleParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x808016B1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canStartParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canStartParam"
    VALUE
    0x808016B2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_canStopParam_C
    "fault class per DFC / Fault class for check DFC_rbr_canStopParam"
    VALUE
    0x808016B3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_can_ClearIpduGroup_C
    "fault class per DFC / Fault class for check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x808016B4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_can_ReceiveSignal_C
    "fault class per DFC / Fault class for check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x808016B5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_can_SendSignal_C
    "fault class per DFC / Fault class for check DFC_rbr_can_SendSignal"
    VALUE
    0x808016B6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_can_SetIpduGroup_C
    "fault class per DFC / Fault class for check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x808016B7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmDTCJ1939_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x808016B8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmDelDTCJ1939_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x808016B9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmDelErrors_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmDelErrors"
    VALUE
    0x808016BA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmGetDFES_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmGetDFES"
    VALUE
    0x808016BB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmGetDTCJ1939_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x808016BC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmGetErrors_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmGetErrors"
    VALUE
    0x808016BD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmGetNumErrors_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x808016BE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmInitQueueOverflow_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x808016BF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmNumDTCJ1939_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x808016C0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmTesterror_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmTesterror"
    VALUE
    0x808016C1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmUpdateDebError_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x808016C2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmUpdateError_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmUpdateError"
    VALUE
    0x808016C3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmgetDFCStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x808016C4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_dsmtestErrorDFC_C
    "fault class per DFC / Fault class for check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x808016C5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAi_C
    "fault class per DFC / Fault class for check DFC_rbr_inAi"
    VALUE
    0x808016C6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAic_C
    "fault class per DFC / Fault class for check DFC_rbr_inAic"
    VALUE
    0x808016C7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAicCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_inAicCfg"
    VALUE
    0x808016C8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAicGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inAicGetStatus"
    VALUE
    0x808016C9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAid_C
    "fault class per DFC / Fault class for check DFC_rbr_inAid"
    VALUE
    0x808016CA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAidCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_inAidCfg"
    VALUE
    0x808016CB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAiv_C
    "fault class per DFC / Fault class for check DFC_rbr_inAiv"
    VALUE
    0x808016CC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAivCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_inAivCfg"
    VALUE
    0x808016CD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inAivGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inAivGetStatus"
    VALUE
    0x808016CE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inDi_C
    "fault class per DFC / Fault class for check DFC_rbr_inDi"
    VALUE
    0x808016CF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inFi_C
    "fault class per DFC / Fault class for check DFC_rbr_inFi"
    VALUE
    0x808016D0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inFiCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_inFiCfg"
    VALUE
    0x808016D1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inFiGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inFiGetStatus"
    VALUE
    0x808016D2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inFi_Buffered_C
    "fault class per DFC / Fault class for check DFC_rbr_inFi_Buffered"
    VALUE
    0x808016D3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inPhase_C
    "fault class per DFC / Fault class for check DFC_rbr_inPhase"
    VALUE
    0x808016D4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inPhaseGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x808016D5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inPhaseResetCounter_C
    "fault class per DFC / Fault class for check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x808016D6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inRi_C
    "fault class per DFC / Fault class for check DFC_rbr_inRi"
    VALUE
    0x808016D7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inRiCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_inRiCfg"
    VALUE
    0x808016D8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inRiCfgTemp_C
    "fault class per DFC / Fault class for check DFC_rbr_inRiCfgTemp"
    VALUE
    0x808016D9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inRiGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inRiGetStatus"
    VALUE
    0x808016DA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inRiGetTemp_C
    "fault class per DFC / Fault class for check DFC_rbr_inRiGetTemp"
    VALUE
    0x808016DB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentCopyFDFifo_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x808016DC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentDisable_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentDisable"
    VALUE
    0x808016DD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentEnable_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentEnable"
    VALUE
    0x808016DE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentGetErrorStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x808016DF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentGetFD_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentGetFD"
    VALUE
    0x808016E0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentGetSD_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentGetSD"
    VALUE
    0x808016E1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentGetSDDatabox_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x808016E2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentGetStatus"
    VALUE
    0x808016E3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentInitSDDatabox_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x808016E4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentRegisterCopyFDFifo_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x808016E5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentRegisterFDFifo_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x808016E6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_inSentRegisterSDDataboxes_C
    "fault class per DFC / Fault class for check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x808016E7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusCanRxBufferOverflow_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x808016E8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusGetCaAddrParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x808016E9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusGetDiagnosticParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x808016EA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x808016EB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusGetStatusParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x808016EC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitCommCaMissing_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x808016ED
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitCommParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitCommParam"
    VALUE
    0x808016EE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitCommState_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitCommState"
    VALUE
    0x808016EF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitDiagnosticParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x808016F0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitFailureListParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x808016F1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitRxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x808016F2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusInitTxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x808016F3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegRxDataboxOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x808016F4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegRxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x808016F5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegRxDataboxState_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x808016F6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegTxDataboxOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x808016F7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegTxDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x808016F8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegTxDataboxState_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x808016F9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x808016FA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegisterInstancesOverlap_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x808016FB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegisterInstancesParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x808016FC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusRegisterInstancesState_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x808016FD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSendDataboxParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x808016FE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSendRequestPGNParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x808016FF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaAddrCaUsed_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x80801700
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaAddrComm_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x80801701
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaAddrInvCan_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x80801702
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaAddrParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x80801703
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaInfoParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x80801704
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSetCaNameParam_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x80801705
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_isobusSftyCanTxErr_C
    "fault class per DFC / Fault class for check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x80801706
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_ReceiveSignal_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x80801707
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_SendSignal_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_SendSignal"
    VALUE
    0x80801708
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_getStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_getStatus"
    VALUE
    0x80801709
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_gotoSleep_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_gotoSleep"
    VALUE
    0x8080170A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_scheduleRequest_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x8080170B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_lin_wakeUp_C
    "fault class per DFC / Fault class for check DFC_rbr_lin_wakeUp"
    VALUE
    0x8080170C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memFlsCfgShr_C
    "fault class per DFC / Fault class for check DFC_rbr_memFlsCfgShr"
    VALUE
    0x8080170D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_memGetStatus"
    VALUE
    0x8080170E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memMarkBlock_C
    "fault class per DFC / Fault class for check DFC_rbr_memMarkBlock"
    VALUE
    0x8080170F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadApi1Error_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadApi1Error"
    VALUE
    0x80801710
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadApi2Error_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadApi2Error"
    VALUE
    0x80801711
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadBlock_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadBlock"
    VALUE
    0x80801712
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadCalibInputError_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadCalibInputError"
    VALUE
    0x80801713
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadCalibOuputError_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadCalibOuputError"
    VALUE
    0x80801714
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memReadSystemError_C
    "fault class per DFC / Fault class for check DFC_rbr_memReadSystemError"
    VALUE
    0x80801715
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_memWriteBlock_C
    "fault class per DFC / Fault class for check DFC_rbr_memWriteBlock"
    VALUE
    0x80801716
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_moOV_FirstConstADC_C
    "fault class per DFC / Fault class for check DFC_rbr_moOV_FirstConstADC"
    VALUE
    0x80801717
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_moOV_SecondConstADC_C
    "fault class per DFC / Fault class for check DFC_rbr_moOV_SecondConstADC"
    VALUE
    0x80801718
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_moUV_FirstConstADC_C
    "fault class per DFC / Fault class for check DFC_rbr_moUV_FirstConstADC"
    VALUE
    0x80801719
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_moUV_SecondConstADC_C
    "fault class per DFC / Fault class for check DFC_rbr_moUV_SecondConstADC"
    VALUE
    0x8080171A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_INH_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_INH"
    VALUE
    0x8080171B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_INHLatch_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_INHLatch"
    VALUE
    0x8080171C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_adcPDD_fail_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_adcPDD_fail"
    VALUE
    0x8080171D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_memoryProtection_err_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_memoryProtection_err"
    VALUE
    0x8080171E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02OC"
    VALUE
    0x8080171F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA02Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA02Unintended"
    VALUE
    0x80801720
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03OC"
    VALUE
    0x80801721
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA03Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA03Unintended"
    VALUE
    0x80801722
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04OC"
    VALUE
    0x80801723
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA04Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA04Unintended"
    VALUE
    0x80801724
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05OC"
    VALUE
    0x80801725
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA05Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA05Unintended"
    VALUE
    0x80801726
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07OC"
    VALUE
    0x80801727
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA07Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA07Unintended"
    VALUE
    0x80801728
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08OC"
    VALUE
    0x80801729
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA08Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA08Unintended"
    VALUE
    0x8080172A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09OC"
    VALUE
    0x8080172B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA09Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA09Unintended"
    VALUE
    0x8080172C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10OC"
    VALUE
    0x8080172D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA10Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA10Unintended"
    VALUE
    0x8080172E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17OC"
    VALUE
    0x8080172F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA17Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA17Unintended"
    VALUE
    0x80801730
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18OC"
    VALUE
    0x80801731
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA18Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA18Unintended"
    VALUE
    0x80801732
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19OC"
    VALUE
    0x80801733
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA19Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA19Unintended"
    VALUE
    0x80801734
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20OC"
    VALUE
    0x80801735
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA20Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA20Unintended"
    VALUE
    0x80801736
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31OC"
    VALUE
    0x80801737
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA31Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA31Unintended"
    VALUE
    0x80801738
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32OC"
    VALUE
    0x80801739
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA32Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA32Unintended"
    VALUE
    0x8080173A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33OC"
    VALUE
    0x8080173B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA33Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA33Unintended"
    VALUE
    0x8080173C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34OC"
    VALUE
    0x8080173D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA34Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA34Unintended"
    VALUE
    0x8080173E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35OC"
    VALUE
    0x8080173F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA35Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA35Unintended"
    VALUE
    0x80801740
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46OC"
    VALUE
    0x80801741
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA46Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA46Unintended"
    VALUE
    0x80801742
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47OC"
    VALUE
    0x80801743
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA47Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA47Unintended"
    VALUE
    0x80801744
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48OC"
    VALUE
    0x80801745
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA48Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA48Unintended"
    VALUE
    0x80801746
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51OC"
    VALUE
    0x80801747
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA51Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA51Unintended"
    VALUE
    0x80801748
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52OC"
    VALUE
    0x80801749
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA52Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA52Unintended"
    VALUE
    0x8080174A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53OC"
    VALUE
    0x8080174B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA53Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA53Unintended"
    VALUE
    0x8080174C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54OC"
    VALUE
    0x8080174D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outA54Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outA54Unintended"
    VALUE
    0x8080174E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAov_C
    "fault class per DFC / Fault class for check DFC_rbr_outAov"
    VALUE
    0x8080174F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAovCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_outAovCfg"
    VALUE
    0x80801750
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAovCfgPI_C
    "fault class per DFC / Fault class for check DFC_rbr_outAovCfgPI"
    VALUE
    0x80801751
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAovGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_outAovGetStatus"
    VALUE
    0x80801752
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAovGetVoltage_C
    "fault class per DFC / Fault class for check DFC_rbr_outAovGetVoltage"
    VALUE
    0x80801753
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outAovResetError_C
    "fault class per DFC / Fault class for check DFC_rbr_outAovResetError"
    VALUE
    0x80801754
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDo_C
    "fault class per DFC / Fault class for check DFC_rbr_outDo"
    VALUE
    0x80801755
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDoCfgPwrLs_C
    "fault class per DFC / Fault class for check DFC_rbr_outDoCfgPwrLs"
    VALUE
    0x80801756
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDoDisable_C
    "fault class per DFC / Fault class for check DFC_rbr_outDoDisable"
    VALUE
    0x80801757
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDoGetCurrent_C
    "fault class per DFC / Fault class for check DFC_rbr_outDoGetCurrent"
    VALUE
    0x80801758
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDoGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_outDoGetStatus"
    VALUE
    0x80801759
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outDoResetError_C
    "fault class per DFC / Fault class for check DFC_rbr_outDoResetError"
    VALUE
    0x8080175A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07OC"
    VALUE
    0x8080175B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK07Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK07Unintended"
    VALUE
    0x8080175C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08OC"
    VALUE
    0x8080175D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK08Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK08Unintended"
    VALUE
    0x8080175E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09OC"
    VALUE
    0x8080175F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK09Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK09Unintended"
    VALUE
    0x80801760
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12OC"
    VALUE
    0x80801761
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK12Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK12Unintended"
    VALUE
    0x80801762
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13OC"
    VALUE
    0x80801763
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK13Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK13Unintended"
    VALUE
    0x80801764
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14OC"
    VALUE
    0x80801765
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK14Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK14Unintended"
    VALUE
    0x80801766
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15OC"
    VALUE
    0x80801767
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK15Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK15Unintended"
    VALUE
    0x80801768
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16OC"
    VALUE
    0x80801769
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK16Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK16Unintended"
    VALUE
    0x8080176A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17OC"
    VALUE
    0x8080176B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK17Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK17Unintended"
    VALUE
    0x8080176C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29OC"
    VALUE
    0x8080176D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK29Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK29Unintended"
    VALUE
    0x8080176E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51OC"
    VALUE
    0x8080176F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK51Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK51Unintended"
    VALUE
    0x80801770
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73OC_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73OC"
    VALUE
    0x80801771
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outK73Unintended_C
    "fault class per DFC / Fault class for check DFC_rbr_outK73Unintended"
    VALUE
    0x80801772
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPo_C
    "fault class per DFC / Fault class for check DFC_rbr_outPo"
    VALUE
    0x80801773
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoCfg"
    VALUE
    0x80801774
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoCfgPeriod_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoCfgPeriod"
    VALUE
    0x80801775
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoCfgPwrLs_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoCfgPwrLs"
    VALUE
    0x80801776
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoDisable_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoDisable"
    VALUE
    0x80801777
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoGetCurrent_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoGetCurrent"
    VALUE
    0x80801778
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoGetStatus"
    VALUE
    0x80801779
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoResetError_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoResetError"
    VALUE
    0x8080177A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPoc_C
    "fault class per DFC / Fault class for check DFC_rbr_outPoc"
    VALUE
    0x8080177B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPocCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_outPocCfg"
    VALUE
    0x8080177C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPocCfgDither_C
    "fault class per DFC / Fault class for check DFC_rbr_outPocCfgDither"
    VALUE
    0x8080177D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPocCfgPI_C
    "fault class per DFC / Fault class for check DFC_rbr_outPocCfgPI"
    VALUE
    0x8080177E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPod_C
    "fault class per DFC / Fault class for check DFC_rbr_outPod"
    VALUE
    0x8080177F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPodCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_outPodCfg"
    VALUE
    0x80801780
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_outPodCfgPeriod_C
    "fault class per DFC / Fault class for check DFC_rbr_outPodCfgPeriod"
    VALUE
    0x80801781
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_rsmFfiApiCallErr_C
    "fault class per DFC / Fault class for check DFC_rbr_rsmFfiApiCallErr"
    VALUE
    0x80801782
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safout_C
    "fault class per DFC / Fault class for check DFC_rbr_safout"
    VALUE
    0x80801783
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutCfg_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutCfg"
    VALUE
    0x80801784
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl1_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl1"
    VALUE
    0x80801785
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl10_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl10"
    VALUE
    0x80801786
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl10Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl10Dev"
    VALUE
    0x80801787
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl10OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl10OR"
    VALUE
    0x80801788
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl11_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl11"
    VALUE
    0x80801789
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl11Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl11Dev"
    VALUE
    0x8080178A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl11OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl11OR"
    VALUE
    0x8080178B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl12_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl12"
    VALUE
    0x8080178C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl12Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl12Dev"
    VALUE
    0x8080178D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl12OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl12OR"
    VALUE
    0x8080178E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl13_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl13"
    VALUE
    0x8080178F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl13Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl13Dev"
    VALUE
    0x80801790
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl13OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl13OR"
    VALUE
    0x80801791
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl14_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl14"
    VALUE
    0x80801792
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl14Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl14Dev"
    VALUE
    0x80801793
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl14OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl14OR"
    VALUE
    0x80801794
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl15_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl15"
    VALUE
    0x80801795
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl15Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl15Dev"
    VALUE
    0x80801796
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl15OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl15OR"
    VALUE
    0x80801797
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl16_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl16"
    VALUE
    0x80801798
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl16Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl16Dev"
    VALUE
    0x80801799
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl16OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl16OR"
    VALUE
    0x8080179A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl17_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl17"
    VALUE
    0x8080179B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl17Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl17Dev"
    VALUE
    0x8080179C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl17OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl17OR"
    VALUE
    0x8080179D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl18_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl18"
    VALUE
    0x8080179E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl18Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl18Dev"
    VALUE
    0x8080179F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl18OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl18OR"
    VALUE
    0x808017A0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl1Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl1Dev"
    VALUE
    0x808017A1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl1OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl1OR"
    VALUE
    0x808017A2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl2_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl2"
    VALUE
    0x808017A3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl2Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl2Dev"
    VALUE
    0x808017A4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl2OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl2OR"
    VALUE
    0x808017A5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl3_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl3"
    VALUE
    0x808017A6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl3Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl3Dev"
    VALUE
    0x808017A7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl3OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl3OR"
    VALUE
    0x808017A8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl4_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl4"
    VALUE
    0x808017A9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl4Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl4Dev"
    VALUE
    0x808017AA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl4OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl4OR"
    VALUE
    0x808017AB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl5_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl5"
    VALUE
    0x808017AC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl5Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl5Dev"
    VALUE
    0x808017AD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl5OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl5OR"
    VALUE
    0x808017AE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl6_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl6"
    VALUE
    0x808017AF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl6Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl6Dev"
    VALUE
    0x808017B0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl6OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl6OR"
    VALUE
    0x808017B1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl7_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl7"
    VALUE
    0x808017B2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl7Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl7Dev"
    VALUE
    0x808017B3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl7OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl7OR"
    VALUE
    0x808017B4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl8_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl8"
    VALUE
    0x808017B5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl8Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl8Dev"
    VALUE
    0x808017B6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl8OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl8OR"
    VALUE
    0x808017B7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl9_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl9"
    VALUE
    0x808017B8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl9Dev_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl9Dev"
    VALUE
    0x808017B9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutChnl9OR_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutChnl9OR"
    VALUE
    0x808017BA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutDevError_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutDevError"
    VALUE
    0x808017BB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutGetStatus_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutGetStatus"
    VALUE
    0x808017BC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutIgnoreError_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutIgnoreError"
    VALUE
    0x808017BD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutResetError_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutResetError"
    VALUE
    0x808017BE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safoutUnlock_C
    "fault class per DFC / Fault class for check DFC_rbr_safoutUnlock"
    VALUE
    0x808017BF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_safout_cfgDiag_C
    "fault class per DFC / Fault class for check DFC_rbr_safout_cfgDiag"
    VALUE
    0x808017C0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secAccessDenied_RC_C
    "fault class per DFC / Fault class for check DFC_rbr_secAccessDenied_RC"
    VALUE
    0x808017C1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secAccessDenied_WDBI_C
    "fault class per DFC / Fault class for check DFC_rbr_secAccessDenied_WDBI"
    VALUE
    0x808017C2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secEvalRespKey_C
    "fault class per DFC / Fault class for check DFC_rbr_secEvalRespKey"
    VALUE
    0x808017C3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secFlashingFailure_C
    "fault class per DFC / Fault class for check DFC_rbr_secFlashingFailure"
    VALUE
    0x808017C4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secGetLevel_C
    "fault class per DFC / Fault class for check DFC_rbr_secGetLevel"
    VALUE
    0x808017C5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secGetRnd_C
    "fault class per DFC / Fault class for check DFC_rbr_secGetRnd"
    VALUE
    0x808017C6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secGetSeed_C
    "fault class per DFC / Fault class for check DFC_rbr_secGetSeed"
    VALUE
    0x808017C7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secInvalidPassword_C
    "fault class per DFC / Fault class for check DFC_rbr_secInvalidPassword"
    VALUE
    0x808017C8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secIsRequestAllowed_C
    "fault class per DFC / Fault class for check DFC_rbr_secIsRequestAllowed"
    VALUE
    0x808017C9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secResetLevel_C
    "fault class per DFC / Fault class for check DFC_rbr_secResetLevel"
    VALUE
    0x808017CA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secSaveSecret_C
    "fault class per DFC / Fault class for check DFC_rbr_secSaveSecret"
    VALUE
    0x808017CB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_secSetLevel_C
    "fault class per DFC / Fault class for check DFC_rbr_secSetLevel"
    VALUE
    0x808017CC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysAit_C
    "fault class per DFC / Fault class for check DFC_rbr_sysAit"
    VALUE
    0x808017CD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysAiv_C
    "fault class per DFC / Fault class for check DFC_rbr_sysAiv"
    VALUE
    0x808017CE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysDi_C
    "fault class per DFC / Fault class for check DFC_rbr_sysDi"
    VALUE
    0x808017CF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysDo_C
    "fault class per DFC / Fault class for check DFC_rbr_sysDo"
    VALUE
    0x808017D0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysGetVss_C
    "fault class per DFC / Fault class for check DFC_rbr_sysGetVss"
    VALUE
    0x808017D1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysInit_C
    "fault class per DFC / Fault class for check DFC_rbr_sysInit"
    VALUE
    0x808017D2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysOperHrIntegrityErr_C
    "fault class per DFC / Fault class for check DFC_rbr_sysOperHrIntegrityErr"
    VALUE
    0x808017D3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysOperHrsSaturated_C
    "fault class per DFC / Fault class for check DFC_rbr_sysOperHrsSaturated"
    VALUE
    0x808017D4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sysSetVss_C
    "fault class per DFC / Fault class for check DFC_rbr_sysSetVss"
    VALUE
    0x808017D5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sys_coreload_C
    "fault class per DFC / Fault class for check DFC_rbr_sys_coreload"
    VALUE
    0x808017D6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_sys_taskload_C
    "fault class per DFC / Fault class for check DFC_rbr_sys_taskload"
    VALUE
    0x808017D7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VSS1_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VSS1"
    VALUE
    0x808017D8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_OV_VSS2_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_OV_VSS2"
    VALUE
    0x808017D9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VSS1_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VSS1"
    VALUE
    0x808017DA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rbr_mo_UV_VSS2_C
    "fault class per DFC / Fault class for check DFC_rbr_mo_UV_VSS2"
    VALUE
    0x808017DB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CANSM_E_BUS_OFF_NETWORK_0_C
    "fault class per DFC / Fault class for check DFC_CANSM_E_BUS_OFF_NETWORK_0"
    VALUE
    0x808017DC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CANSM_E_BUS_OFF_NETWORK_1_C
    "fault class per DFC / Fault class for check DFC_CANSM_E_BUS_OFF_NETWORK_1"
    VALUE
    0x808017DD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CANSM_E_BUS_OFF_NETWORK_2_C
    "fault class per DFC / Fault class for check DFC_CANSM_E_BUS_OFF_NETWORK_2"
    VALUE
    0x808017DE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CANSM_E_BUS_OFF_NETWORK_3_C
    "fault class per DFC / Fault class for check DFC_CANSM_E_BUS_OFF_NETWORK_3"
    VALUE
    0x808017DF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CANTRCV_E_NO_TRCV_CONTROL_0_C
    "fault class per DFC / Fault class for check DFC_CANTRCV_E_NO_TRCV_CONTROL_0"
    VALUE
    0x808017E0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_CAN_E_TIMEOUT_C
    "fault class per DFC / Fault class for check DFC_CAN_E_TIMEOUT"
    VALUE
    0x808017E1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_0_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_0"
    VALUE
    0x808017E2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_1_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_1"
    VALUE
    0x808017E3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_2_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_2"
    VALUE
    0x808017E4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_3_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_3"
    VALUE
    0x808017E5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_4_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_4"
    VALUE
    0x808017E6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_COMM_E_NET_START_IND_CHANNEL_5_C
    "fault class per DFC / Fault class for check DFC_COMM_E_NET_START_IND_CHANNEL_5"
    VALUE
    0x808017E7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_LIN_E_TIMEOUT_C
    "fault class per DFC / Fault class for check DFC_LIN_E_TIMEOUT"
    VALUE
    0x808017E8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_MultiStackTrace_Threshold_C
    "fault class per DFC / Fault class for check DFC_rba_MultiStackTrace_Threshold"
    VALUE
    0x808017E9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_ETH_E_ACCESS_0_C
    "fault class per DFC / Fault class for check DFC_ETH_E_ACCESS_0"
    VALUE
    0x808017EA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_RBA_IOEXTLIB_KEEPALIVE_DRV_C
    "fault class per DFC / Fault class for check DFC_RBA_IOEXTLIB_KEEPALIVE_DRV"
    VALUE
    0x808017EB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_RBA_IOEXTLIB_KEEPALIVE_INI_C
    "fault class per DFC / Fault class for check DFC_RBA_IOEXTLIB_KEEPALIVE_INI"
    VALUE
    0x808017EC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_MRly_Diag_Stk_Event_C
    "fault class per DFC / Fault class for check DFC_rba_MRly_Diag_Stk_Event"
    VALUE
    0x808017ED
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_MemDiagExtd_MemReadSngErr_C
    "fault class per DFC / Fault class for check DFC_rba_MemDiagExtd_MemReadSngErr"
    VALUE
    0x808017EE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_MemDiag_MemReadErr_C
    "fault class per DFC / Fault class for check DFC_rba_MemDiag_MemReadErr"
    VALUE
    0x808017EF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_MemDiag_MemWrErr_C
    "fault class per DFC / Fault class for check DFC_rba_MemDiag_MemWrErr"
    VALUE
    0x808017F0
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_SyC_IrrSwOffTrigEngRun_Event_C
    "fault class per DFC / Fault class for check DFC_rba_SyC_IrrSwOffTrigEngRun_Event"
    VALUE
    0x808017F1
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_T15_Diag_ComInVld_Event_C
    "fault class per DFC / Fault class for check DFC_rba_T15_Diag_ComInVld_Event"
    VALUE
    0x808017F2
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_T15_Diag_ComOff_HwOn_Event_C
    "fault class per DFC / Fault class for check DFC_rba_T15_Diag_ComOff_HwOn_Event"
    VALUE
    0x808017F3
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_rba_T15_Diag_ComOn_HwOff_Event_C
    "fault class per DFC / Fault class for check DFC_rba_T15_Diag_ComOn_HwOff_Event"
    VALUE
    0x808017F4
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_0"
    VALUE
    0x808017F5
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_1"
    VALUE
    0x808017F6
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_10_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_10"
    VALUE
    0x808017F7
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_11"
    VALUE
    0x808017F8
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_13"
    VALUE
    0x808017F9
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_14"
    VALUE
    0x808017FA
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_2"
    VALUE
    0x808017FB
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_22_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_22"
    VALUE
    0x808017FC
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_23_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_23"
    VALUE
    0x808017FD
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_4"
    VALUE
    0x808017FE
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_5"
    VALUE
    0x808017FF
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_7_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_7"
    VALUE
    0x80801800
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM0_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM0_8"
    VALUE
    0x80801801
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM10_16_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM10_16"
    VALUE
    0x80801802
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM10_17_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM10_17"
    VALUE
    0x80801803
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM10_21_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM10_21"
    VALUE
    0x80801804
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_0"
    VALUE
    0x80801805
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_1"
    VALUE
    0x80801806
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_2"
    VALUE
    0x80801807
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_3_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_3"
    VALUE
    0x80801808
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_4"
    VALUE
    0x80801809
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_5"
    VALUE
    0x8080180A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_8"
    VALUE
    0x8080180B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM11_9_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM11_9"
    VALUE
    0x8080180C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_0"
    VALUE
    0x8080180D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_1"
    VALUE
    0x8080180E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_10_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_10"
    VALUE
    0x8080180F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_11"
    VALUE
    0x80801810
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_13"
    VALUE
    0x80801811
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_14"
    VALUE
    0x80801812
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_2"
    VALUE
    0x80801813
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_22_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_22"
    VALUE
    0x80801814
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_23_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_23"
    VALUE
    0x80801815
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_4"
    VALUE
    0x80801816
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_5"
    VALUE
    0x80801817
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_7_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_7"
    VALUE
    0x80801818
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM1_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM1_8"
    VALUE
    0x80801819
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM21_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM21_0"
    VALUE
    0x8080181A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM21_16_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM21_16"
    VALUE
    0x8080181B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM21_3_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM21_3"
    VALUE
    0x8080181C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_1"
    VALUE
    0x8080181D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_10_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_10"
    VALUE
    0x8080181E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_11"
    VALUE
    0x8080181F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_13"
    VALUE
    0x80801820
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_14"
    VALUE
    0x80801821
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_2"
    VALUE
    0x80801822
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_22_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_22"
    VALUE
    0x80801823
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_23_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_23"
    VALUE
    0x80801824
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_4"
    VALUE
    0x80801825
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_5"
    VALUE
    0x80801826
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_7_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_7"
    VALUE
    0x80801827
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM2_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM2_8"
    VALUE
    0x80801828
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_1"
    VALUE
    0x80801829
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_10_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_10"
    VALUE
    0x8080182A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_11"
    VALUE
    0x8080182B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_13"
    VALUE
    0x8080182C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_14"
    VALUE
    0x8080182D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_2"
    VALUE
    0x8080182E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_22_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_22"
    VALUE
    0x8080182F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_23_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_23"
    VALUE
    0x80801830
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_4"
    VALUE
    0x80801831
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_5"
    VALUE
    0x80801832
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_7_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_7"
    VALUE
    0x80801833
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM3_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM3_8"
    VALUE
    0x80801834
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_0"
    VALUE
    0x80801835
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_11"
    VALUE
    0x80801836
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_12_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_12"
    VALUE
    0x80801837
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_14"
    VALUE
    0x80801838
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_15_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_15"
    VALUE
    0x80801839
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_17_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_17"
    VALUE
    0x8080183A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_18_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_18"
    VALUE
    0x8080183B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_2"
    VALUE
    0x8080183C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_20_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_20"
    VALUE
    0x8080183D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_21_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_21"
    VALUE
    0x8080183E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_25_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_25"
    VALUE
    0x8080183F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_4"
    VALUE
    0x80801840
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_5_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_5"
    VALUE
    0x80801841
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_7_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_7"
    VALUE
    0x80801842
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM6_8_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM6_8"
    VALUE
    0x80801843
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_1"
    VALUE
    0x80801844
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_12_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_12"
    VALUE
    0x80801845
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_13"
    VALUE
    0x80801846
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_14_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_14"
    VALUE
    0x80801847
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_15_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_15"
    VALUE
    0x80801848
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_16_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_16"
    VALUE
    0x80801849
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_17_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_17"
    VALUE
    0x8080184A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_2"
    VALUE
    0x8080184B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_20_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_20"
    VALUE
    0x8080184C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_25_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_25"
    VALUE
    0x8080184D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_26_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_26"
    VALUE
    0x8080184E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_28_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_28"
    VALUE
    0x8080184F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_29_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_29"
    VALUE
    0x80801850
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_30_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_30"
    VALUE
    0x80801851
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM7_31_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM7_31"
    VALUE
    0x80801852
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_0"
    VALUE
    0x80801853
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_1"
    VALUE
    0x80801854
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_10_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_10"
    VALUE
    0x80801855
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_11_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_11"
    VALUE
    0x80801856
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_12_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_12"
    VALUE
    0x80801857
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_13_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_13"
    VALUE
    0x80801858
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_16_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_16"
    VALUE
    0x80801859
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_18_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_18"
    VALUE
    0x8080185A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_2_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_2"
    VALUE
    0x8080185B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_3_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_3"
    VALUE
    0x8080185C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_30_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_30"
    VALUE
    0x8080185D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_31_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_31"
    VALUE
    0x8080185E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM8_4_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM8_4"
    VALUE
    0x8080185F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM9_0_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM9_0"
    VALUE
    0x80801860
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM9_1_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM9_1"
    VALUE
    0x80801861
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM9_15_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM9_15"
    VALUE
    0x80801862
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MOXEMM_SMU_ALM9_3_C
    "fault class per DFC / Fault class for check DFC_MOXEMM_SMU_ALM9_3"
    VALUE
    0x80801863
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoCSOPICO_C
    "fault class per DFC / Fault class for check DFC_MoCSOPICO"
    VALUE
    0x80801864
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoFVarPostBldSel_C
    "fault class per DFC / Fault class for check DFC_MoFVarPostBldSel"
    VALUE
    0x80801865
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoSysCtrlReIni_C
    "fault class per DFC / Fault class for check DFC_MoSysCtrlReIni"
    VALUE
    0x80801866
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTMCUFW_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTMCUFW"
    VALUE
    0x80801867
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTMonBIST_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTMonBIST"
    VALUE
    0x80801868
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTRegMonTest_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTRegMonTest"
    VALUE
    0x80801869
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTStbySMUAlvTest_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTStbySMUAlvTest"
    VALUE
    0x8080186A
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTTempSens_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTTempSens"
    VALUE
    0x8080186B
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_MoXEMMHwLTUCBCfg_C
    "fault class per DFC / Fault class for check DFC_MoXEMMHwLTUCBCfg"
    VALUE
    0x8080186C
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_OCWDAABEActv_C
    "fault class per DFC / Fault class for check DFC_OCWDAABEActv"
    VALUE
    0x8080186D
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_OCWDACom_C
    "fault class per DFC / Fault class for check DFC_OCWDACom"
    VALUE
    0x8080186E
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_OCWDAErrPin_C
    "fault class per DFC / Fault class for check DFC_OCWDAErrPin"
    VALUE
    0x8080186F
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_SWReset_0_C
    "fault class per DFC / Fault class for check DFC_SWReset_0"
    VALUE
    0x80801870
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_SWReset_1_C
    "fault class per DFC / Fault class for check DFC_SWReset_1"
    VALUE
    0x80801871
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_Cls.DFC_SWReset_2_C
    "fault class per DFC / Fault class for check DFC_SWReset_2"
    VALUE
    0x80801872
    Val_Wu8
    3.000
    DFES_OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_ctDstTrig_C
    ""
    VALUE
    0x80801874
    Val_Wu8
    254.0
    OneToOne
    1.0
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DbLv_C
    "Debounce level limit for creating fault entry (valid for all DFCs)"
    VALUE
    0x80801875
    Val_Wu8
    15.00
    DFES_OneToOne
    0.00
    15.00

    FORMAT "%5.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_Unused_C
    "manufacterer specific trouble code / "
    VALUE
    0x80803738
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80c7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80c7"
    VALUE
    0x8080373A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80c8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80c8"
    VALUE
    0x8080373C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80c9_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80c9"
    VALUE
    0x8080373E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ca_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ca"
    VALUE
    0x80803740
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80cb_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80cb"
    VALUE
    0x80803742
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80cc_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80cc"
    VALUE
    0x80803744
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80cd_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80cd"
    VALUE
    0x80803746
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ce_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ce"
    VALUE
    0x80803748
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80cf_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80cf"
    VALUE
    0x8080374A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80d0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80d0"
    VALUE
    0x8080374C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80d1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80d1"
    VALUE
    0x8080374E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80d2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80803750
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80d3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80803752
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80d4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80803754
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80d5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80803756
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80d6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80803758
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80d7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80d7"
    VALUE
    0x8080375A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80d8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80d8"
    VALUE
    0x8080375C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80d9_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80d9"
    VALUE
    0x8080375E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80da_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80da"
    VALUE
    0x80803760
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80db_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80db"
    VALUE
    0x80803762
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80dc_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80dc"
    VALUE
    0x80803764
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80dd_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80dd"
    VALUE
    0x80803766
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80de_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80de"
    VALUE
    0x80803768
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80df_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80df"
    VALUE
    0x8080376A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80e0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80e0"
    VALUE
    0x8080376C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80e1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80e1"
    VALUE
    0x8080376E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80e2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80803770
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80e3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80803772
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80e4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80803774
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80e5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80803776
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80e6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80803778
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80e7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80e7"
    VALUE
    0x8080377A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80e8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80e8"
    VALUE
    0x8080377C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80e9_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80e9"
    VALUE
    0x8080377E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ea_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ea"
    VALUE
    0x80803780
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80eb_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80eb"
    VALUE
    0x80803782
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ec_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ec"
    VALUE
    0x80803784
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ed_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ed"
    VALUE
    0x80803786
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ee_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ee"
    VALUE
    0x80803788
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ef_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ef"
    VALUE
    0x8080378A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80f0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80f0"
    VALUE
    0x8080378C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80f1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80f1"
    VALUE
    0x8080378E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80f2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80803790
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80f3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80803792
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80f4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80803794
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80f5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80803796
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80f6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80f6"
    VALUE
    0x80803798
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80f7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80f7"
    VALUE
    0x8080379A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80f8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80f8"
    VALUE
    0x8080379C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80f9_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80f9"
    VALUE
    0x8080379E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80fa_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80fa"
    VALUE
    0x808037A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80fb_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80fb"
    VALUE
    0x808037A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80fc_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80fc"
    VALUE
    0x808037A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80fd_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80fd"
    VALUE
    0x808037A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80fe_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80fe"
    VALUE
    0x808037A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ff_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ff"
    VALUE
    0x808037AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8100_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8100"
    VALUE
    0x808037AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8101_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8101"
    VALUE
    0x808037AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8102_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8102"
    VALUE
    0x808037B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8103_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8103"
    VALUE
    0x808037B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8104_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8104"
    VALUE
    0x808037B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8105_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8105"
    VALUE
    0x808037B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8106_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8106"
    VALUE
    0x808037B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8107_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8107"
    VALUE
    0x808037BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8108_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8108"
    VALUE
    0x808037BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8109_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8109"
    VALUE
    0x808037BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x810a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x810a"
    VALUE
    0x808037C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x810b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x810b"
    VALUE
    0x808037C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x810c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x810c"
    VALUE
    0x808037C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x810d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x810d"
    VALUE
    0x808037C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x810e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x810e"
    VALUE
    0x808037C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x810f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x810f"
    VALUE
    0x808037CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8110_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8110"
    VALUE
    0x808037CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8111_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8111"
    VALUE
    0x808037CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8112_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8112"
    VALUE
    0x808037D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8113_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8113"
    VALUE
    0x808037D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8114_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8114"
    VALUE
    0x808037D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8115_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8115"
    VALUE
    0x808037D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8116_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8116"
    VALUE
    0x808037D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8117_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8117"
    VALUE
    0x808037DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8118_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8118"
    VALUE
    0x808037DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8119_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8119"
    VALUE
    0x808037DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x811a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x811a"
    VALUE
    0x808037E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x811b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x811b"
    VALUE
    0x808037E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x811c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x811c"
    VALUE
    0x808037E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x811d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x811d"
    VALUE
    0x808037E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x811e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x811e"
    VALUE
    0x808037E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x811f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x811f"
    VALUE
    0x808037EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8120_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8120"
    VALUE
    0x808037EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8121_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8121"
    VALUE
    0x808037EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8122_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8122"
    VALUE
    0x808037F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8123_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8123"
    VALUE
    0x808037F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8124_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8124"
    VALUE
    0x808037F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8125_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8125"
    VALUE
    0x808037F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8126_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8126"
    VALUE
    0x808037F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8127_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8127"
    VALUE
    0x808037FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8128_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8128"
    VALUE
    0x808037FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8129_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8129"
    VALUE
    0x808037FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x812a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x812a"
    VALUE
    0x80803800
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_TiInRow0x8B01_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_TiInRow0x8B01"
    VALUE
    0x80803802
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_TiInRow0x8B02_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_TiInRow0x8B02"
    VALUE
    0x80803804
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_TiInRow0x8B03_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_TiInRow0x8B03"
    VALUE
    0x80803806
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_DevLibBattUHi_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_DevLibBattUHi"
    VALUE
    0x80803808
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_DevLibBattULo_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_DevLibBattULo"
    VALUE
    0x8080380A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8063_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8063"
    VALUE
    0x8080380C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8064_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8064"
    VALUE
    0x8080380E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8065_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8065"
    VALUE
    0x80803810
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8066_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8066"
    VALUE
    0x80803812
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8067_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8067"
    VALUE
    0x80803814
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8068_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8068"
    VALUE
    0x80803816
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8069_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8069"
    VALUE
    0x80803818
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x806a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x806a"
    VALUE
    0x8080381A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x806b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x806b"
    VALUE
    0x8080381C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x806c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x806c"
    VALUE
    0x8080381E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x806d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x806d"
    VALUE
    0x80803820
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x806e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x806e"
    VALUE
    0x80803822
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x806f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x806f"
    VALUE
    0x80803824
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8070_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8070"
    VALUE
    0x80803826
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8071_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8071"
    VALUE
    0x80803828
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8072_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8072"
    VALUE
    0x8080382A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8073_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8073"
    VALUE
    0x8080382C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8074_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8074"
    VALUE
    0x8080382E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8075_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8075"
    VALUE
    0x80803830
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8076_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8076"
    VALUE
    0x80803832
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8077_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8077"
    VALUE
    0x80803834
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8078_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8078"
    VALUE
    0x80803836
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8079_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8079"
    VALUE
    0x80803838
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x807a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x807a"
    VALUE
    0x8080383A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x807b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x807b"
    VALUE
    0x8080383C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x807c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x807c"
    VALUE
    0x8080383E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x807d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x807d"
    VALUE
    0x80803840
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x807e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x807e"
    VALUE
    0x80803842
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x807f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x807f"
    VALUE
    0x80803844
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8080_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8080"
    VALUE
    0x80803846
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8081_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8081"
    VALUE
    0x80803848
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8082_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8082"
    VALUE
    0x8080384A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8083_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8083"
    VALUE
    0x8080384C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8084_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8084"
    VALUE
    0x8080384E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8085_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8085"
    VALUE
    0x80803850
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8086_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8086"
    VALUE
    0x80803852
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8087_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8087"
    VALUE
    0x80803854
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8088_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8088"
    VALUE
    0x80803856
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8089_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8089"
    VALUE
    0x80803858
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x808a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x808a"
    VALUE
    0x8080385A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x808b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x808b"
    VALUE
    0x8080385C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x808c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x808c"
    VALUE
    0x8080385E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x808d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x808d"
    VALUE
    0x80803860
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x808e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x808e"
    VALUE
    0x80803862
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x808f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x808f"
    VALUE
    0x80803864
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8090_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8090"
    VALUE
    0x80803866
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8091_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8091"
    VALUE
    0x80803868
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8092_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8092"
    VALUE
    0x8080386A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8093_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8093"
    VALUE
    0x8080386C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8094_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8094"
    VALUE
    0x8080386E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8095_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8095"
    VALUE
    0x80803870
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8096_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8096"
    VALUE
    0x80803872
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8097_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8097"
    VALUE
    0x80803874
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8098_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8098"
    VALUE
    0x80803876
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x8099_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x8099"
    VALUE
    0x80803878
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x809a_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x809a"
    VALUE
    0x8080387A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x809b_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x809b"
    VALUE
    0x8080387C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x809c_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x809c"
    VALUE
    0x8080387E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x809d_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x809d"
    VALUE
    0x80803880
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x809e_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x809e"
    VALUE
    0x80803882
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x809f_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x809f"
    VALUE
    0x80803884
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80a0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80a0"
    VALUE
    0x80803886
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80a1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80a1"
    VALUE
    0x80803888
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80a2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80a2"
    VALUE
    0x8080388A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80a3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80a3"
    VALUE
    0x8080388C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80a4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80a4"
    VALUE
    0x8080388E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80a5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80803890
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80a6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80a6"
    VALUE
    0x80803892
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80a7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80a7"
    VALUE
    0x80803894
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80a8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80a8"
    VALUE
    0x80803896
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80a9_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80a9"
    VALUE
    0x80803898
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80aa_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80aa"
    VALUE
    0x8080389A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ab_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ab"
    VALUE
    0x8080389C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ac_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ac"
    VALUE
    0x8080389E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ad_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ad"
    VALUE
    0x808038A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ae_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ae"
    VALUE
    0x808038A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80af_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80af"
    VALUE
    0x808038A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80b0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80b0"
    VALUE
    0x808038A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80b1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80b1"
    VALUE
    0x808038A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80b2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80b2"
    VALUE
    0x808038AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80b3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80b3"
    VALUE
    0x808038AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80b4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80b4"
    VALUE
    0x808038AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80b5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80b5"
    VALUE
    0x808038B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80b6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80b6"
    VALUE
    0x808038B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80b7_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80b7"
    VALUE
    0x808038B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80b8_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80b8"
    VALUE
    0x808038B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80b9_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80b9"
    VALUE
    0x808038B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80ba_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80ba"
    VALUE
    0x808038BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80bb_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80bb"
    VALUE
    0x808038BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80bc_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80bc"
    VALUE
    0x808038BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80bd_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80bd"
    VALUE
    0x808038C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80be_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80be"
    VALUE
    0x808038C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80bf_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80bf"
    VALUE
    0x808038C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80c0_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80c0"
    VALUE
    0x808038C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80c1_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80c1"
    VALUE
    0x808038C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80c2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80c2"
    VALUE
    0x808038CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80c3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80c3"
    VALUE
    0x808038CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80c4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80c4"
    VALUE
    0x808038CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80c5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80c5"
    VALUE
    0x808038D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_NoDeb0x80c6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_NoDeb0x80c6"
    VALUE
    0x808038D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_TiUpDwn0x8A01_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x808038D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_TiUpDwn0x8A02_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x808038D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_bds_TiUpDwn0x8A03_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x808038D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA13OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA13OR"
    VALUE
    0x808038DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA13SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA13SCB"
    VALUE
    0x808038DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA13SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA13SCG"
    VALUE
    0x808038DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA14OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA14OR"
    VALUE
    0x808038E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA14SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA14SCB"
    VALUE
    0x808038E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA14SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA14SCG"
    VALUE
    0x808038E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA21OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA21OR"
    VALUE
    0x808038E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA21SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA21SCB"
    VALUE
    0x808038E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA21SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA21SCG"
    VALUE
    0x808038EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA22OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA22OR"
    VALUE
    0x808038EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA22SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA22SCB"
    VALUE
    0x808038EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA22SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA22SCG"
    VALUE
    0x808038F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA23OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA23OR"
    VALUE
    0x808038F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA23SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA23SCB"
    VALUE
    0x808038F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA23SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA23SCG"
    VALUE
    0x808038F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA24OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA24OR"
    VALUE
    0x808038F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA24SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA24SCB"
    VALUE
    0x808038FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA24SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA24SCG"
    VALUE
    0x808038FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA25OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA25OR"
    VALUE
    0x808038FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA25SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA25SCB"
    VALUE
    0x80803900
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA25SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA25SCG"
    VALUE
    0x80803902
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA26OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA26OR"
    VALUE
    0x80803904
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA26SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA26SCB"
    VALUE
    0x80803906
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA26SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA26SCG"
    VALUE
    0x80803908
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA27OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA27OR"
    VALUE
    0x8080390A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA27SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA27SCB"
    VALUE
    0x8080390C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA27SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA27SCG"
    VALUE
    0x8080390E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA28OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA28OR"
    VALUE
    0x80803910
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA28SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA28SCB"
    VALUE
    0x80803912
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA28SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA28SCG"
    VALUE
    0x80803914
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA29OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA29OR"
    VALUE
    0x80803916
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA29SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA29SCB"
    VALUE
    0x80803918
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA29SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA29SCG"
    VALUE
    0x8080391A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36AicSCB"
    VALUE
    0x8080391C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36AicSCG"
    VALUE
    0x8080391E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36OR"
    VALUE
    0x80803920
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36SCB"
    VALUE
    0x80803922
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36SCG"
    VALUE
    0x80803924
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA36ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80803926
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37AicSCB"
    VALUE
    0x80803928
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37AicSCG"
    VALUE
    0x8080392A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37OR"
    VALUE
    0x8080392C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37SCB"
    VALUE
    0x8080392E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37SCG"
    VALUE
    0x80803930
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA37ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80803932
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38AicSCB"
    VALUE
    0x80803934
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38AicSCG"
    VALUE
    0x80803936
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38OR"
    VALUE
    0x80803938
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38SCB"
    VALUE
    0x8080393A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38SCG"
    VALUE
    0x8080393C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA38ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x8080393E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39AicSCB"
    VALUE
    0x80803940
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39AicSCG"
    VALUE
    0x80803942
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39OR"
    VALUE
    0x80803944
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39SCB"
    VALUE
    0x80803946
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39SCG"
    VALUE
    0x80803948
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA39ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x8080394A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA40OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA40OR"
    VALUE
    0x8080394C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA40SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA40SCB"
    VALUE
    0x8080394E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA40SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA40SCG"
    VALUE
    0x80803950
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA41OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA41OR"
    VALUE
    0x80803952
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA41SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA41SCB"
    VALUE
    0x80803954
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA41SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA41SCG"
    VALUE
    0x80803956
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA42OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA42OR"
    VALUE
    0x80803958
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA42SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA42SCB"
    VALUE
    0x8080395A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA42SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA42SCG"
    VALUE
    0x8080395C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43AicSCB"
    VALUE
    0x8080395E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43AicSCG"
    VALUE
    0x80803960
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43OR"
    VALUE
    0x80803962
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43SCB"
    VALUE
    0x80803964
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43SCG"
    VALUE
    0x80803966
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA43ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80803968
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA44OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA44OL"
    VALUE
    0x8080396A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA44SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA44SCB"
    VALUE
    0x8080396C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA44SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA44SCG"
    VALUE
    0x8080396E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA57OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA57OR"
    VALUE
    0x80803970
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA57SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA57SCB"
    VALUE
    0x80803972
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA57SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA57SCG"
    VALUE
    0x80803974
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA59OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA59OL"
    VALUE
    0x80803976
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA59SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA59SCB"
    VALUE
    0x80803978
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inA59SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inA59SCG"
    VALUE
    0x8080397A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK10OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK10OR"
    VALUE
    0x8080397C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK10SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK10SCB"
    VALUE
    0x8080397E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK10SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK10SCG"
    VALUE
    0x80803980
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK11OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK11OR"
    VALUE
    0x80803982
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK11SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK11SCB"
    VALUE
    0x80803984
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK11SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK11SCG"
    VALUE
    0x80803986
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30AicSCB"
    VALUE
    0x80803988
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30AicSCG"
    VALUE
    0x8080398A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30OR"
    VALUE
    0x8080398C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30SCB"
    VALUE
    0x8080398E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30SCG"
    VALUE
    0x80803990
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK30ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80803992
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK31OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK31OR"
    VALUE
    0x80803994
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK31SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK31SCB"
    VALUE
    0x80803996
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK31SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK31SCG"
    VALUE
    0x80803998
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK32OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK32OR"
    VALUE
    0x8080399A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK32SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK32SCB"
    VALUE
    0x8080399C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK32SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK32SCG"
    VALUE
    0x8080399E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK33OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK33OR"
    VALUE
    0x808039A0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK33SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK33SCB"
    VALUE
    0x808039A2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK33SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK33SCG"
    VALUE
    0x808039A4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK34OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK34OR"
    VALUE
    0x808039A6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK34SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK34SCB"
    VALUE
    0x808039A8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK34SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK34SCG"
    VALUE
    0x808039AA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK35OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK35OR"
    VALUE
    0x808039AC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK35SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK35SCB"
    VALUE
    0x808039AE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK35SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK35SCG"
    VALUE
    0x808039B0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK36OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK36OR"
    VALUE
    0x808039B2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK36SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK36SCB"
    VALUE
    0x808039B4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK36SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK36SCG"
    VALUE
    0x808039B6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37AicSCB"
    VALUE
    0x808039B8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37AicSCG"
    VALUE
    0x808039BA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37OR"
    VALUE
    0x808039BC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37SCB"
    VALUE
    0x808039BE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37SCG"
    VALUE
    0x808039C0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK37ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x808039C2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38AicSCB"
    VALUE
    0x808039C4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38AicSCG"
    VALUE
    0x808039C6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38OR"
    VALUE
    0x808039C8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38SCB"
    VALUE
    0x808039CA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38SCG"
    VALUE
    0x808039CC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK38ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x808039CE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39AicSCB"
    VALUE
    0x808039D0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39AicSCG"
    VALUE
    0x808039D2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39OR"
    VALUE
    0x808039D4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39SCB"
    VALUE
    0x808039D6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39SCG"
    VALUE
    0x808039D8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK39ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x808039DA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40AicSCB"
    VALUE
    0x808039DC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40AicSCG"
    VALUE
    0x808039DE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40OR"
    VALUE
    0x808039E0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40SCB"
    VALUE
    0x808039E2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40SCG"
    VALUE
    0x808039E4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK40ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x808039E6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41AicSCB"
    VALUE
    0x808039E8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41AicSCG"
    VALUE
    0x808039EA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41OR"
    VALUE
    0x808039EC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41SCB"
    VALUE
    0x808039EE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41SCG"
    VALUE
    0x808039F0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK41ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x808039F2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42AicSCB"
    VALUE
    0x808039F4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42AicSCG"
    VALUE
    0x808039F6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42OR"
    VALUE
    0x808039F8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42SCB"
    VALUE
    0x808039FA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42SCG"
    VALUE
    0x808039FC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK42ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x808039FE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK43OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK43OR"
    VALUE
    0x80803A00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK43SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK43SCB"
    VALUE
    0x80803A02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK43SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK43SCG"
    VALUE
    0x80803A04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80803A06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44AicSCG"
    VALUE
    0x80803A08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44OR"
    VALUE
    0x80803A0A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44SCB"
    VALUE
    0x80803A0C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44SCG"
    VALUE
    0x80803A0E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK44ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80803A10
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45AicSCB"
    VALUE
    0x80803A12
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45AicSCG"
    VALUE
    0x80803A14
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45OR"
    VALUE
    0x80803A16
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45SCB"
    VALUE
    0x80803A18
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45SCG"
    VALUE
    0x80803A1A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK45ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80803A1C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK52OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK52OR"
    VALUE
    0x80803A1E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK52SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK52SCB"
    VALUE
    0x80803A20
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK52SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK52SCG"
    VALUE
    0x80803A22
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK53OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK53OR"
    VALUE
    0x80803A24
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK53SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK53SCB"
    VALUE
    0x80803A26
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK53SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK53SCG"
    VALUE
    0x80803A28
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54AicSCB"
    VALUE
    0x80803A2A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80803A2C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54OR"
    VALUE
    0x80803A2E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54SCB"
    VALUE
    0x80803A30
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54SCG"
    VALUE
    0x80803A32
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK54ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80803A34
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55AicSCB"
    VALUE
    0x80803A36
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55AicSCG"
    VALUE
    0x80803A38
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55OR"
    VALUE
    0x80803A3A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55SCB"
    VALUE
    0x80803A3C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55SCG"
    VALUE
    0x80803A3E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK55ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80803A40
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK56OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK56OR"
    VALUE
    0x80803A42
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK56SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK56SCB"
    VALUE
    0x80803A44
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK56SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK56SCG"
    VALUE
    0x80803A46
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK57OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK57OR"
    VALUE
    0x80803A48
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK57SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK57SCB"
    VALUE
    0x80803A4A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK57SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK57SCG"
    VALUE
    0x80803A4C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK58OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK58OR"
    VALUE
    0x80803A4E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK58SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK58SCB"
    VALUE
    0x80803A50
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK58SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK58SCG"
    VALUE
    0x80803A52
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK59OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK59OR"
    VALUE
    0x80803A54
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK59SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK59SCB"
    VALUE
    0x80803A56
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK59SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK59SCG"
    VALUE
    0x80803A58
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK60OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK60OR"
    VALUE
    0x80803A5A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK60SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK60SCB"
    VALUE
    0x80803A5C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK60SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK60SCG"
    VALUE
    0x80803A5E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61AicSCB"
    VALUE
    0x80803A60
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61AicSCG"
    VALUE
    0x80803A62
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61OR"
    VALUE
    0x80803A64
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61SCB"
    VALUE
    0x80803A66
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61SCG"
    VALUE
    0x80803A68
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK61ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80803A6A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK62OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK62OR"
    VALUE
    0x80803A6C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK62SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK62SCB"
    VALUE
    0x80803A6E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK62SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK62SCG"
    VALUE
    0x80803A70
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80803A72
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63AicSCG"
    VALUE
    0x80803A74
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63OR"
    VALUE
    0x80803A76
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63SCB"
    VALUE
    0x80803A78
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63SCG"
    VALUE
    0x80803A7A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK63ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80803A7C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64AicSCB"
    VALUE
    0x80803A7E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64AicSCG"
    VALUE
    0x80803A80
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64OR"
    VALUE
    0x80803A82
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64SCB"
    VALUE
    0x80803A84
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64SCG"
    VALUE
    0x80803A86
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK64ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80803A88
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65AicSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80803A8A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65AicSCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80803A8C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65OR"
    VALUE
    0x80803A8E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65SCB"
    VALUE
    0x80803A90
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65SCG"
    VALUE
    0x80803A92
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK65ShuntSCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80803A94
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK74OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK74OR"
    VALUE
    0x80803A96
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK74SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK74SCB"
    VALUE
    0x80803A98
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK74SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK74SCG"
    VALUE
    0x80803A9A
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK75OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK75OR"
    VALUE
    0x80803A9C
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK75SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK75SCB"
    VALUE
    0x80803A9E
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK75SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK75SCG"
    VALUE
    0x80803AA0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK76OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK76OR"
    VALUE
    0x80803AA2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK76SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK76SCB"
    VALUE
    0x80803AA4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK76SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK76SCG"
    VALUE
    0x80803AA6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK77OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK77OR"
    VALUE
    0x80803AA8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK77SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK77SCB"
    VALUE
    0x80803AAA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK77SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK77SCG"
    VALUE
    0x80803AAC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK78OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK78OR"
    VALUE
    0x80803AAE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK78SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK78SCB"
    VALUE
    0x80803AB0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_inK78SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_inK78SCG"
    VALUE
    0x80803AB2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_DvUBAT_FWs_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80803AB4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OVErr_VPR6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80803AB6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OVWarn_VPR6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80803AB8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80803ABA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80803ABC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_UBAT_MON_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80803ABE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80803AC0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80803AC2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_UBRM24_MON_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80803AC4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VDD5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80803AC6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VDD5_IN_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80803AC8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VPR6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80803ACA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VSS3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80803ACC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_OV_VSS4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80803ACE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_Temp1_HTErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80803AD0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_Temp1_HTWarn_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80803AD2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_Temp2_HTErr_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80803AD4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_Temp2_HTWarn_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80803AD6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80803AD8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80803ADA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VDD5_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80803ADC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VDD5_IN_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80803ADE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VPR6_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80803AE0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VSS3_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80803AE2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_mo_UV_VSS4_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80803AE4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA01OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA01OL"
    VALUE
    0x80803AE6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA01OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA01OT"
    VALUE
    0x80803AE8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA01SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA01SCB"
    VALUE
    0x80803AEA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA01SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA01SCG"
    VALUE
    0x80803AEC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02OL"
    VALUE
    0x80803AEE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02OR_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02OR"
    VALUE
    0x80803AF0
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02OT"
    VALUE
    0x80803AF2
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02SCB"
    VALUE
    0x80803AF4
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA02SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA02SCG"
    VALUE
    0x80803AF6
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03OL"
    VALUE
    0x80803AF8
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03OT"
    VALUE
    0x80803AFA
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03SCB"
    VALUE
    0x80803AFC
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA03SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA03SCG"
    VALUE
    0x80803AFE
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04OL"
    VALUE
    0x80803B00
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04OT_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04OT"
    VALUE
    0x80803B02
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04SCB_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04SCB"
    VALUE
    0x80803B04
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA04SCG_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA04SCG"
    VALUE
    0x80803B06
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05OL_C
    "manufacterer specific trouble code / Manufacturer specific diagnostic trouble code for check DFC_rbr_outA05OL"
    VALUE
    0x80803B08
    Val_Wu16
    65535.00
    DFES_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFES_DTCM.DFC_rbr_outA05OR_C
