/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8065UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8065"
    VALUE
    0x80803058
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8066UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8066"
    VALUE
    0x80803059
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8067UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8067"
    VALUE
    0x8080305A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8068UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8068"
    VALUE
    0x8080305B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8069UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8069"
    VALUE
    0x8080305C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x806aUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x806a"
    VALUE
    0x8080305D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x806bUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x806b"
    VALUE
    0x8080305E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x806cUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x806c"
    VALUE
    0x8080305F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x806dUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x806d"
    VALUE
    0x80803060
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x806eUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x806e"
    VALUE
    0x80803061
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x806fUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x806f"
    VALUE
    0x80803062
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8070UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8070"
    VALUE
    0x80803063
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8071UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8071"
    VALUE
    0x80803064
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8072UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8072"
    VALUE
    0x80803065
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8073UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8073"
    VALUE
    0x80803066
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8074UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8074"
    VALUE
    0x80803067
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8075UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8075"
    VALUE
    0x80803068
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8076UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8076"
    VALUE
    0x80803069
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8077UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8077"
    VALUE
    0x8080306A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8078UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8078"
    VALUE
    0x8080306B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8079UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8079"
    VALUE
    0x8080306C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x807aUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x807a"
    VALUE
    0x8080306D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x807bUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x807b"
    VALUE
    0x8080306E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x807cUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x807c"
    VALUE
    0x8080306F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x807dUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x807d"
    VALUE
    0x80803070
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x807eUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x807e"
    VALUE
    0x80803071
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x807fUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x807f"
    VALUE
    0x80803072
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8080UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8080"
    VALUE
    0x80803073
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8081UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8081"
    VALUE
    0x80803074
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8082UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8082"
    VALUE
    0x80803075
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8083UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8083"
    VALUE
    0x80803076
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8084UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8084"
    VALUE
    0x80803077
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8085UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8085"
    VALUE
    0x80803078
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8086UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8086"
    VALUE
    0x80803079
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8087UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8087"
    VALUE
    0x8080307A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8088UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8088"
    VALUE
    0x8080307B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8089UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8089"
    VALUE
    0x8080307C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x808aUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x808a"
    VALUE
    0x8080307D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x808bUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x808b"
    VALUE
    0x8080307E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x808cUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x808c"
    VALUE
    0x8080307F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x808dUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x808d"
    VALUE
    0x80803080
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x808eUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x808e"
    VALUE
    0x80803081
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x808fUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x808f"
    VALUE
    0x80803082
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8090UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8090"
    VALUE
    0x80803083
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8091UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8091"
    VALUE
    0x80803084
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8092UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8092"
    VALUE
    0x80803085
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8093UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8093"
    VALUE
    0x80803086
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8094UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8094"
    VALUE
    0x80803087
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8095UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8095"
    VALUE
    0x80803088
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8096UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8096"
    VALUE
    0x80803089
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8097UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8097"
    VALUE
    0x8080308A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8098UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8098"
    VALUE
    0x8080308B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x8099UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x8099"
    VALUE
    0x8080308C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x809aUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x809a"
    VALUE
    0x8080308D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x809bUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x809b"
    VALUE
    0x8080308E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x809cUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x809c"
    VALUE
    0x8080308F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x809dUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x809d"
    VALUE
    0x80803090
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x809eUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x809e"
    VALUE
    0x80803091
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x809fUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x809f"
    VALUE
    0x80803092
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80a0UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80a0"
    VALUE
    0x80803093
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80a1UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80a1"
    VALUE
    0x80803094
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80a2UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80a2"
    VALUE
    0x80803095
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80a3UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80a3"
    VALUE
    0x80803096
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80a4UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80a4"
    VALUE
    0x80803097
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80a5UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80803098
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80a6UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80a6"
    VALUE
    0x80803099
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80a7UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80a7"
    VALUE
    0x8080309A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80a8UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80a8"
    VALUE
    0x8080309B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80a9UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80a9"
    VALUE
    0x8080309C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80aaUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80aa"
    VALUE
    0x8080309D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80abUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80ab"
    VALUE
    0x8080309E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80acUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80ac"
    VALUE
    0x8080309F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80adUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80ad"
    VALUE
    0x808030A0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80aeUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80ae"
    VALUE
    0x808030A1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80afUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80af"
    VALUE
    0x808030A2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80b0UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80b0"
    VALUE
    0x808030A3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80b1UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80b1"
    VALUE
    0x808030A4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80b2UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80b2"
    VALUE
    0x808030A5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80b3UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80b3"
    VALUE
    0x808030A6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80b4UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80b4"
    VALUE
    0x808030A7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80b5UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80b5"
    VALUE
    0x808030A8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80b6UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80b6"
    VALUE
    0x808030A9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80b7UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80b7"
    VALUE
    0x808030AA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80b8UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80b8"
    VALUE
    0x808030AB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80b9UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80b9"
    VALUE
    0x808030AC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80baUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80ba"
    VALUE
    0x808030AD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80bbUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80bb"
    VALUE
    0x808030AE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80bcUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80bc"
    VALUE
    0x808030AF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80bdUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80bd"
    VALUE
    0x808030B0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80beUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80be"
    VALUE
    0x808030B1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80bfUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80bf"
    VALUE
    0x808030B2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80c0UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80c0"
    VALUE
    0x808030B3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80c1UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80c1"
    VALUE
    0x808030B4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80c2UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80c2"
    VALUE
    0x808030B5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80c3UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80c3"
    VALUE
    0x808030B6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80c4UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80c4"
    VALUE
    0x808030B7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80c5UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80c5"
    VALUE
    0x808030B8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_NoDeb0x80c6UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_NoDeb0x80c6"
    VALUE
    0x808030B9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_TiUpDwn0x8A01UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x808030BA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_TiUpDwn0x8A02UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x808030BB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.cal_TiUpDwn0x8A03UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x808030BC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tK44SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44SCB"
    VALUE
    0x808030BD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA13ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA13OR"
    VALUE
    0x808030BE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA13SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA13SCB"
    VALUE
    0x808030BF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA13SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA13SCG"
    VALUE
    0x808030C0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA14ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA14OR"
    VALUE
    0x808030C1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA14SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA14SCB"
    VALUE
    0x808030C2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA14SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA14SCG"
    VALUE
    0x808030C3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA21ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA21OR"
    VALUE
    0x808030C4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA21SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA21SCB"
    VALUE
    0x808030C5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA21SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA21SCG"
    VALUE
    0x808030C6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA22ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA22OR"
    VALUE
    0x808030C7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA22SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA22SCB"
    VALUE
    0x808030C8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA22SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA22SCG"
    VALUE
    0x808030C9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA23ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA23OR"
    VALUE
    0x808030CA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA23SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA23SCB"
    VALUE
    0x808030CB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA23SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA23SCG"
    VALUE
    0x808030CC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA24ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA24OR"
    VALUE
    0x808030CD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA24SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA24SCB"
    VALUE
    0x808030CE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA24SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA24SCG"
    VALUE
    0x808030CF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA25ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA25OR"
    VALUE
    0x808030D0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA25SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA25SCB"
    VALUE
    0x808030D1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA25SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA25SCG"
    VALUE
    0x808030D2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA26ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA26OR"
    VALUE
    0x808030D3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA26SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA26SCB"
    VALUE
    0x808030D4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA26SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA26SCG"
    VALUE
    0x808030D5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA27ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA27OR"
    VALUE
    0x808030D6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA27SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA27SCB"
    VALUE
    0x808030D7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA27SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA27SCG"
    VALUE
    0x808030D8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA28ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA28OR"
    VALUE
    0x808030D9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA28SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA28SCB"
    VALUE
    0x808030DA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA28SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA28SCG"
    VALUE
    0x808030DB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA29ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA29OR"
    VALUE
    0x808030DC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA29SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA29SCB"
    VALUE
    0x808030DD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA29SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA29SCG"
    VALUE
    0x808030DE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36AicSCB"
    VALUE
    0x808030DF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36AicSCG"
    VALUE
    0x808030E0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36OR"
    VALUE
    0x808030E1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36SCB"
    VALUE
    0x808030E2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36SCG"
    VALUE
    0x808030E3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA36ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x808030E4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37AicSCB"
    VALUE
    0x808030E5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37AicSCG"
    VALUE
    0x808030E6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37OR"
    VALUE
    0x808030E7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37SCB"
    VALUE
    0x808030E8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37SCG"
    VALUE
    0x808030E9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA37ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x808030EA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38AicSCB"
    VALUE
    0x808030EB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38AicSCG"
    VALUE
    0x808030EC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38OR"
    VALUE
    0x808030ED
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38SCB"
    VALUE
    0x808030EE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38SCG"
    VALUE
    0x808030EF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA38ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x808030F0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39AicSCB"
    VALUE
    0x808030F1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39AicSCG"
    VALUE
    0x808030F2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39OR"
    VALUE
    0x808030F3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39SCB"
    VALUE
    0x808030F4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39SCG"
    VALUE
    0x808030F5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA39ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x808030F6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA40ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA40OR"
    VALUE
    0x808030F7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA40SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA40SCB"
    VALUE
    0x808030F8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA40SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA40SCG"
    VALUE
    0x808030F9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA41ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA41OR"
    VALUE
    0x808030FA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA41SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA41SCB"
    VALUE
    0x808030FB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA41SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA41SCG"
    VALUE
    0x808030FC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA42ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA42OR"
    VALUE
    0x808030FD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA42SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA42SCB"
    VALUE
    0x808030FE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA42SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA42SCG"
    VALUE
    0x808030FF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43AicSCB"
    VALUE
    0x80803100
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43AicSCG"
    VALUE
    0x80803101
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43OR"
    VALUE
    0x80803102
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43SCB"
    VALUE
    0x80803103
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43SCG"
    VALUE
    0x80803104
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA43ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80803105
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA44OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA44OL"
    VALUE
    0x80803106
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA44SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA44SCB"
    VALUE
    0x80803107
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA44SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA44SCG"
    VALUE
    0x80803108
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA57ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA57OR"
    VALUE
    0x80803109
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA57SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA57SCB"
    VALUE
    0x8080310A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA57SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA57SCG"
    VALUE
    0x8080310B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA59OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA59OL"
    VALUE
    0x8080310C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA59SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA59SCB"
    VALUE
    0x8080310D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiA59SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inA59SCG"
    VALUE
    0x8080310E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK10ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK10OR"
    VALUE
    0x8080310F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK10SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK10SCB"
    VALUE
    0x80803110
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK10SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK10SCG"
    VALUE
    0x80803111
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK11ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK11OR"
    VALUE
    0x80803112
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK11SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK11SCB"
    VALUE
    0x80803113
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK11SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK11SCG"
    VALUE
    0x80803114
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30AicSCB"
    VALUE
    0x80803115
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30AicSCG"
    VALUE
    0x80803116
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30OR"
    VALUE
    0x80803117
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30SCB"
    VALUE
    0x80803118
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30SCG"
    VALUE
    0x80803119
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK30ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x8080311A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK31ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK31OR"
    VALUE
    0x8080311B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK31SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK31SCB"
    VALUE
    0x8080311C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK31SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK31SCG"
    VALUE
    0x8080311D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK32ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK32OR"
    VALUE
    0x8080311E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK32SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK32SCB"
    VALUE
    0x8080311F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK32SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK32SCG"
    VALUE
    0x80803120
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK33ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK33OR"
    VALUE
    0x80803121
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK33SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK33SCB"
    VALUE
    0x80803122
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK33SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK33SCG"
    VALUE
    0x80803123
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK34ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK34OR"
    VALUE
    0x80803124
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK34SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK34SCB"
    VALUE
    0x80803125
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK34SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK34SCG"
    VALUE
    0x80803126
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK35ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK35OR"
    VALUE
    0x80803127
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK35SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK35SCB"
    VALUE
    0x80803128
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK35SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK35SCG"
    VALUE
    0x80803129
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK36ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK36OR"
    VALUE
    0x8080312A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK36SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK36SCB"
    VALUE
    0x8080312B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK36SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK36SCG"
    VALUE
    0x8080312C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37AicSCB"
    VALUE
    0x8080312D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37AicSCG"
    VALUE
    0x8080312E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37OR"
    VALUE
    0x8080312F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37SCB"
    VALUE
    0x80803130
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37SCG"
    VALUE
    0x80803131
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK37ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80803132
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38AicSCB"
    VALUE
    0x80803133
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38AicSCG"
    VALUE
    0x80803134
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38OR"
    VALUE
    0x80803135
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38SCB"
    VALUE
    0x80803136
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38SCG"
    VALUE
    0x80803137
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK38ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80803138
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39AicSCB"
    VALUE
    0x80803139
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39AicSCG"
    VALUE
    0x8080313A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39OR"
    VALUE
    0x8080313B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39SCB"
    VALUE
    0x8080313C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39SCG"
    VALUE
    0x8080313D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK39ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x8080313E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40AicSCB"
    VALUE
    0x8080313F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40AicSCG"
    VALUE
    0x80803140
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40OR"
    VALUE
    0x80803141
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40SCB"
    VALUE
    0x80803142
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40SCG"
    VALUE
    0x80803143
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK40ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80803144
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41AicSCB"
    VALUE
    0x80803145
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41AicSCG"
    VALUE
    0x80803146
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41OR"
    VALUE
    0x80803147
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41SCB"
    VALUE
    0x80803148
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41SCG"
    VALUE
    0x80803149
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK41ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x8080314A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42AicSCB"
    VALUE
    0x8080314B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42AicSCG"
    VALUE
    0x8080314C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42OR"
    VALUE
    0x8080314D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42SCB"
    VALUE
    0x8080314E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42SCG"
    VALUE
    0x8080314F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK42ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80803150
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK43ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK43OR"
    VALUE
    0x80803151
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK43SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK43SCB"
    VALUE
    0x80803152
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK43SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK43SCG"
    VALUE
    0x80803153
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK44AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44AicSCB"
    VALUE
    0x80803154
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK44AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44AicSCG"
    VALUE
    0x80803155
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK44ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44OR"
    VALUE
    0x80803156
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK44SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44SCG"
    VALUE
    0x80803157
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK44ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80803158
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45AicSCB"
    VALUE
    0x80803159
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45AicSCG"
    VALUE
    0x8080315A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45OR"
    VALUE
    0x8080315B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45SCB"
    VALUE
    0x8080315C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45SCG"
    VALUE
    0x8080315D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK45ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x8080315E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK52ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK52OR"
    VALUE
    0x8080315F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK52SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK52SCB"
    VALUE
    0x80803160
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK52SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK52SCG"
    VALUE
    0x80803161
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK53ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK53OR"
    VALUE
    0x80803162
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK53SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK53SCB"
    VALUE
    0x80803163
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK53SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK53SCG"
    VALUE
    0x80803164
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54AicSCB"
    VALUE
    0x80803165
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54AicSCG"
    VALUE
    0x80803166
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54OR"
    VALUE
    0x80803167
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54SCB"
    VALUE
    0x80803168
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54SCG"
    VALUE
    0x80803169
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK54ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x8080316A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55AicSCB"
    VALUE
    0x8080316B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55AicSCG"
    VALUE
    0x8080316C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55OR"
    VALUE
    0x8080316D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55SCB"
    VALUE
    0x8080316E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55SCG"
    VALUE
    0x8080316F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK55ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80803170
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK56ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK56OR"
    VALUE
    0x80803171
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK56SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK56SCB"
    VALUE
    0x80803172
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK56SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK56SCG"
    VALUE
    0x80803173
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK57ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK57OR"
    VALUE
    0x80803174
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK57SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK57SCB"
    VALUE
    0x80803175
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK57SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK57SCG"
    VALUE
    0x80803176
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK58ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK58OR"
    VALUE
    0x80803177
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK58SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK58SCB"
    VALUE
    0x80803178
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK58SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK58SCG"
    VALUE
    0x80803179
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK59ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK59OR"
    VALUE
    0x8080317A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK59SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK59SCB"
    VALUE
    0x8080317B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK59SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK59SCG"
    VALUE
    0x8080317C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK60ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK60OR"
    VALUE
    0x8080317D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK60SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK60SCB"
    VALUE
    0x8080317E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK60SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK60SCG"
    VALUE
    0x8080317F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61AicSCB"
    VALUE
    0x80803180
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61AicSCG"
    VALUE
    0x80803181
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61OR"
    VALUE
    0x80803182
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61SCB"
    VALUE
    0x80803183
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61SCG"
    VALUE
    0x80803184
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK61ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80803185
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK62ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK62OR"
    VALUE
    0x80803186
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK62SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK62SCB"
    VALUE
    0x80803187
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK62SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK62SCG"
    VALUE
    0x80803188
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63AicSCB"
    VALUE
    0x80803189
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63AicSCG"
    VALUE
    0x8080318A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63OR"
    VALUE
    0x8080318B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63SCB"
    VALUE
    0x8080318C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63SCG"
    VALUE
    0x8080318D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK63ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x8080318E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64AicSCB"
    VALUE
    0x8080318F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64AicSCG"
    VALUE
    0x80803190
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64OR"
    VALUE
    0x80803191
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64SCB"
    VALUE
    0x80803192
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64SCG"
    VALUE
    0x80803193
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK64ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80803194
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65AicSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65AicSCB"
    VALUE
    0x80803195
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65AicSCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65AicSCG"
    VALUE
    0x80803196
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65OR"
    VALUE
    0x80803197
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65SCB"
    VALUE
    0x80803198
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65SCG"
    VALUE
    0x80803199
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK65ShuntSCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x8080319A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK74ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK74OR"
    VALUE
    0x8080319B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK74SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK74SCB"
    VALUE
    0x8080319C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK74SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK74SCG"
    VALUE
    0x8080319D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK75ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK75OR"
    VALUE
    0x8080319E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK75SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK75SCB"
    VALUE
    0x8080319F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK75SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK75SCG"
    VALUE
    0x808031A0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK76ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK76OR"
    VALUE
    0x808031A1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK76SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK76SCB"
    VALUE
    0x808031A2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK76SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK76SCG"
    VALUE
    0x808031A3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK77ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK77OR"
    VALUE
    0x808031A4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK77SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK77SCB"
    VALUE
    0x808031A5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK77SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK77SCG"
    VALUE
    0x808031A6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK78ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK78OR"
    VALUE
    0x808031A7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK78SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK78SCB"
    VALUE
    0x808031A8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrIn_tiK78SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_inK78SCG"
    VALUE
    0x808031A9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK07OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK07OL"
    VALUE
    0x808031AA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK07ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK07OR"
    VALUE
    0x808031AB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK07OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK07OT"
    VALUE
    0x808031AC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK07SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK07SCB"
    VALUE
    0x808031AD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK07SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK07SCG"
    VALUE
    0x808031AE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK08OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK08OL"
    VALUE
    0x808031AF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK08ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK08OR"
    VALUE
    0x808031B0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK08OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK08OT"
    VALUE
    0x808031B1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK08SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK08SCB"
    VALUE
    0x808031B2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK08SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK08SCG"
    VALUE
    0x808031B3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK09OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK09OL"
    VALUE
    0x808031B4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK09ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK09OR"
    VALUE
    0x808031B5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK09OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK09OT"
    VALUE
    0x808031B6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK09SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK09SCB"
    VALUE
    0x808031B7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK09SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK09SCG"
    VALUE
    0x808031B8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK12OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK12OL"
    VALUE
    0x808031B9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK12OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK12OT"
    VALUE
    0x808031BA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK12SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK12SCB"
    VALUE
    0x808031BB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK12SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK12SCG"
    VALUE
    0x808031BC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK13OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK13OL"
    VALUE
    0x808031BD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK13OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK13OT"
    VALUE
    0x808031BE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK13SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK13SCB"
    VALUE
    0x808031BF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK13SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK13SCG"
    VALUE
    0x808031C0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK14OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK14OL"
    VALUE
    0x808031C1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK14OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK14OT"
    VALUE
    0x808031C2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK14SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK14SCB"
    VALUE
    0x808031C3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK14SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK14SCG"
    VALUE
    0x808031C4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK15OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK15OL"
    VALUE
    0x808031C5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK15OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK15OT"
    VALUE
    0x808031C6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK15SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK15SCB"
    VALUE
    0x808031C7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK15SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK15SCG"
    VALUE
    0x808031C8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK16OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK16OL"
    VALUE
    0x808031C9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK16OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK16OT"
    VALUE
    0x808031CA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK16SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK16SCB"
    VALUE
    0x808031CB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK16SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK16SCG"
    VALUE
    0x808031CC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK25ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK25OR"
    VALUE
    0x808031CD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK25SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK25SCB"
    VALUE
    0x808031CE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK25SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK25SCG"
    VALUE
    0x808031CF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK29OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK29OL"
    VALUE
    0x808031D0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK29ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK29OR"
    VALUE
    0x808031D1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK29OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK29OT"
    VALUE
    0x808031D2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK29SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK29SCB"
    VALUE
    0x808031D3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK29SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK29SCG"
    VALUE
    0x808031D4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK51OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK51OL"
    VALUE
    0x808031D5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK51OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK51OT"
    VALUE
    0x808031D6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK51SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK51SCB"
    VALUE
    0x808031D7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK51SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK51SCG"
    VALUE
    0x808031D8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK62ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK62OR"
    VALUE
    0x808031D9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK62SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK62SCB"
    VALUE
    0x808031DA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK62SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK62SCG"
    VALUE
    0x808031DB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK73OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK73OL"
    VALUE
    0x808031DC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK73ORUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK73OR"
    VALUE
    0x808031DD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK73OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK73OT"
    VALUE
    0x808031DE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK73SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK73SCB"
    VALUE
    0x808031DF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK73SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK73SCG"
    VALUE
    0x808031E0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK80OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK80OL"
    VALUE
    0x808031E1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK80OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK80OT"
    VALUE
    0x808031E2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK80SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK80SCB"
    VALUE
    0x808031E3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK80SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK80SCG"
    VALUE
    0x808031E4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK81OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK81OL"
    VALUE
    0x808031E5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK81OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK81OT"
    VALUE
    0x808031E6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK81SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK81SCB"
    VALUE
    0x808031E7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK81SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK81SCG"
    VALUE
    0x808031E8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK82OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK82OL"
    VALUE
    0x808031E9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK82OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK82OT"
    VALUE
    0x808031EA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK82SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK82SCB"
    VALUE
    0x808031EB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK82SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK82SCG"
    VALUE
    0x808031EC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK83OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK83OL"
    VALUE
    0x808031ED
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK83OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK83OT"
    VALUE
    0x808031EE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK83SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK83SCB"
    VALUE
    0x808031EF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK83SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK83SCG"
    VALUE
    0x808031F0
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK84OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK84OL"
    VALUE
    0x808031F1
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK84OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK84OT"
    VALUE
    0x808031F2
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK84SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK84SCB"
    VALUE
    0x808031F3
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK84SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK84SCG"
    VALUE
    0x808031F4
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK85OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK85OL"
    VALUE
    0x808031F5
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK85OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK85OT"
    VALUE
    0x808031F6
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK85SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK85SCB"
    VALUE
    0x808031F7
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK85SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK85SCG"
    VALUE
    0x808031F8
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK86OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK86OL"
    VALUE
    0x808031F9
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK86OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK86OT"
    VALUE
    0x808031FA
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK86SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK86SCB"
    VALUE
    0x808031FB
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK86SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK86SCG"
    VALUE
    0x808031FC
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK87OLUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK87OL"
    VALUE
    0x808031FD
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK87OTUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK87OT"
    VALUE
    0x808031FE
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK87SCBUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK87SCB"
    VALUE
    0x808031FF
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbrOut_tiK87SCGUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_outK87SCG"
    VALUE
    0x80803200
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_DvUBAT_FWsUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80803201
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OVErr_VPR6UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80803202
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OVWarn_VPR6UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80803203
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80803204
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_UBAT_MONUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80803205
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_UBRM24_FLEXINUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80803206
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_UBRM24_LOADSUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80803207
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_UBRM24_MONUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80803208
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_VDD5UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80803209
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_VDD5_INUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x8080320A
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_VPR6UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x8080320B
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_VSS3UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x8080320C
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_OV_VSS4UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x8080320D
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_Temp1_HTErrUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x8080320E
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_Temp1_HTWarnUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x8080320F
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_Temp2_HTErrUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80803210
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_Temp2_HTWarnUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80803211
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80803212
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_VDD5UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80803213
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_VDD5_INUDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80803214
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_VPR6UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80803215
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_VSS3UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80803216
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_RatDeb.rbr_mo_UV_VSS4UDRat_C
    "Ratioof up-down debouncing / Defect / Heal Ratio for check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x80803217
    Val_Wu8
    3.00000000000
    DDRC_Ratio
    1.00000000000
    4.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DevLib_DigOutDbgSig_C
    "Calibration parameter to select the Digital out signal for which the debugging information is to be updated into the measuring points"
    VALUE
    0x8080911A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facLowHysLo_C
    "Structure containing hysterisis limits for battery voltage correction factor / Lower hysterisis limit for battery correction factor LOW."
    VALUE
    0x8080911E
    Kw_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facLowHysHi_C
    "Structure containing hysterisis limits for battery voltage correction factor / Higher hysterisis limit for battery correction factor LOW."
    VALUE
    0x80809120
    Kw_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facHighHysLo_C
    "Structure containing hysterisis limits for battery voltage correction factor / Lower hysterisis limit for battery correction factor HIGH."
    VALUE
    0x80809122
    Kw_Ws16
    2.000000
    Fact
    1.000000
    3.000000

    FORMAT "%8.6"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facHighHysHi_C
    "Structure containing hysterisis limits for battery voltage correction factor / Higher hysterisis limit for battery correction factor HIGH."
    VALUE
    0x80809124
    Kw_Ws16
    2.000000
    Fact
    1.000000
    3.000000

    FORMAT "%8.6"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DevLib_PWMOutDbgSig_C
    "Calibration parameter to select the PWM out signal for which the debugging information is to be updated into the measuring points"
    VALUE
    0x8080911C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattLoHysLo_C
    "Structure containing hysterisis check for battery voltage LOW/HIGH / Lower limit for battery voltage LOW hysterisis check."
    VALUE
    0x80809126
    Kw_Ws16
    9000.000
    Volt_Batt
    3000.00
    12000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattLoHysHi_C
    "Structure containing hysterisis check for battery voltage LOW/HIGH / Higher limit for battery voltage LOW hysterisis check"
    VALUE
    0x80809128
    Kw_Ws16
    9000.000
    Volt_Batt
    3000.00
    12000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattHiHysLo_C
    "Structure containing hysterisis check for battery voltage LOW/HIGH / Lower limit for battery voltage HIGH hysterisis check"
    VALUE
    0x8080912A
    Kw_Ws16
    24000.00
    Volt_Batt
    12000.00
    36000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattHiHysHi_C
    "Structure containing hysterisis check for battery voltage LOW/HIGH / Upper limit for battery voltage HIGH hysterisis check"
    VALUE
    0x8080912C
    Kw_Ws16
    24000.00
    Volt_Batt
    12000.00
    36000.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_Unused_C
    "Behaviour control mask / "
    VALUE
    0x80800E34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    READ_ONLY

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80c7_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80c7"
    VALUE
    0x80800E35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80c8_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80c8"
    VALUE
    0x80800E36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80c9_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80c9"
    VALUE
    0x80800E37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ca_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ca"
    VALUE
    0x80800E38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80cb_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80cb"
    VALUE
    0x80800E39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80cc_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80cc"
    VALUE
    0x80800E3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80cd_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80cd"
    VALUE
    0x80800E3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ce_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ce"
    VALUE
    0x80800E3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80cf_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80cf"
    VALUE
    0x80800E3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80d0_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80d0"
    VALUE
    0x80800E3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80d1_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80d1"
    VALUE
    0x80800E3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80d2_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80d2"
    VALUE
    0x80800E40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80d3_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80d3"
    VALUE
    0x80800E41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80d4_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80d4"
    VALUE
    0x80800E42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80d5_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80d5"
    VALUE
    0x80800E43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80d6_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80d6"
    VALUE
    0x80800E44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80d7_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80d7"
    VALUE
    0x80800E45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80d8_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80d8"
    VALUE
    0x80800E46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80d9_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80d9"
    VALUE
    0x80800E47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80da_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80da"
    VALUE
    0x80800E48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80db_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80db"
    VALUE
    0x80800E49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80dc_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80dc"
    VALUE
    0x80800E4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80dd_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80dd"
    VALUE
    0x80800E4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80de_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80de"
    VALUE
    0x80800E4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80df_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80df"
    VALUE
    0x80800E4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80e0_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80e0"
    VALUE
    0x80800E4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80e1_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80e1"
    VALUE
    0x80800E4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80e2_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80e2"
    VALUE
    0x80800E50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80e3_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80e3"
    VALUE
    0x80800E51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80e4_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80e4"
    VALUE
    0x80800E52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80e5_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80e5"
    VALUE
    0x80800E53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80e6_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80e6"
    VALUE
    0x80800E54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80e7_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80e7"
    VALUE
    0x80800E55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80e8_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80e8"
    VALUE
    0x80800E56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80e9_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80e9"
    VALUE
    0x80800E57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ea_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ea"
    VALUE
    0x80800E58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80eb_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80eb"
    VALUE
    0x80800E59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ec_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ec"
    VALUE
    0x80800E5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ed_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ed"
    VALUE
    0x80800E5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ee_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ee"
    VALUE
    0x80800E5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ef_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ef"
    VALUE
    0x80800E5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80f0_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80f0"
    VALUE
    0x80800E5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80f1_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80f1"
    VALUE
    0x80800E5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80f2_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80f2"
    VALUE
    0x80800E60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80f3_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80f3"
    VALUE
    0x80800E61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80f4_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80f4"
    VALUE
    0x80800E62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80f5_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80f5"
    VALUE
    0x80800E63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80f6_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80f6"
    VALUE
    0x80800E64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80f7_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80f7"
    VALUE
    0x80800E65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80f8_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80f8"
    VALUE
    0x80800E66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80f9_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80f9"
    VALUE
    0x80800E67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80fa_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80fa"
    VALUE
    0x80800E68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80fb_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80fb"
    VALUE
    0x80800E69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80fc_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80fc"
    VALUE
    0x80800E6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80fd_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80fd"
    VALUE
    0x80800E6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80fe_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80fe"
    VALUE
    0x80800E6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ff_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ff"
    VALUE
    0x80800E6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8100_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8100"
    VALUE
    0x80800E6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8101_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8101"
    VALUE
    0x80800E6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8102_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8102"
    VALUE
    0x80800E70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8103_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8103"
    VALUE
    0x80800E71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8104_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8104"
    VALUE
    0x80800E72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8105_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8105"
    VALUE
    0x80800E73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8106_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8106"
    VALUE
    0x80800E74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8107_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8107"
    VALUE
    0x80800E75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8108_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8108"
    VALUE
    0x80800E76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8109_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8109"
    VALUE
    0x80800E77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x810a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x810a"
    VALUE
    0x80800E78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x810b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x810b"
    VALUE
    0x80800E79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x810c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x810c"
    VALUE
    0x80800E7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x810d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x810d"
    VALUE
    0x80800E7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x810e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x810e"
    VALUE
    0x80800E7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x810f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x810f"
    VALUE
    0x80800E7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8110_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8110"
    VALUE
    0x80800E7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8111_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8111"
    VALUE
    0x80800E7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8112_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8112"
    VALUE
    0x80800E80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8113_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8113"
    VALUE
    0x80800E81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8114_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8114"
    VALUE
    0x80800E82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8115_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8115"
    VALUE
    0x80800E83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8116_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8116"
    VALUE
    0x80800E84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8117_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8117"
    VALUE
    0x80800E85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8118_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8118"
    VALUE
    0x80800E86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8119_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8119"
    VALUE
    0x80800E87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x811a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x811a"
    VALUE
    0x80800E88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x811b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x811b"
    VALUE
    0x80800E89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x811c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x811c"
    VALUE
    0x80800E8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x811d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x811d"
    VALUE
    0x80800E8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x811e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x811e"
    VALUE
    0x80800E8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x811f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x811f"
    VALUE
    0x80800E8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8120_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8120"
    VALUE
    0x80800E8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8121_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8121"
    VALUE
    0x80800E8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8122_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8122"
    VALUE
    0x80800E90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8123_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8123"
    VALUE
    0x80800E91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8124_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8124"
    VALUE
    0x80800E92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8125_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8125"
    VALUE
    0x80800E93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8126_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8126"
    VALUE
    0x80800E94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8127_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8127"
    VALUE
    0x80800E95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8128_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8128"
    VALUE
    0x80800E96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8129_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8129"
    VALUE
    0x80800E97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x812a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x812a"
    VALUE
    0x80800E98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_TiInRow0x8B01_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_TiInRow0x8B01"
    VALUE
    0x80800E99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_TiInRow0x8B02_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_TiInRow0x8B02"
    VALUE
    0x80800E9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_TiInRow0x8B03_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_TiInRow0x8B03"
    VALUE
    0x80800E9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_DevLibBattUHi_C
    "Behaviour control mask / Behaviour control masks of check DFC_DevLibBattUHi"
    VALUE
    0x80800E9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_DevLibBattULo_C
    "Behaviour control mask / Behaviour control masks of check DFC_DevLibBattULo"
    VALUE
    0x80800E9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8063_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8063"
    VALUE
    0x80800E9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8064_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8064"
    VALUE
    0x80800E9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8065_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8065"
    VALUE
    0x80800EA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8066_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8066"
    VALUE
    0x80800EA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8067_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8067"
    VALUE
    0x80800EA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8068_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8068"
    VALUE
    0x80800EA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8069_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8069"
    VALUE
    0x80800EA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x806a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x806a"
    VALUE
    0x80800EA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x806b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x806b"
    VALUE
    0x80800EA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x806c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x806c"
    VALUE
    0x80800EA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x806d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x806d"
    VALUE
    0x80800EA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x806e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x806e"
    VALUE
    0x80800EA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x806f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x806f"
    VALUE
    0x80800EAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8070_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8070"
    VALUE
    0x80800EAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8071_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8071"
    VALUE
    0x80800EAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8072_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8072"
    VALUE
    0x80800EAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8073_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8073"
    VALUE
    0x80800EAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8074_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8074"
    VALUE
    0x80800EAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8075_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8075"
    VALUE
    0x80800EB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8076_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8076"
    VALUE
    0x80800EB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8077_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8077"
    VALUE
    0x80800EB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8078_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8078"
    VALUE
    0x80800EB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8079_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8079"
    VALUE
    0x80800EB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x807a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x807a"
    VALUE
    0x80800EB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x807b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x807b"
    VALUE
    0x80800EB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x807c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x807c"
    VALUE
    0x80800EB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x807d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x807d"
    VALUE
    0x80800EB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x807e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x807e"
    VALUE
    0x80800EB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x807f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x807f"
    VALUE
    0x80800EBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8080_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8080"
    VALUE
    0x80800EBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8081_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8081"
    VALUE
    0x80800EBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8082_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8082"
    VALUE
    0x80800EBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8083_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8083"
    VALUE
    0x80800EBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8084_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8084"
    VALUE
    0x80800EBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8085_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8085"
    VALUE
    0x80800EC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8086_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8086"
    VALUE
    0x80800EC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8087_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8087"
    VALUE
    0x80800EC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8088_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8088"
    VALUE
    0x80800EC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8089_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8089"
    VALUE
    0x80800EC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x808a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x808a"
    VALUE
    0x80800EC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x808b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x808b"
    VALUE
    0x80800EC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x808c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x808c"
    VALUE
    0x80800EC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x808d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x808d"
    VALUE
    0x80800EC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x808e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x808e"
    VALUE
    0x80800EC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x808f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x808f"
    VALUE
    0x80800ECA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8090_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8090"
    VALUE
    0x80800ECB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8091_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8091"
    VALUE
    0x80800ECC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8092_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8092"
    VALUE
    0x80800ECD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8093_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8093"
    VALUE
    0x80800ECE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8094_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8094"
    VALUE
    0x80800ECF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8095_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8095"
    VALUE
    0x80800ED0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8096_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8096"
    VALUE
    0x80800ED1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8097_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8097"
    VALUE
    0x80800ED2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8098_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8098"
    VALUE
    0x80800ED3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8099_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8099"
    VALUE
    0x80800ED4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x809a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x809a"
    VALUE
    0x80800ED5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x809b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x809b"
    VALUE
    0x80800ED6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x809c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x809c"
    VALUE
    0x80800ED7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x809d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x809d"
    VALUE
    0x80800ED8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x809e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x809e"
    VALUE
    0x80800ED9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x809f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x809f"
    VALUE
    0x80800EDA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80a0_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80a0"
    VALUE
    0x80800EDB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80a1_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80a1"
    VALUE
    0x80800EDC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80a2_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80a2"
    VALUE
    0x80800EDD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80a3_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80a3"
    VALUE
    0x80800EDE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80a4_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80a4"
    VALUE
    0x80800EDF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80a5_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80a5"
    VALUE
    0x80800EE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80a6_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80a6"
    VALUE
    0x80800EE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80a7_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80a7"
    VALUE
    0x80800EE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80a8_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80a8"
    VALUE
    0x80800EE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80a9_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80a9"
    VALUE
    0x80800EE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80aa_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80aa"
    VALUE
    0x80800EE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ab_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ab"
    VALUE
    0x80800EE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ac_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ac"
    VALUE
    0x80800EE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ad_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ad"
    VALUE
    0x80800EE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ae_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ae"
    VALUE
    0x80800EE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80af_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80af"
    VALUE
    0x80800EEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80b0_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80b0"
    VALUE
    0x80800EEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80b1_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80b1"
    VALUE
    0x80800EEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80b2_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80b2"
    VALUE
    0x80800EED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80b3_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80b3"
    VALUE
    0x80800EEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80b4_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80b4"
    VALUE
    0x80800EEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80b5_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80b5"
    VALUE
    0x80800EF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80b6_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80b6"
    VALUE
    0x80800EF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80b7_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80b7"
    VALUE
    0x80800EF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80b8_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80b8"
    VALUE
    0x80800EF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80b9_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80b9"
    VALUE
    0x80800EF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80ba_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80ba"
    VALUE
    0x80800EF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80bb_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80bb"
    VALUE
    0x80800EF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80bc_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80bc"
    VALUE
    0x80800EF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80bd_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80bd"
    VALUE
    0x80800EF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80be_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80be"
    VALUE
    0x80800EF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80bf_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80bf"
    VALUE
    0x80800EFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80c0_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80c0"
    VALUE
    0x80800EFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80c1_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80c1"
    VALUE
    0x80800EFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80c2_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80c2"
    VALUE
    0x80800EFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80c3_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80c3"
    VALUE
    0x80800EFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80c4_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80c4"
    VALUE
    0x80800EFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80c5_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80c5"
    VALUE
    0x80800F00
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x80c6_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x80c6"
    VALUE
    0x80800F01
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_TiUpDwn0x8A01_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_TiUpDwn0x8A01"
    VALUE
    0x80800F02
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_TiUpDwn0x8A02_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_TiUpDwn0x8A02"
    VALUE
    0x80800F03
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_TiUpDwn0x8A03_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_TiUpDwn0x8A03"
    VALUE
    0x80800F04
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA13OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA13OR"
    VALUE
    0x80800F05
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA13SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA13SCB"
    VALUE
    0x80800F06
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA13SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA13SCG"
    VALUE
    0x80800F07
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA14OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA14OR"
    VALUE
    0x80800F08
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA14SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA14SCB"
    VALUE
    0x80800F09
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA14SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA14SCG"
    VALUE
    0x80800F0A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA21OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA21OR"
    VALUE
    0x80800F0B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA21SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA21SCB"
    VALUE
    0x80800F0C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA21SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA21SCG"
    VALUE
    0x80800F0D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA22OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA22OR"
    VALUE
    0x80800F0E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA22SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA22SCB"
    VALUE
    0x80800F0F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA22SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA22SCG"
    VALUE
    0x80800F10
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA23OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA23OR"
    VALUE
    0x80800F11
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA23SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA23SCB"
    VALUE
    0x80800F12
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA23SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA23SCG"
    VALUE
    0x80800F13
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA24OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA24OR"
    VALUE
    0x80800F14
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA24SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA24SCB"
    VALUE
    0x80800F15
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA24SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA24SCG"
    VALUE
    0x80800F16
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA25OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA25OR"
    VALUE
    0x80800F17
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA25SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA25SCB"
    VALUE
    0x80800F18
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA25SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA25SCG"
    VALUE
    0x80800F19
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA26OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA26OR"
    VALUE
    0x80800F1A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA26SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA26SCB"
    VALUE
    0x80800F1B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA26SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA26SCG"
    VALUE
    0x80800F1C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA27OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA27OR"
    VALUE
    0x80800F1D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA27SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA27SCB"
    VALUE
    0x80800F1E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA27SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA27SCG"
    VALUE
    0x80800F1F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA28OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA28OR"
    VALUE
    0x80800F20
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA28SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA28SCB"
    VALUE
    0x80800F21
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA28SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA28SCG"
    VALUE
    0x80800F22
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA29OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA29OR"
    VALUE
    0x80800F23
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA29SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA29SCB"
    VALUE
    0x80800F24
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA29SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA29SCG"
    VALUE
    0x80800F25
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36AicSCB"
    VALUE
    0x80800F26
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36AicSCG"
    VALUE
    0x80800F27
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36OR"
    VALUE
    0x80800F28
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36SCB"
    VALUE
    0x80800F29
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36SCG"
    VALUE
    0x80800F2A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA36ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA36ShuntSCB"
    VALUE
    0x80800F2B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37AicSCB"
    VALUE
    0x80800F2C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37AicSCG"
    VALUE
    0x80800F2D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37OR"
    VALUE
    0x80800F2E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37SCB"
    VALUE
    0x80800F2F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37SCG"
    VALUE
    0x80800F30
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA37ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA37ShuntSCB"
    VALUE
    0x80800F31
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38AicSCB"
    VALUE
    0x80800F32
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38AicSCG"
    VALUE
    0x80800F33
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38OR"
    VALUE
    0x80800F34
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38SCB"
    VALUE
    0x80800F35
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38SCG"
    VALUE
    0x80800F36
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA38ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA38ShuntSCB"
    VALUE
    0x80800F37
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39AicSCB"
    VALUE
    0x80800F38
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39AicSCG"
    VALUE
    0x80800F39
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39OR"
    VALUE
    0x80800F3A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39SCB"
    VALUE
    0x80800F3B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39SCG"
    VALUE
    0x80800F3C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA39ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA39ShuntSCB"
    VALUE
    0x80800F3D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA40OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA40OR"
    VALUE
    0x80800F3E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA40SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA40SCB"
    VALUE
    0x80800F3F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA40SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA40SCG"
    VALUE
    0x80800F40
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA41OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA41OR"
    VALUE
    0x80800F41
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA41SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA41SCB"
    VALUE
    0x80800F42
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA41SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA41SCG"
    VALUE
    0x80800F43
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA42OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA42OR"
    VALUE
    0x80800F44
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA42SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA42SCB"
    VALUE
    0x80800F45
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA42SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA42SCG"
    VALUE
    0x80800F46
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43AicSCB"
    VALUE
    0x80800F47
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43AicSCG"
    VALUE
    0x80800F48
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43OR"
    VALUE
    0x80800F49
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43SCB"
    VALUE
    0x80800F4A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43SCG"
    VALUE
    0x80800F4B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA43ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA43ShuntSCB"
    VALUE
    0x80800F4C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA44OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA44OL"
    VALUE
    0x80800F4D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA44SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA44SCB"
    VALUE
    0x80800F4E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA44SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA44SCG"
    VALUE
    0x80800F4F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA57OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA57OR"
    VALUE
    0x80800F50
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA57SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA57SCB"
    VALUE
    0x80800F51
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA57SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA57SCG"
    VALUE
    0x80800F52
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA59OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA59OL"
    VALUE
    0x80800F53
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA59SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA59SCB"
    VALUE
    0x80800F54
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inA59SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inA59SCG"
    VALUE
    0x80800F55
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK10OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK10OR"
    VALUE
    0x80800F56
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK10SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK10SCB"
    VALUE
    0x80800F57
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK10SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK10SCG"
    VALUE
    0x80800F58
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK11OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK11OR"
    VALUE
    0x80800F59
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK11SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK11SCB"
    VALUE
    0x80800F5A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK11SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK11SCG"
    VALUE
    0x80800F5B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30AicSCB"
    VALUE
    0x80800F5C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30AicSCG"
    VALUE
    0x80800F5D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30OR"
    VALUE
    0x80800F5E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30SCB"
    VALUE
    0x80800F5F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30SCG"
    VALUE
    0x80800F60
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK30ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK30ShuntSCB"
    VALUE
    0x80800F61
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK31OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK31OR"
    VALUE
    0x80800F62
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK31SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK31SCB"
    VALUE
    0x80800F63
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK31SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK31SCG"
    VALUE
    0x80800F64
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK32OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK32OR"
    VALUE
    0x80800F65
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK32SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK32SCB"
    VALUE
    0x80800F66
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK32SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK32SCG"
    VALUE
    0x80800F67
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK33OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK33OR"
    VALUE
    0x80800F68
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK33SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK33SCB"
    VALUE
    0x80800F69
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK33SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK33SCG"
    VALUE
    0x80800F6A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK34OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK34OR"
    VALUE
    0x80800F6B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK34SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK34SCB"
    VALUE
    0x80800F6C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK34SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK34SCG"
    VALUE
    0x80800F6D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK35OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK35OR"
    VALUE
    0x80800F6E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK35SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK35SCB"
    VALUE
    0x80800F6F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK35SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK35SCG"
    VALUE
    0x80800F70
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK36OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK36OR"
    VALUE
    0x80800F71
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK36SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK36SCB"
    VALUE
    0x80800F72
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK36SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK36SCG"
    VALUE
    0x80800F73
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37AicSCB"
    VALUE
    0x80800F74
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37AicSCG"
    VALUE
    0x80800F75
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37OR"
    VALUE
    0x80800F76
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37SCB"
    VALUE
    0x80800F77
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37SCG"
    VALUE
    0x80800F78
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK37ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK37ShuntSCB"
    VALUE
    0x80800F79
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38AicSCB"
    VALUE
    0x80800F7A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38AicSCG"
    VALUE
    0x80800F7B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38OR"
    VALUE
    0x80800F7C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38SCB"
    VALUE
    0x80800F7D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38SCG"
    VALUE
    0x80800F7E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK38ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK38ShuntSCB"
    VALUE
    0x80800F7F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39AicSCB"
    VALUE
    0x80800F80
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39AicSCG"
    VALUE
    0x80800F81
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39OR"
    VALUE
    0x80800F82
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39SCB"
    VALUE
    0x80800F83
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39SCG"
    VALUE
    0x80800F84
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK39ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK39ShuntSCB"
    VALUE
    0x80800F85
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40AicSCB"
    VALUE
    0x80800F86
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40AicSCG"
    VALUE
    0x80800F87
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40OR"
    VALUE
    0x80800F88
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40SCB"
    VALUE
    0x80800F89
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40SCG"
    VALUE
    0x80800F8A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK40ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK40ShuntSCB"
    VALUE
    0x80800F8B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41AicSCB"
    VALUE
    0x80800F8C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41AicSCG"
    VALUE
    0x80800F8D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41OR"
    VALUE
    0x80800F8E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41SCB"
    VALUE
    0x80800F8F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41SCG"
    VALUE
    0x80800F90
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK41ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK41ShuntSCB"
    VALUE
    0x80800F91
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42AicSCB"
    VALUE
    0x80800F92
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42AicSCG"
    VALUE
    0x80800F93
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42OR"
    VALUE
    0x80800F94
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42SCB"
    VALUE
    0x80800F95
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42SCG"
    VALUE
    0x80800F96
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK42ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK42ShuntSCB"
    VALUE
    0x80800F97
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK43OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK43OR"
    VALUE
    0x80800F98
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK43SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK43SCB"
    VALUE
    0x80800F99
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK43SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK43SCG"
    VALUE
    0x80800F9A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44AicSCB"
    VALUE
    0x80800F9B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44AicSCG"
    VALUE
    0x80800F9C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44OR"
    VALUE
    0x80800F9D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44SCB"
    VALUE
    0x80800F9E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44SCG"
    VALUE
    0x80800F9F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK44ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK44ShuntSCB"
    VALUE
    0x80800FA0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45AicSCB"
    VALUE
    0x80800FA1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45AicSCG"
    VALUE
    0x80800FA2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45OR"
    VALUE
    0x80800FA3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45SCB"
    VALUE
    0x80800FA4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45SCG"
    VALUE
    0x80800FA5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK45ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK45ShuntSCB"
    VALUE
    0x80800FA6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK52OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK52OR"
    VALUE
    0x80800FA7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK52SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK52SCB"
    VALUE
    0x80800FA8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK52SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK52SCG"
    VALUE
    0x80800FA9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK53OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK53OR"
    VALUE
    0x80800FAA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK53SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK53SCB"
    VALUE
    0x80800FAB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK53SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK53SCG"
    VALUE
    0x80800FAC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54AicSCB"
    VALUE
    0x80800FAD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54AicSCG"
    VALUE
    0x80800FAE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54OR"
    VALUE
    0x80800FAF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54SCB"
    VALUE
    0x80800FB0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54SCG"
    VALUE
    0x80800FB1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK54ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK54ShuntSCB"
    VALUE
    0x80800FB2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55AicSCB"
    VALUE
    0x80800FB3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55AicSCG"
    VALUE
    0x80800FB4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55OR"
    VALUE
    0x80800FB5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55SCB"
    VALUE
    0x80800FB6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55SCG"
    VALUE
    0x80800FB7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK55ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK55ShuntSCB"
    VALUE
    0x80800FB8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK56OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK56OR"
    VALUE
    0x80800FB9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK56SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK56SCB"
    VALUE
    0x80800FBA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK56SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK56SCG"
    VALUE
    0x80800FBB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK57OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK57OR"
    VALUE
    0x80800FBC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK57SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK57SCB"
    VALUE
    0x80800FBD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK57SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK57SCG"
    VALUE
    0x80800FBE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK58OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK58OR"
    VALUE
    0x80800FBF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK58SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK58SCB"
    VALUE
    0x80800FC0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK58SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK58SCG"
    VALUE
    0x80800FC1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK59OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK59OR"
    VALUE
    0x80800FC2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK59SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK59SCB"
    VALUE
    0x80800FC3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK59SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK59SCG"
    VALUE
    0x80800FC4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK60OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK60OR"
    VALUE
    0x80800FC5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK60SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK60SCB"
    VALUE
    0x80800FC6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK60SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK60SCG"
    VALUE
    0x80800FC7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61AicSCB"
    VALUE
    0x80800FC8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61AicSCG"
    VALUE
    0x80800FC9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61OR"
    VALUE
    0x80800FCA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61SCB"
    VALUE
    0x80800FCB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61SCG"
    VALUE
    0x80800FCC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK61ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK61ShuntSCB"
    VALUE
    0x80800FCD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK62OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK62OR"
    VALUE
    0x80800FCE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK62SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK62SCB"
    VALUE
    0x80800FCF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK62SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK62SCG"
    VALUE
    0x80800FD0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63AicSCB"
    VALUE
    0x80800FD1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63AicSCG"
    VALUE
    0x80800FD2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63OR"
    VALUE
    0x80800FD3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63SCB"
    VALUE
    0x80800FD4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63SCG"
    VALUE
    0x80800FD5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK63ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK63ShuntSCB"
    VALUE
    0x80800FD6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64AicSCB"
    VALUE
    0x80800FD7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64AicSCG"
    VALUE
    0x80800FD8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64OR"
    VALUE
    0x80800FD9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64SCB"
    VALUE
    0x80800FDA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64SCG"
    VALUE
    0x80800FDB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK64ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK64ShuntSCB"
    VALUE
    0x80800FDC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65AicSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65AicSCB"
    VALUE
    0x80800FDD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65AicSCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65AicSCG"
    VALUE
    0x80800FDE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65OR"
    VALUE
    0x80800FDF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65SCB"
    VALUE
    0x80800FE0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65SCG"
    VALUE
    0x80800FE1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK65ShuntSCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK65ShuntSCB"
    VALUE
    0x80800FE2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK74OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK74OR"
    VALUE
    0x80800FE3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK74SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK74SCB"
    VALUE
    0x80800FE4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK74SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK74SCG"
    VALUE
    0x80800FE5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK75OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK75OR"
    VALUE
    0x80800FE6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK75SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK75SCB"
    VALUE
    0x80800FE7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK75SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK75SCG"
    VALUE
    0x80800FE8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK76OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK76OR"
    VALUE
    0x80800FE9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK76SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK76SCB"
    VALUE
    0x80800FEA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK76SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK76SCG"
    VALUE
    0x80800FEB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK77OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK77OR"
    VALUE
    0x80800FEC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK77SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK77SCB"
    VALUE
    0x80800FED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK77SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK77SCG"
    VALUE
    0x80800FEE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK78OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK78OR"
    VALUE
    0x80800FEF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK78SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK78SCB"
    VALUE
    0x80800FF0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inK78SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inK78SCG"
    VALUE
    0x80800FF1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_DvUBAT_FWs_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_DvUBAT_FWs"
    VALUE
    0x80800FF2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OVErr_VPR6_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OVErr_VPR6"
    VALUE
    0x80800FF3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OVWarn_VPR6_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OVWarn_VPR6"
    VALUE
    0x80800FF4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80800FF5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80800FF6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_UBAT_MON_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_UBAT_MON"
    VALUE
    0x80800FF7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_UBRM24_FLEXIN_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_UBRM24_FLEXIN"
    VALUE
    0x80800FF8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_UBRM24_LOADS_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_UBRM24_LOADS"
    VALUE
    0x80800FF9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_UBRM24_MON_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_UBRM24_MON"
    VALUE
    0x80800FFA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VDD5_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VDD5"
    VALUE
    0x80800FFB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VDD5_IN_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VDD5_IN"
    VALUE
    0x80800FFC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VPR6_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VPR6"
    VALUE
    0x80800FFD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VSS3_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VSS3"
    VALUE
    0x80800FFE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_OV_VSS4_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_OV_VSS4"
    VALUE
    0x80800FFF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_Temp1_HTErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_Temp1_HTErr"
    VALUE
    0x80801000
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_Temp1_HTWarn_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_Temp1_HTWarn"
    VALUE
    0x80801001
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_Temp2_HTErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_Temp2_HTErr"
    VALUE
    0x80801002
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_Temp2_HTWarn_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_Temp2_HTWarn"
    VALUE
    0x80801003
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x80801004
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_2"
    VALUE
    0x80801005
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VDD5_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VDD5"
    VALUE
    0x80801006
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VDD5_IN_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VDD5_IN"
    VALUE
    0x80801007
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VPR6_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VPR6"
    VALUE
    0x80801008
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VSS3_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VSS3"
    VALUE
    0x80801009
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_mo_UV_VSS4_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_mo_UV_VSS4"
    VALUE
    0x8080100A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA01OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA01OL"
    VALUE
    0x8080100B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA01OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA01OT"
    VALUE
    0x8080100C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA01SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA01SCB"
    VALUE
    0x8080100D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA01SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA01SCG"
    VALUE
    0x8080100E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02OL"
    VALUE
    0x8080100F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02OR"
    VALUE
    0x80801010
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02OT"
    VALUE
    0x80801011
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02SCB"
    VALUE
    0x80801012
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA02SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA02SCG"
    VALUE
    0x80801013
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03OL"
    VALUE
    0x80801014
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03OT"
    VALUE
    0x80801015
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03SCB"
    VALUE
    0x80801016
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA03SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA03SCG"
    VALUE
    0x80801017
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04OL"
    VALUE
    0x80801018
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04OT"
    VALUE
    0x80801019
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04SCB"
    VALUE
    0x8080101A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA04SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA04SCG"
    VALUE
    0x8080101B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05OL"
    VALUE
    0x8080101C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05OR"
    VALUE
    0x8080101D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05OT"
    VALUE
    0x8080101E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05SCB"
    VALUE
    0x8080101F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA05SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA05SCG"
    VALUE
    0x80801020
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA06OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA06OL"
    VALUE
    0x80801021
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA06OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA06OR"
    VALUE
    0x80801022
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA06OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA06OT"
    VALUE
    0x80801023
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA06SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA06SCB"
    VALUE
    0x80801024
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA06SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA06SCG"
    VALUE
    0x80801025
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07OL"
    VALUE
    0x80801026
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07OT"
    VALUE
    0x80801027
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07SCB"
    VALUE
    0x80801028
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA07SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA07SCG"
    VALUE
    0x80801029
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08OL"
    VALUE
    0x8080102A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08OT"
    VALUE
    0x8080102B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08SCB"
    VALUE
    0x8080102C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA08SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA08SCG"
    VALUE
    0x8080102D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09OL"
    VALUE
    0x8080102E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09OR"
    VALUE
    0x8080102F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09OT"
    VALUE
    0x80801030
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09SCB"
    VALUE
    0x80801031
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA09SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA09SCG"
    VALUE
    0x80801032
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10OL"
    VALUE
    0x80801033
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10OT"
    VALUE
    0x80801034
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10SCB"
    VALUE
    0x80801035
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA10SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA10SCG"
    VALUE
    0x80801036
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA11OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA11OL"
    VALUE
    0x80801037
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA11OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA11OT"
    VALUE
    0x80801038
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA11SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA11SCB"
    VALUE
    0x80801039
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA11SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA11SCG"
    VALUE
    0x8080103A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA12OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA12OR"
    VALUE
    0x8080103B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA12SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA12SCB"
    VALUE
    0x8080103C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA12SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA12SCG"
    VALUE
    0x8080103D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA16OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA16OL"
    VALUE
    0x8080103E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA16OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA16OT"
    VALUE
    0x8080103F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA16SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA16SCB"
    VALUE
    0x80801040
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA16SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA16SCG"
    VALUE
    0x80801041
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17OL"
    VALUE
    0x80801042
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17OR"
    VALUE
    0x80801043
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17OT"
    VALUE
    0x80801044
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17SCB"
    VALUE
    0x80801045
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA17SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA17SCG"
    VALUE
    0x80801046
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18OL"
    VALUE
    0x80801047
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18OT"
    VALUE
    0x80801048
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18SCB"
    VALUE
    0x80801049
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA18SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA18SCG"
    VALUE
    0x8080104A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19OL"
    VALUE
    0x8080104B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19OR"
    VALUE
    0x8080104C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19OT"
    VALUE
    0x8080104D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19SCB"
    VALUE
    0x8080104E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA19SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA19SCG"
    VALUE
    0x8080104F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20OL"
    VALUE
    0x80801050
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20OR"
    VALUE
    0x80801051
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20OT"
    VALUE
    0x80801052
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20SCB"
    VALUE
    0x80801053
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA20SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA20SCG"
    VALUE
    0x80801054
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31OL"
    VALUE
    0x80801055
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31OR"
    VALUE
    0x80801056
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31OT"
    VALUE
    0x80801057
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31SCB"
    VALUE
    0x80801058
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA31SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA31SCG"
    VALUE
    0x80801059
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32OL"
    VALUE
    0x8080105A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32OR"
    VALUE
    0x8080105B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32OT"
    VALUE
    0x8080105C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32SCB"
    VALUE
    0x8080105D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA32SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA32SCG"
    VALUE
    0x8080105E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33OL"
    VALUE
    0x8080105F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33OR"
    VALUE
    0x80801060
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33OT"
    VALUE
    0x80801061
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33SCB"
    VALUE
    0x80801062
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA33SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA33SCG"
    VALUE
    0x80801063
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34OL"
    VALUE
    0x80801064
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34OR"
    VALUE
    0x80801065
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34OT"
    VALUE
    0x80801066
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34SCB"
    VALUE
    0x80801067
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA34SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA34SCG"
    VALUE
    0x80801068
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35OL"
    VALUE
    0x80801069
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35OR"
    VALUE
    0x8080106A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35OT"
    VALUE
    0x8080106B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35SCB"
    VALUE
    0x8080106C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA35SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA35SCG"
    VALUE
    0x8080106D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46OL"
    VALUE
    0x8080106E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46OR"
    VALUE
    0x8080106F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46OT"
    VALUE
    0x80801070
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46SCB"
    VALUE
    0x80801071
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA46SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA46SCG"
    VALUE
    0x80801072
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47OL"
    VALUE
    0x80801073
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47OR"
    VALUE
    0x80801074
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47OT"
    VALUE
    0x80801075
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47SCB"
    VALUE
    0x80801076
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA47SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA47SCG"
    VALUE
    0x80801077
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48OL"
    VALUE
    0x80801078
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48OR"
    VALUE
    0x80801079
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48OT"
    VALUE
    0x8080107A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48SCB"
    VALUE
    0x8080107B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA48SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA48SCG"
    VALUE
    0x8080107C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA49OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA49OL"
    VALUE
    0x8080107D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA49OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA49OT"
    VALUE
    0x8080107E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA49SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA49SCB"
    VALUE
    0x8080107F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA49SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA49SCG"
    VALUE
    0x80801080
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA50OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA50OL"
    VALUE
    0x80801081
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA50OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA50OT"
    VALUE
    0x80801082
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA50SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA50SCB"
    VALUE
    0x80801083
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA50SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA50SCG"
    VALUE
    0x80801084
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51OL"
    VALUE
    0x80801085
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51OR"
    VALUE
    0x80801086
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51OT"
    VALUE
    0x80801087
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51SCB"
    VALUE
    0x80801088
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA51SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA51SCG"
    VALUE
    0x80801089
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52OL"
    VALUE
    0x8080108A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52OR"
    VALUE
    0x8080108B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52OT"
    VALUE
    0x8080108C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52SCB"
    VALUE
    0x8080108D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA52SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA52SCG"
    VALUE
    0x8080108E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53OL"
    VALUE
    0x8080108F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53OR"
    VALUE
    0x80801090
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53OT"
    VALUE
    0x80801091
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53SCB"
    VALUE
    0x80801092
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA53SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA53SCG"
    VALUE
    0x80801093
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54OL"
    VALUE
    0x80801094
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54OR"
    VALUE
    0x80801095
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54OT"
    VALUE
    0x80801096
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54SCB"
    VALUE
    0x80801097
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA54SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA54SCG"
    VALUE
    0x80801098
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA55OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA55OL"
    VALUE
    0x80801099
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA55OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA55OT"
    VALUE
    0x8080109A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA55SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA55SCB"
    VALUE
    0x8080109B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA55SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA55SCG"
    VALUE
    0x8080109C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA56OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA56OL"
    VALUE
    0x8080109D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA56OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA56OT"
    VALUE
    0x8080109E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA56SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA56SCB"
    VALUE
    0x8080109F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA56SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA56SCG"
    VALUE
    0x808010A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA58OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA58OL"
    VALUE
    0x808010A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA58OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA58OT"
    VALUE
    0x808010A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA58SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA58SCB"
    VALUE
    0x808010A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outA58SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outA58SCG"
    VALUE
    0x808010A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07OL"
    VALUE
    0x808010A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07OR"
    VALUE
    0x808010A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07OT"
    VALUE
    0x808010A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07SCB"
    VALUE
    0x808010A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK07SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK07SCG"
    VALUE
    0x808010A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08OL"
    VALUE
    0x808010AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08OR"
    VALUE
    0x808010AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08OT"
    VALUE
    0x808010AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08SCB"
    VALUE
    0x808010AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK08SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK08SCG"
    VALUE
    0x808010AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09OL"
    VALUE
    0x808010AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09OR"
    VALUE
    0x808010B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09OT"
    VALUE
    0x808010B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09SCB"
    VALUE
    0x808010B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK09SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK09SCG"
    VALUE
    0x808010B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12OL"
    VALUE
    0x808010B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12OT"
    VALUE
    0x808010B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12SCB"
    VALUE
    0x808010B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK12SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK12SCG"
    VALUE
    0x808010B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13OL"
    VALUE
    0x808010B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13OT"
    VALUE
    0x808010B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13SCB"
    VALUE
    0x808010BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK13SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK13SCG"
    VALUE
    0x808010BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14OL"
    VALUE
    0x808010BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14OR"
    VALUE
    0x808010BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14OT"
    VALUE
    0x808010BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14SCB"
    VALUE
    0x808010BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK14SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK14SCG"
    VALUE
    0x808010C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15OL"
    VALUE
    0x808010C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15OR"
    VALUE
    0x808010C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15OT"
    VALUE
    0x808010C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15SCB"
    VALUE
    0x808010C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK15SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK15SCG"
    VALUE
    0x808010C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16OL"
    VALUE
    0x808010C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16OR"
    VALUE
    0x808010C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16OT"
    VALUE
    0x808010C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16SCB"
    VALUE
    0x808010C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK16SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK16SCG"
    VALUE
    0x808010CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17OL"
    VALUE
    0x808010CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17OR"
    VALUE
    0x808010CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17OT"
    VALUE
    0x808010CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17SCB"
    VALUE
    0x808010CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK17SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK17SCG"
    VALUE
    0x808010CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK25OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK25OR"
    VALUE
    0x808010D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK25SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK25SCB"
    VALUE
    0x808010D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK25SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK25SCG"
    VALUE
    0x808010D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29OL"
    VALUE
    0x808010D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29OR"
    VALUE
    0x808010D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29OT"
    VALUE
    0x808010D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29SCB"
    VALUE
    0x808010D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK29SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK29SCG"
    VALUE
    0x808010D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51OL"
    VALUE
    0x808010D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51OT"
    VALUE
    0x808010D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51SCB"
    VALUE
    0x808010DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK51SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK51SCG"
    VALUE
    0x808010DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK62OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK62OR"
    VALUE
    0x808010DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK62SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK62SCB"
    VALUE
    0x808010DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK62SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK62SCG"
    VALUE
    0x808010DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73OL"
    VALUE
    0x808010DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73OR_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73OR"
    VALUE
    0x808010E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73OT"
    VALUE
    0x808010E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73SCB"
    VALUE
    0x808010E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK73SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK73SCG"
    VALUE
    0x808010E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK80OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK80OL"
    VALUE
    0x808010E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK80OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK80OT"
    VALUE
    0x808010E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK80SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK80SCB"
    VALUE
    0x808010E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK80SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK80SCG"
    VALUE
    0x808010E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK81OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK81OL"
    VALUE
    0x808010E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK81OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK81OT"
    VALUE
    0x808010E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK81SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK81SCB"
    VALUE
    0x808010EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK81SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK81SCG"
    VALUE
    0x808010EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK82OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK82OL"
    VALUE
    0x808010EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK82OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK82OT"
    VALUE
    0x808010ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK82SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK82SCB"
    VALUE
    0x808010EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK82SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK82SCG"
    VALUE
    0x808010EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK83OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK83OL"
    VALUE
    0x808010F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK83OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK83OT"
    VALUE
    0x808010F1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK83SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK83SCB"
    VALUE
    0x808010F2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK83SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK83SCG"
    VALUE
    0x808010F3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK84OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK84OL"
    VALUE
    0x808010F4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK84OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK84OT"
    VALUE
    0x808010F5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK84SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK84SCB"
    VALUE
    0x808010F6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK84SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK84SCG"
    VALUE
    0x808010F7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK85OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK85OL"
    VALUE
    0x808010F8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK85OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK85OT"
    VALUE
    0x808010F9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK85SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK85SCB"
    VALUE
    0x808010FA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK85SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK85SCG"
    VALUE
    0x808010FB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK86OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK86OL"
    VALUE
    0x808010FC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK86OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK86OT"
    VALUE
    0x808010FD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK86SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK86SCB"
    VALUE
    0x808010FE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK86SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK86SCG"
    VALUE
    0x808010FF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK87OL_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK87OL"
    VALUE
    0x80801100
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK87OT_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK87OT"
    VALUE
    0x80801101
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK87SCB_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK87SCB"
    VALUE
    0x80801102
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_outK87SCG_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_outK87SCG"
    VALUE
    0x80801103
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_DSMDummy_C
    "Behaviour control mask / Behaviour control masks of check DFC_DSMDummy"
    VALUE
    0x80801104
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8000_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8000"
    VALUE
    0x80801105
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8001_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8001"
    VALUE
    0x80801106
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8002_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8002"
    VALUE
    0x80801107
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8003_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8003"
    VALUE
    0x80801108
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8004_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8004"
    VALUE
    0x80801109
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8005_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8005"
    VALUE
    0x8080110A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8006_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8006"
    VALUE
    0x8080110B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8007_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8007"
    VALUE
    0x8080110C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8008_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8008"
    VALUE
    0x8080110D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8009_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8009"
    VALUE
    0x8080110E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x800a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x800a"
    VALUE
    0x8080110F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x800b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x800b"
    VALUE
    0x80801110
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x800c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x800c"
    VALUE
    0x80801111
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x800d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x800d"
    VALUE
    0x80801112
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x800e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x800e"
    VALUE
    0x80801113
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x800f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x800f"
    VALUE
    0x80801114
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8010_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8010"
    VALUE
    0x80801115
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8011_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8011"
    VALUE
    0x80801116
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8012_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8012"
    VALUE
    0x80801117
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8013_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8013"
    VALUE
    0x80801118
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8014_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8014"
    VALUE
    0x80801119
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8015_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8015"
    VALUE
    0x8080111A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8016_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8016"
    VALUE
    0x8080111B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8017_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8017"
    VALUE
    0x8080111C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8018_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8018"
    VALUE
    0x8080111D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8019_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8019"
    VALUE
    0x8080111E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x801a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x801a"
    VALUE
    0x8080111F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x801b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x801b"
    VALUE
    0x80801120
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x801c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x801c"
    VALUE
    0x80801121
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x801d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x801d"
    VALUE
    0x80801122
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x801e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x801e"
    VALUE
    0x80801123
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x801f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x801f"
    VALUE
    0x80801124
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8020_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8020"
    VALUE
    0x80801125
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8021_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8021"
    VALUE
    0x80801126
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8022_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8022"
    VALUE
    0x80801127
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8023_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8023"
    VALUE
    0x80801128
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8024_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8024"
    VALUE
    0x80801129
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8025_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8025"
    VALUE
    0x8080112A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8026_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8026"
    VALUE
    0x8080112B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8027_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8027"
    VALUE
    0x8080112C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8028_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8028"
    VALUE
    0x8080112D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8029_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8029"
    VALUE
    0x8080112E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x802a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x802a"
    VALUE
    0x8080112F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x802b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x802b"
    VALUE
    0x80801130
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x802c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x802c"
    VALUE
    0x80801131
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x802d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x802d"
    VALUE
    0x80801132
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x802e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x802e"
    VALUE
    0x80801133
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x802f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x802f"
    VALUE
    0x80801134
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8030_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8030"
    VALUE
    0x80801135
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8031_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8031"
    VALUE
    0x80801136
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8032_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8032"
    VALUE
    0x80801137
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8033_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8033"
    VALUE
    0x80801138
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8034_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8034"
    VALUE
    0x80801139
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8035_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8035"
    VALUE
    0x8080113A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8036_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8036"
    VALUE
    0x8080113B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8037_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8037"
    VALUE
    0x8080113C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8038_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8038"
    VALUE
    0x8080113D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8039_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8039"
    VALUE
    0x8080113E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x803a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x803a"
    VALUE
    0x8080113F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x803b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x803b"
    VALUE
    0x80801140
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x803c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x803c"
    VALUE
    0x80801141
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x803d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x803d"
    VALUE
    0x80801142
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x803e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x803e"
    VALUE
    0x80801143
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x803f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x803f"
    VALUE
    0x80801144
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8040_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8040"
    VALUE
    0x80801145
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8041_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8041"
    VALUE
    0x80801146
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8042_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8042"
    VALUE
    0x80801147
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8043_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8043"
    VALUE
    0x80801148
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8044_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8044"
    VALUE
    0x80801149
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8045_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8045"
    VALUE
    0x8080114A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8046_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8046"
    VALUE
    0x8080114B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8047_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8047"
    VALUE
    0x8080114C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8048_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8048"
    VALUE
    0x8080114D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8049_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8049"
    VALUE
    0x8080114E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x804a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x804a"
    VALUE
    0x8080114F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x804b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x804b"
    VALUE
    0x80801150
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x804c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x804c"
    VALUE
    0x80801151
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x804d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x804d"
    VALUE
    0x80801152
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x804e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x804e"
    VALUE
    0x80801153
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x804f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x804f"
    VALUE
    0x80801154
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8050_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8050"
    VALUE
    0x80801155
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8051_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8051"
    VALUE
    0x80801156
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8052_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8052"
    VALUE
    0x80801157
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8053_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8053"
    VALUE
    0x80801158
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8054_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8054"
    VALUE
    0x80801159
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8055_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8055"
    VALUE
    0x8080115A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8056_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8056"
    VALUE
    0x8080115B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8057_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8057"
    VALUE
    0x8080115C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8058_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8058"
    VALUE
    0x8080115D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8059_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8059"
    VALUE
    0x8080115E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x805a_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x805a"
    VALUE
    0x8080115F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x805b_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x805b"
    VALUE
    0x80801160
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x805c_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x805c"
    VALUE
    0x80801161
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x805d_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x805d"
    VALUE
    0x80801162
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x805e_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x805e"
    VALUE
    0x80801163
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x805f_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x805f"
    VALUE
    0x80801164
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8060_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8060"
    VALUE
    0x80801165
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8061_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8061"
    VALUE
    0x80801166
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8062_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8062"
    VALUE
    0x80801167
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8C01_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8C01"
    VALUE
    0x80801168
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8C02_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8C02"
    VALUE
    0x80801169
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_bds_NoDeb0x8C03_C
    "Behaviour control mask / Behaviour control masks of check DFC_bds_NoDeb0x8C03"
    VALUE
    0x8080116A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetDataNoBuf_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetDataNoBuf"
    VALUE
    0x8080116B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetDataParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetDataParam"
    VALUE
    0x8080116C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetDataboxNoInit_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetDataboxNoInit"
    VALUE
    0x8080116D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetDataboxParam"
    VALUE
    0x8080116E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetRxBufStatusParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetRxBufStatusParam"
    VALUE
    0x8080116F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetStatusParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetStatusParam"
    VALUE
    0x80801170
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canGetTxBufStatusParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canGetTxBufStatusParam"
    VALUE
    0x80801171
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canInitParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canInitParam"
    VALUE
    0x80801172
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canInitRxDataboxOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canInitRxDataboxOverlap"
    VALUE
    0x80801173
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canInitRxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canInitRxDataboxParam"
    VALUE
    0x80801174
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canInitTxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canInitTxDataboxParam"
    VALUE
    0x80801175
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canIpduGroupControl_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canIpduGroupControl"
    VALUE
    0x80801176
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canIsDataboxFreeNoInit_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canIsDataboxFreeNoInit"
    VALUE
    0x80801177
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canIsDataboxFreeParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canIsDataboxFreeParam"
    VALUE
    0x80801178
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canIsTxEmptyParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canIsTxEmptyParam"
    VALUE
    0x80801179
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegBusOffCallbInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegBusOffCallbInvState"
    VALUE
    0x8080117A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegBusOffCallbParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegBusOffCallbParam"
    VALUE
    0x8080117B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxBufInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxBufInvState"
    VALUE
    0x8080117C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxBufOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxBufOverlap"
    VALUE
    0x8080117D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxBufParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxBufParam"
    VALUE
    0x8080117E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxCallbInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxCallbInvState"
    VALUE
    0x8080117F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxCallbParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxCallbParam"
    VALUE
    0x80801180
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxDataboxInvNumb_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxDataboxInvNumb"
    VALUE
    0x80801181
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxDataboxInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxDataboxInvState"
    VALUE
    0x80801182
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxDataboxOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxDataboxOverlap"
    VALUE
    0x80801183
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegRxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegRxDataboxParam"
    VALUE
    0x80801184
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxBufInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxBufInvState"
    VALUE
    0x80801185
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxBufOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxBufOverlap"
    VALUE
    0x80801186
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxBufParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxBufParam"
    VALUE
    0x80801187
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxDataboxInvNumb_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxDataboxInvNumb"
    VALUE
    0x80801188
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxDataboxInvState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxDataboxInvState"
    VALUE
    0x80801189
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxDataboxOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxDataboxOverlap"
    VALUE
    0x8080118A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canRegTxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canRegTxDataboxParam"
    VALUE
    0x8080118B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canResetTxBufParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canResetTxBufParam"
    VALUE
    0x8080118C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canSendDataBufOvfl_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canSendDataBufOvfl"
    VALUE
    0x8080118D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canSendDataParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canSendDataParam"
    VALUE
    0x8080118E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canSendDataboxNoInit_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canSendDataboxNoInit"
    VALUE
    0x8080118F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canSendDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canSendDataboxParam"
    VALUE
    0x80801190
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canSetTxCycleParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canSetTxCycleParam"
    VALUE
    0x80801191
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canStartParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canStartParam"
    VALUE
    0x80801192
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_canStopParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_canStopParam"
    VALUE
    0x80801193
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_can_ClearIpduGroup_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_can_ClearIpduGroup"
    VALUE
    0x80801194
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_can_ReceiveSignal_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_can_ReceiveSignal"
    VALUE
    0x80801195
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_can_SendSignal_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_can_SendSignal"
    VALUE
    0x80801196
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_can_SetIpduGroup_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_can_SetIpduGroup"
    VALUE
    0x80801197
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmDTCJ1939_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmDTCJ1939"
    VALUE
    0x80801198
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmDelDTCJ1939_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmDelDTCJ1939"
    VALUE
    0x80801199
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmDelErrors_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmDelErrors"
    VALUE
    0x8080119A
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmGetDFES_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmGetDFES"
    VALUE
    0x8080119B
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmGetDTCJ1939_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmGetDTCJ1939"
    VALUE
    0x8080119C
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmGetErrors_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmGetErrors"
    VALUE
    0x8080119D
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmGetNumErrors_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmGetNumErrors"
    VALUE
    0x8080119E
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmInitQueueOverflow_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmInitQueueOverflow"
    VALUE
    0x8080119F
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmNumDTCJ1939_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmNumDTCJ1939"
    VALUE
    0x808011A0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmTesterror_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmTesterror"
    VALUE
    0x808011A1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmUpdateDebError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmUpdateDebError"
    VALUE
    0x808011A2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmUpdateError_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmUpdateError"
    VALUE
    0x808011A3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmgetDFCStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmgetDFCStatus"
    VALUE
    0x808011A4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_dsmtestErrorDFC_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_dsmtestErrorDFC"
    VALUE
    0x808011A5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAi_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAi"
    VALUE
    0x808011A6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAic_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAic"
    VALUE
    0x808011A7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAicCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAicCfg"
    VALUE
    0x808011A8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAicGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAicGetStatus"
    VALUE
    0x808011A9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAid_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAid"
    VALUE
    0x808011AA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAidCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAidCfg"
    VALUE
    0x808011AB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAiv_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAiv"
    VALUE
    0x808011AC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAivCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAivCfg"
    VALUE
    0x808011AD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inAivGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inAivGetStatus"
    VALUE
    0x808011AE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inDi_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inDi"
    VALUE
    0x808011AF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inFi_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inFi"
    VALUE
    0x808011B0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inFiCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inFiCfg"
    VALUE
    0x808011B1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inFiGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inFiGetStatus"
    VALUE
    0x808011B2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inFi_Buffered_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inFi_Buffered"
    VALUE
    0x808011B3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inPhase_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inPhase"
    VALUE
    0x808011B4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inPhaseGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inPhaseGetStatus"
    VALUE
    0x808011B5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inPhaseResetCounter_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inPhaseResetCounter"
    VALUE
    0x808011B6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inRi_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inRi"
    VALUE
    0x808011B7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inRiCfg_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inRiCfg"
    VALUE
    0x808011B8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inRiCfgTemp_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inRiCfgTemp"
    VALUE
    0x808011B9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inRiGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inRiGetStatus"
    VALUE
    0x808011BA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inRiGetTemp_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inRiGetTemp"
    VALUE
    0x808011BB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentCopyFDFifo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentCopyFDFifo"
    VALUE
    0x808011BC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentDisable_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentDisable"
    VALUE
    0x808011BD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentEnable_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentEnable"
    VALUE
    0x808011BE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentGetErrorStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentGetErrorStatus"
    VALUE
    0x808011BF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentGetFD_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentGetFD"
    VALUE
    0x808011C0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentGetSD_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentGetSD"
    VALUE
    0x808011C1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentGetSDDatabox_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentGetSDDatabox"
    VALUE
    0x808011C2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentGetStatus"
    VALUE
    0x808011C3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentInitSDDatabox_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentInitSDDatabox"
    VALUE
    0x808011C4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentRegisterCopyFDFifo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentRegisterCopyFDFifo"
    VALUE
    0x808011C5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentRegisterFDFifo_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentRegisterFDFifo"
    VALUE
    0x808011C6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_inSentRegisterSDDataboxes_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_inSentRegisterSDDataboxes"
    VALUE
    0x808011C7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusCanRxBufferOverflow_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusCanRxBufferOverflow"
    VALUE
    0x808011C8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusGetCaAddrParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusGetCaAddrParam"
    VALUE
    0x808011C9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusGetDiagnosticParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusGetDiagnosticParam"
    VALUE
    0x808011CA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusGetRxDataboxStatusParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusGetRxDataboxStatusParam"
    VALUE
    0x808011CB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusGetStatusParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusGetStatusParam"
    VALUE
    0x808011CC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitCommCaMissing_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitCommCaMissing"
    VALUE
    0x808011CD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitCommParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitCommParam"
    VALUE
    0x808011CE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitCommState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitCommState"
    VALUE
    0x808011CF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitDiagnosticParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitDiagnosticParam"
    VALUE
    0x808011D0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitFailureListParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitFailureListParam"
    VALUE
    0x808011D1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitRxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitRxDataboxParam"
    VALUE
    0x808011D2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusInitTxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusInitTxDataboxParam"
    VALUE
    0x808011D3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegRxDataboxOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegRxDataboxOverlap"
    VALUE
    0x808011D4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegRxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegRxDataboxParam"
    VALUE
    0x808011D5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegRxDataboxState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegRxDataboxState"
    VALUE
    0x808011D6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegTxDataboxOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegTxDataboxOverlap"
    VALUE
    0x808011D7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegTxDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegTxDataboxParam"
    VALUE
    0x808011D8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegTxDataboxState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegTxDataboxState"
    VALUE
    0x808011D9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegisterErrClrCallbackParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegisterErrClrCallbackParam"
    VALUE
    0x808011DA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegisterInstancesOverlap_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegisterInstancesOverlap"
    VALUE
    0x808011DB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegisterInstancesParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegisterInstancesParam"
    VALUE
    0x808011DC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusRegisterInstancesState_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusRegisterInstancesState"
    VALUE
    0x808011DD
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSendDataboxParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSendDataboxParam"
    VALUE
    0x808011DE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSendRequestPGNParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSendRequestPGNParam"
    VALUE
    0x808011DF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaAddrCaUsed_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaAddrCaUsed"
    VALUE
    0x808011E0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaAddrComm_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaAddrComm"
    VALUE
    0x808011E1
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaAddrInvCan_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaAddrInvCan"
    VALUE
    0x808011E2
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaAddrParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaAddrParam"
    VALUE
    0x808011E3
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaInfoParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaInfoParam"
    VALUE
    0x808011E4
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSetCaNameParam_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSetCaNameParam"
    VALUE
    0x808011E5
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_isobusSftyCanTxErr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_isobusSftyCanTxErr"
    VALUE
    0x808011E6
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_ReceiveSignal_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_ReceiveSignal"
    VALUE
    0x808011E7
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_SendSignal_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_SendSignal"
    VALUE
    0x808011E8
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_getStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_getStatus"
    VALUE
    0x808011E9
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_gotoSleep_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_gotoSleep"
    VALUE
    0x808011EA
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_scheduleRequest_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_scheduleRequest"
    VALUE
    0x808011EB
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_lin_wakeUp_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_lin_wakeUp"
    VALUE
    0x808011EC
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memFlsCfgShr_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memFlsCfgShr"
    VALUE
    0x808011ED
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memGetStatus_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memGetStatus"
    VALUE
    0x808011EE
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memMarkBlock_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memMarkBlock"
    VALUE
    0x808011EF
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DFC_CtlMsk2.DFC_rbr_memReadApi1Error_C
    "Behaviour control mask / Behaviour control masks of check DFC_rbr_memReadApi1Error"
    VALUE
    0x808011F0
    Val_Wu8
    255.0
    DFES_OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

