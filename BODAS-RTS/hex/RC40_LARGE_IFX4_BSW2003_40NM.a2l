/*-- Generated by A2L Merger --*/
ASAP2_VERSION  1 70
/* Created by DAMOS++ V5.8.27 WinServer 2016 */

/begin PROJECT RC40_LARGE_IFX4_BSW2003_40NM "RC40_LARGE_IFX4_BSW2003_40NM"
  /begin HEADER ""
    VERSION    "V01_28"
    PROJECT_NO RC40_LARGE_IFX4_BSW2003_40NM
  /end HEADER

  /begin MODULE DIM ""

  /begin A2ML 
/***********************************************************/
/*                                                         */
/* ASAP2 meta language for XCP protocol layer V1.2         */
/*                                                         */
/*                                                         */
/*   Datatypes:                                            */
/*                                                         */
/*   A2ML       description                                */
/*   ----------------------------------------------------- */
/*   uchar      unsigned 8  Bit                            */
/*   char       signed 8 Bit                               */
/*   uint       unsigned integer 16 Bit                    */
/*   int        signed integer 16 Bit                      */
/*   ulong      unsigned integer 32 Bit                    */
/*   long       signed integer 32 Bit                      */
/*   float      float 32 Bit IEEE 754                      */
/*                                                         */
/***********************************************************/

/*************** start of PROTOCOL_LAYER *******************/ 
   
  struct Protocol_Layer {     /* At MODULE */ 
   
    uint;                                /* XCP protocol layer version */ 
                                         /* e.g. "1.2" = 0x0102            */ 
   
    uint;                                /* T1 [ms] */ 
    uint;                                /* T2 [ms] */ 
    uint;                                /* T3 [ms] */ 
    uint;                                /* T4 [ms] */ 
    uint;                                /* T5 [ms] */ 
    uint;                                /* T6 [ms] */ 
    uint;                                /* T7 [ms] */ 
   
    uchar;                               /* MAX_CTO */ 
    uint;                                /* MAX_DTO default for DAQ and STIM */ 
   
    enum {                               /* BYTE_ORDER */ 
      "BYTE_ORDER_MSB_LAST"  = 0, 
      "BYTE_ORDER_MSB_FIRST" = 1 
    }; 
   
    enum {                               /* ADDRESS_GRANULARITY */ 
      "ADDRESS_GRANULARITY_BYTE"    = 1, 
      "ADDRESS_GRANULARITY_WORD"    = 2, 
      "ADDRESS_GRANULARITY_DWORD"   = 4 
    }; 
   
    taggedstruct {                       /* optional                     */ 
       
      ("OPTIONAL_CMD" enum {             /* XCP-Code of optional command */  
                                         /* supported by the slave       */ 
   
        "GET_COMM_MODE_INFO"       = 0xFB, 
        "GET_ID"                   = 0xFA, 
        "SET_REQUEST"              = 0xF9, 
        "GET_SEED"                 = 0xF8, 
        "UNLOCK"                   = 0xF7, 
        "SET_MTA"                  = 0xF6, 
        "UPLOAD"                   = 0xF5, 
        "SHORT_UPLOAD"             = 0xF4, 
        "BUILD_CHECKSUM"           = 0xF3, 
        "TRANSPORT_LAYER_CMD"      = 0xF2, 
        "USER_CMD"                 = 0xF1, 
        "DOWNLOAD"                 = 0xF0, 
        "DOWNLOAD_NEXT"            = 0xEF, 
        "DOWNLOAD_MAX"             = 0xEE, 
        "SHORT_DOWNLOAD"           = 0xED, 
        "MODIFY_BITS"              = 0xEC, 
        "SET_CAL_PAGE"             = 0xEB, 
        "GET_CAL_PAGE"             = 0xEA, 
        "GET_PAG_PROCESSOR_INFO"   = 0xE9, 
        "GET_SEGMENT_INFO"         = 0xE8, 
        "GET_PAGE_INFO"            = 0xE7, 
        "SET_SEGMENT_MODE"         = 0xE6, 
        "GET_SEGMENT_MODE"         = 0xE5, 
        "COPY_CAL_PAGE"            = 0xE4, 
        "CLEAR_DAQ_LIST"           = 0xE3, 
        "SET_DAQ_PTR"              = 0xE2, 
        "WRITE_DAQ"                = 0xE1, 
        "SET_DAQ_LIST_MODE"        = 0xE0, 
        "GET_DAQ_LIST_MODE"        = 0xDF, 
        "START_STOP_DAQ_LIST"      = 0xDE, 
        "START_STOP_SYNCH"         = 0xDD, 
        "GET_DAQ_CLOCK"            = 0xDC, 
        "READ_DAQ"                 = 0xDB, 
        "GET_DAQ_PROCESSOR_INFO"   = 0xDA, 
        "GET_DAQ_RESOLUTION_INFO"  = 0xD9, 
        "GET_DAQ_LIST_INFO"        = 0xD8, 
        "GET_DAQ_EVENT_INFO"       = 0xD7, 
        "FREE_DAQ"                 = 0xD6, 
        "ALLOC_DAQ"                = 0xD5, 
        "ALLOC_ODT"                = 0xD4, 
        "ALLOC_ODT_ENTRY"          = 0xD3, 
        "PROGRAM_START"            = 0xD2, 
        "PROGRAM_CLEAR"            = 0xD1, 
        "PROGRAM"                  = 0xD0, 
        "PROGRAM_RESET"            = 0xCF, 
        "GET_PGM_PROCESSOR_INFO"   = 0xCE, 
        "GET_SECTOR_INFO"          = 0xCD, 
        "PROGRAM_PREPARE"          = 0xCC, 
        "PROGRAM_FORMAT"           = 0xCB, 
        "PROGRAM_NEXT"             = 0xCA, 
        "PROGRAM_MAX"              = 0xC9, 
        "PROGRAM_VERIFY"           = 0xC8,
        "WRITE_DAQ_MULTIPLE"       = 0xC7
      })*;           
                                          
      "COMMUNICATION_MODE_SUPPORTED" taggedunion { /* optional modes supported */ 
         "BLOCK" taggedstruct { 
            "SLAVE";                  /* Slave Block Mode supported  */ 
            "MASTER" struct {         /* Master Block Mode supported */ 
               uchar;  /* MAX_BS */ 
               uchar;  /* MIN_ST */ 
            }; 
         }; 
         "INTERLEAVED" uchar;    /* QUEUE_SIZE */  
      }; 
   
      "SEED_AND_KEY_EXTERNAL_FUNCTION" char[256];  /* Name of the Seed&Key function */ 
                                                   /* including file extension      */ 
                                                   /* without path                  */ 
      "MAX_DTO_STIM" uint;     /* overrules MAX_DTO see above for STIM use case */                                           
    }; 
   
  };

/***************** end of PROTOCOL_LAYER *******************/ 


/*********************** start of DAQ **********************/ 

  struct Daq {                         /* DAQ supported, at MODULE*/ 
    enum {                             /* DAQ_CONFIG_TYPE */ 
      "STATIC"  = 0, 
      "DYNAMIC" = 1 
    }; 
   
    uint;                               /* MAX_DAQ */ 
    uint;                               /* MAX_EVENT_CHANNEL */ 
    uchar;                              /* MIN_DAQ */ 
   
    enum {                            /* OPTIMISATION_TYPE */ 
      "OPTIMISATION_TYPE_DEFAULT"            = 0, 
      "OPTIMISATION_TYPE_ODT_TYPE_16"        = 1, 
      "OPTIMISATION_TYPE_ODT_TYPE_32"        = 2, 
      "OPTIMISATION_TYPE_ODT_TYPE_64"        = 3, 
      "OPTIMISATION_TYPE_ODT_TYPE_ALIGNMENT" = 4, 
      "OPTIMISATION_TYPE_MAX_ENTRY_SIZE"     = 5 
    }; 
   
    enum {                           /* ADDRESS_EXTENSION */ 
      "ADDRESS_EXTENSION_FREE" = 0, 
      "ADDRESS_EXTENSION_ODT"  = 1, 
      "ADDRESS_EXTENSION_DAQ"  = 3 
    }; 
   
   
    enum {                           /* IDENTIFICATION_FIELD */ 
      "IDENTIFICATION_FIELD_TYPE_ABSOLUTE"              = 0, 
      "IDENTIFICATION_FIELD_TYPE_RELATIVE_BYTE"         = 1, 
      "IDENTIFICATION_FIELD_TYPE_RELATIVE_WORD"         = 2, 
      "IDENTIFICATION_FIELD_TYPE_RELATIVE_WORD_ALIGNED" = 3 
    }; 
     
   
    enum {                        /* GRANULARITY_ODT_ENTRY_SIZE_DAQ */ 
      "GRANULARITY_ODT_ENTRY_SIZE_DAQ_BYTE"    = 1, 
      "GRANULARITY_ODT_ENTRY_SIZE_DAQ_WORD"    = 2, 
      "GRANULARITY_ODT_ENTRY_SIZE_DAQ_DWORD"   = 4, 
      "GRANULARITY_ODT_ENTRY_SIZE_DAQ_DLONG"   = 8 
    }; 
   
    uchar;                              /* MAX_ODT_ENTRY_SIZE_DAQ */ 
   
    enum {                              /* OVERLOAD_INDICATION */ 
      "NO_OVERLOAD_INDICATION"    = 0, 
      "OVERLOAD_INDICATION_PID"   = 1, 
      "OVERLOAD_INDICATION_EVENT" = 2 
    }; 
   
    taggedstruct {                      /* optional */ 
      "DAQ_ALTERNATING_SUPPORTED" uint; /* Display_Event_Channel_Number */
      "PRESCALER_SUPPORTED"; 
      "RESUME_SUPPORTED"; 
      "STORE_DAQ_SUPPORTED";
   
      block "STIM" struct {             /* STIM supported */ 
   
        enum {                      /* GRANULARITY_ODT_ENTRY_SIZE_STIM */ 
          "GRANULARITY_ODT_ENTRY_SIZE_STIM_BYTE"   = 1, 
          "GRANULARITY_ODT_ENTRY_SIZE_STIM_WORD"   = 2, 
          "GRANULARITY_ODT_ENTRY_SIZE_STIM_DWORD"  = 4, 
          "GRANULARITY_ODT_ENTRY_SIZE_STIM_DLONG"  = 8 
        }; 
   
        uchar;                          /* MAX_ODT_ENTRY_SIZE_STIM */ 
   
        taggedstruct {                  /* bitwise stimulation */ 
          "BIT_STIM_SUPPORTED"; 
          "MIN_ST_STIM" uchar; /* separation time between DTOs */
          /* time in units of 100 microseconds */
        }; 
      }; 
             
      block "TIMESTAMP_SUPPORTED" struct {  
        uint;                           /* TIMESTAMP_TICKS */ 
        enum { /* TIMESTAMP_SIZE */ 
          "NO_TIME_STAMP" = 0, 
          "SIZE_BYTE"     = 1, 
          "SIZE_WORD"     = 2, 
          "SIZE_DWORD"    = 4 
        }; 
        enum { /* RESOLUTION OF TIMESTAMP */ 
          "UNIT_1NS"   = 0, 
          "UNIT_10NS"  = 1, 
          "UNIT_100NS" = 2, 
          "UNIT_1US"   = 3, 
          "UNIT_10US"  = 4, 
          "UNIT_100US" = 5, 
          "UNIT_1MS"   = 6, 
          "UNIT_10MS"  = 7, 
          "UNIT_100MS" = 8, 
          "UNIT_1S"    = 9, 
          "UNIT_1PS"   = 10,
          "UNIT_10PS"  = 11,
          "UNIT_100PS" = 12
        }; 
        taggedstruct { 
          "TIMESTAMP_FIXED"; 
        }; 
      }; 
   
      "PID_OFF_SUPPORTED";
  
      "MAX_DAQ_TOTAL" uint;
      "MAX_ODT_TOTAL" uint;
      "MAX_ODT_DAQ_TOTAL" uint;
      "MAX_ODT_STIM_TOTAL" uint;
      "MAX_ODT_ENTRIES_TOTAL" uint;
	  "MAX_ODT_ENTRIES_DAQ_TOTAL" uint;
      "MAX_ODT_ENTRIES_STIM_TOTAL" uint;

      
      "CPU_LOAD_MAX_TOTAL" float;
      
      block "DAQ_MEMORY_CONSUMPTION" struct {
        ulong; /* "DAQ_MEMORY_LIMIT"		: in Elements[AG] */
        uint;  /* "DAQ_SIZE" 			: Anzahl Elements[AG] pro DAQ-Liste */
        uint;  /* "ODT_SIZE" 			: Anzahl Elements[AG] pro ODT */
        uint;  /* "ODT_ENTRY_SIZE" 		: Anzahl Elements[AG] pro ODT_Entry */
        uint;  /* "ODT_DAQ_BUFFER_ELEMENT_SIZE" : Anzahl Payload-Elements[AG]*Faktor = sizeof(Sendepuffer)[AG] */
        uint;  /* "ODT_STIM_BUFFER_ELEMENT_SIZE": Anzahl Payload-Elements[AG]*Faktor = sizeof(Empfangspuffer)[AG] */
      };
       
      /************************ start of DAQ_LIST *************************/ 
   
      (block "DAQ_LIST" struct {          /* DAQ_LIST                    */ 
                                          /* multiple possible           */ 
        uint;                             /* DAQ_LIST_NUMBER             */ 
        taggedstruct {                            /* optional */ 
          "DAQ_LIST_TYPE" enum {               
            "DAQ"      = 1,               /* DIRECTION = DAQ only     */ 
            "STIM"     = 2,               /* DIRECTION = STIM only    */ 
            "DAQ_STIM" = 3                /* both directions possible */ 
                                          /* but not simultaneously   */ 
          }; 
   
          "MAX_ODT"         uchar;        /* MAX_ODT         */ 
          "MAX_ODT_ENTRIES" uchar;        /* MAX_ODT_ENTRIES */ 
   
          "FIRST_PID" uchar;              /* FIRST_PID for this DAQ_LIST */ 
          "EVENT_FIXED" uint;             /* this DAQ_LIST always        */ 
                                          /* in this event               */ 
          block "PREDEFINED" taggedstruct { /* predefined                */ 
                                            /* not configurable DAQ_LIST */ 
             (block "ODT" struct { 
                     uchar;                   /* ODT number */ 
                     taggedstruct { 
                         ("ODT_ENTRY" struct { 
                                     uchar;   /* ODT_ENTRY number            */ 
                                     ulong;   /* address of element                 */ 
                                     uchar;   /* address extension of element */ 
                                     uchar;   /* size of element [AG]                */ 
                                     uchar;   /* BIT_OFFSET                          */ 
                           })*; 
                     }; /* end of ODT_ENTRY */ 
              })*; /* end of ODT */ 
           }; /* end of PREDEFINED */ 
        }; 
      
      })*;
      
      /********************* end of DAQ_LIST ***************************/ 
   
      /************************* start of EVENT ************************/ 
     
      (block "EVENT" struct {             /* EVENT               */ 
                                          /* multiple possible   */ 
        char[101];                        /* EVENT_CHANNEL_NAME       */ 
        char[9];                          /* EVENT_CHANNEL_SHORT_NAME */ 
        uint;                             /* EVENT_CHANNEL_NUMBER     */ 
     
        enum { 
          "DAQ"      = 1,                 /* only DAQ_LISTs         */ 
                                          /* with DIRECTION = DAQ   */ 
          "STIM"     = 2,                 /* only DAQ_LISTs         */ 
                                          /* with DIRECTION = STIM  */ 
          "DAQ_STIM" = 3                  /* both kind of DAQ_LISTs */ 
        }; 
     
        uchar;                            /* MAX_DAQ_LIST */ 
        uchar;                            /* EVENT_CHANNEL_TIME_CYCLE */
        uchar;                            /* EVENT_CHANNEL_TIME_UNIT */ 
        uchar;                            /* EVENT_CHANNEL_PRIORITY */ 
          taggedstruct { /* optional */
            
            "COMPLEMENTARY_BYPASS_EVENT_CHANNEL_NUMBER" uint;
            "CONSISTENCY" enum {
  
                 "DAQ" = 0,
                 "EVENT" = 1
            };
           
            block "MIN_CYCLE_TIME" struct { /* Configuration with 0-0 not allowed */
             uchar;                            /* EVENT_CHANNEL_TIME_CYCLE */
             uchar;                            /* EVENT_CHANNEL_TIME_UNIT  */
            };
           
           "CPU_LOAD_MAX" float;
          
           block "CPU_LOAD_CONSUMPTION_DAQ" struct {
            float;  // "DAQ_FACTOR"
            float;  // "ODT_FACTOR"
            float;  // "ODT_ENTRY_FACTOR" 
            taggedstruct { 
              (block "ODT_ENTRY_SIZE_FACTOR_TABLE" struct{// Kopierroutine
                     uint; //"SIZE" 
                     float; // "SIZE_FACTOR" 
               })*;
             };
           };
           
           block "CPU_LOAD_CONSUMPTION_STIM" struct {
            float;  // "DAQ_FACTOR"
            float;  // "ODT_FACTOR"
            float;  // "ODT_ENTRY_FACTOR" 
            taggedstruct { 
              (block "ODT_ENTRY_SIZE_FACTOR_TABLE" struct{// Kopierroutine
                     uint; //"SIZE" 
                     float; //"SIZE_FACTOR" 
               })*;
             };
           };
           
           block "CPU_LOAD_CONSUMPTION_QUEUE" struct {
              float;  // "ODT_FACTOR" 
              float;  // "ODT_ELEMENT_LOAD",length in elements[AG]
           };        
         };
      })*;
      
      /******************** end of EVENT *********************/ 
   
    }; /* end of optional at DAQ */ 
   
  }; 
  
/********************* end of DAQ **************************/  
  

/***************** start of DAQ_EVENT **********************/ 
 
  taggedunion Daq_Event {         /* at MEASUREMENT */ 
     "FIXED_EVENT_LIST" taggedstruct { 
        ("EVENT" uint)* ; 
     }; 
     "VARIABLE" taggedstruct { 
        block "AVAILABLE_EVENT_LIST" taggedstruct { 
           ("EVENT" uint)*; 
        }; 
        block "DEFAULT_EVENT_LIST" taggedstruct { 
           ("EVENT" uint)*; 
        }; 
     }; 
  }; 

/******************** end of DAQ_EVENT *********************/ 
   

/*********************** start of PAG **********************/ 
   
  struct Pag {                  /* PAG supported, at MODULE */ 
    uchar;                      /* MAX_SEGMENTS */ 
    taggedstruct {              /* optional */ 
      "FREEZE_SUPPORTED"; 
    }; 
   
  }; 

/*********************** end of PAG ************************/ 
      

/*********************** start of PGM **********************/ 
   
  struct Pgm {                  /* PGM supported, at MODULE */ 
   
    enum { 
      "PGM_MODE_ABSOLUTE"                = 1, 
      "PGM_MODE_FUNCTIONAL"              = 2, 
      "PGM_MODE_ABSOLUTE_AND_FUNCTIONAL" = 3 
    }; 
    uchar;                               /* MAX_SECTORS */ 
    uchar;                               /* MAX_CTO_PGM */ 
  
    taggedstruct {                       /* optional                */ 
      (block "SECTOR" struct {           /* SECTOR                  */ 
                                         /* multiple possible       */ 
        char[101];                       /* SECTOR_NAME             */ 
        uchar;                           /* SECTOR_NUMBER           */ 
        ulong;                           /* Address                 */ 
        ulong;                           /* Length                  */ 
        uchar;                           /* CLEAR_SEQUENCE_NUMBER   */ 
        uchar;                           /* PROGRAM_SEQUENCE_NUMBER */ 
        uchar;                           /* PROGRAM_METHOD          */ 
      })*; /* end of SECTOR */ 
                                          
      "COMMUNICATION_MODE_SUPPORTED" taggedunion { /* optional modes supported */ 
         "BLOCK" taggedstruct { 
            "SLAVE";                  /* Slave Block Mode supported  */ 
            "MASTER" struct {         /* Master Block Mode supported */ 
               uchar;  /* MAX_BS_PGM */ 
               uchar;  /* MIN_ST_PGM */ 
            }; 
         }; 
       "INTERLEAVED" uchar;    /* QUEUE_SIZE_PGM */  
       }; 
    }; 
  }; 

/*********************** end of PGM ************************/ 

  
/*********************** start of SEGMENT ******************/ 
   
  struct Segment {               /* at MEMORY_SEGMENT */ 
    uchar;                               /* SEGMENT_NUMBER     */ 
    uchar;                               /* number of pages    */ 
    uchar;                               /* ADDRESS_EXTENSION  */ 
    uchar;                               /* COMPRESSION_METHOD */ 
    uchar;                               /* ENCRYPTION_METHOD  */ 
   
    taggedstruct {                       /* optional           */ 
      block "CHECKSUM" struct { 
        enum {                           /* checksum type      */ 
          "XCP_ADD_11"       =   1, 
          "XCP_ADD_12"       =   2, 
          "XCP_ADD_14"       =   3, 
          "XCP_ADD_22"       =   4, 
          "XCP_ADD_24"       =   5, 
          "XCP_ADD_44"       =   6, 
          "XCP_CRC_16"       =   7, 
          "XCP_CRC_16_CITT"  =   8, 
          "XCP_CRC_32"       =   9, 
          "XCP_USER_DEFINED" = 255 
        }; 
   
        taggedstruct { 
          "MAX_BLOCK_SIZE"              ulong ;    /* maximum block size            */ 
                                                   /* for checksum calculation      */ 
          "EXTERNAL_FUNCTION" char[256];           /* Name of the Checksum function */ 
                                                   /* including file extension      */ 
                                                   /* without path                  */ 
        }; 
      }; 
   
      (block "PAGE" struct {               /* PAGES for this SEGMENT */ 
                                           /* multiple possible      */ 
        uchar;                             /* PAGE_NUMBER            */ 
   
        enum {            /* ECU_ACCESS_TYPE */ 
            "ECU_ACCESS_NOT_ALLOWED"      = 0, 
            "ECU_ACCESS_WITHOUT_XCP_ONLY" = 1, 
            "ECU_ACCESS_WITH_XCP_ONLY"    = 2, 
            "ECU_ACCESS_DONT_CARE"        = 3 
         }; 
   
        enum {       /* XCP_READ_ACCESS_TYPE */ 
            "XCP_READ_ACCESS_NOT_ALLOWED"      = 0, 
            "XCP_READ_ACCESS_WITHOUT_ECU_ONLY" = 1, 
            "XCP_READ_ACCESS_WITH_ECU_ONLY"    = 2, 
            "XCP_READ_ACCESS_DONT_CARE"        = 3 
         }; 
   
        enum {      /* XCP_WRITE_ACCESS_TYPE */ 
            "XCP_WRITE_ACCESS_NOT_ALLOWED"      = 0, 
            "XCP_WRITE_ACCESS_WITHOUT_ECU_ONLY" = 1, 
            "XCP_WRITE_ACCESS_WITH_ECU_ONLY"    = 2, 
            "XCP_WRITE_ACCESS_DONT_CARE"        = 3 
        }; 
        taggedstruct { 
          "INIT_SEGMENT" uchar; /* references segment that initialises this page */ 
        }; 
   
      })*; /* end of PAGE */                 
   
      (block "ADDRESS_MAPPING" struct {  /* multiple possible   */ 
                           ulong;        /* source address      */ 
                           ulong;        /* destination address */ 
                           ulong;        /* length              */ 
      })*; 
   
      "PGM_VERIFY" ulong; /* verification value for PGM */ 
    }; /* end of optional */ 
   
  }; 

/************************ end of SEGMENT *******************/ 

  
/*********************** start of Common Parameters ********/ 
 
  taggedstruct Common_Parameters {  
   
    block "PROTOCOL_LAYER" struct Protocol_Layer; 
   
    block "SEGMENT" struct Segment; 
   
    block "DAQ" struct Daq; 
    block "PAG" struct Pag; 
    block "PGM" struct Pgm; 
   
    block "DAQ_EVENT" taggedunion Daq_Event; 
   
  }; 

/********************** end of Common Parameters **********/ 


/***********************************************************/
/*                                                         */
/* ASAP2 meta language for XCP on CAN V1.2                 */
/*                                                         */
/*                                                         */
/*   Datatypes:                                            */
/*                                                         */
/*   A2ML       description                                */
/*   ----------------------------------------------------- */
/*   uchar      unsigned 8  Bit                            */
/*   char       signed 8 Bit                               */
/*   uint       unsigned integer 16 Bit                    */
/*   int        signed integer 16 Bit                      */
/*   ulong      unsigned integer 32 Bit                    */
/*   long       signed integer 32 Bit                      */
/*   float      float 32 Bit IEEE 745                      */
/*                                                         */
/***********************************************************/
/************************ start of CAN *********************/

  struct CAN_Parameters { /* At MODULE */
    uint; /* XCP on CAN version */
          /* e.g. "1.2" = 0x0102 */
    taggedstruct { /* optional */
      "CAN_ID_BROADCAST" ulong; /* Auto detection CAN-ID */
                                /* master -> slaves */
                                /* Bit31= 1: extended identifier */
      "CAN_ID_MASTER" ulong;    /* CMD/STIM CAN-ID */
                                /* master -> slave */
                                /* Bit31= 1: extended identifier */
      "CAN_ID_MASTER_INCREMENTAL";     /* master uses range of CAN-IDs  */
                                /* start of range = CAN_ID_MASTER */
                                /* end of range = CAN_ID_MASTER+MAX_BS(_PGM)-1 */
      "CAN_ID_SLAVE" ulong;     /* RES/ERR/EV/SERV/DAQ CAN-ID */
                                /* slave -> master */
                                /* Bit31= 1: extended identifier */
      "BAUDRATE" ulong;         /* BAUDRATE [Hz] */
      "SAMPLE_POINT" uchar;     /* sample point */
                                /* [% complete bit time] */
      "SAMPLE_RATE" enum {
        "SINGLE" = 1,           /* 1 sample per bit */
        "TRIPLE" = 3            /* 3 samples per bit */
      };
      "BTL_CYCLES" uchar;       /* BTL_CYCLES */
                                /* [slots per bit time] */
      "SJW" uchar;              /* length synchr. segment */
                                /* [BTL_CYCLES] */
      "SYNC_EDGE" enum {
        "SINGLE" = 1,           /* on falling edge only */
        "DUAL" = 2              /* on falling and rising edge */
      };
      "MAX_DLC_REQUIRED";       /* master to slave frames */
                                /* always to have DLC = MAX_DLC = 8 */
                              
      (block "DAQ_LIST_CAN_ID" struct { /* At IF_DATA DAQ */
        uint;                   /* reference to DAQ_LIST_NUMBER */
        taggedstruct {          /* exclusive tags */
                                /* either VARIABLE or FIXED */
          "VARIABLE";
          "FIXED" ulong;        /* this DAQ_LIST always */
                                /* on this CAN_ID */
        };
      })*;
      (block "EVENT_CAN_ID_LIST" struct { /* At IF_DATA DAQ  */
        uint;                   /* reference to EVENT_NUMBER */
        taggedstruct {          /* exclusive tags */
          ("FIXED" ulong)*;        /* this Event always on this ID */
        };
      })*;
        
      "MAX_BUS_LOAD"  ulong;    /* maximum available bus */
                                   /* load in percent */
  
      block "CAN_FD" struct {
        taggedstruct {

          "MAX_DLC" uint; /* 8, 12, 16, 20, 24, 32, 48 or 64 */
          "CAN_FD_DATA_TRANSFER_BAUDRATE" ulong; /* BAUDRATE [Hz] */
 
          "SAMPLE_POINT" uchar;   /* sample point receiver*/
                                      /* [% complete bit time] */
        
          "BTL_CYCLES" uchar;            /* BTL_CYCLES        */
                                     /* [slots per bit time]   */
          "SJW" uchar;              /* length synchr. segment */
                                     /* [BTL_CYCLES]           */
          "SYNC_EDGE" enum {
                       "SINGLE" = 1, /* on falling edge only */
                       "DUAL"   = 2  /* on falling and rising edge*/
                     };
  
          "MAX_DLC_REQUIRED";      /* master to slave frames */
                         /* always to have DLC = MAX_DLC_for CAN-FD */
  
          "SECONDARY_SAMPLE_POINT" uchar;/* sender sample point */
                                     /* [% complete bit time] */
          "TRANSCEIVER_DELAY_COMPENSATION" enum {
                         "OFF" = 0,
                         "ON" = 1
          };
                       
        };
        
      };
      
    };
    
  };

/************************* end of CAN **********************/


/***********************************************************/
/*                                                         */
/* ASAP2 meta language for XCP on TCP_IP V1.2              */
/*                                                         */
/*                                                         */
/*   Datatypes:                                            */
/*                                                         */
/*   A2ML       description                                */
/*   ----------------------------------------------------- */
/*   uchar      unsigned 8  Bit                            */
/*   char       signed 8 Bit                               */
/*   uint       unsigned integer 16 Bit                    */
/*   int        signed integer 16 Bit                      */
/*   ulong      unsigned integer 32 Bit                    */
/*   long       signed integer 32 Bit                      */
/*   float      float 32 Bit IEEE 745                      */
/*                                                         */
/***********************************************************/
/************************ start of TCP_IP ******************/

  struct TCP_IP_Parameters {

     uint; /* XCP on TCP_IP version */
           /* e.g. "1.2" = 0x0102 */
     uint; /* PORT */

     taggedunion {
       "HOST_NAME" char[256];
       "ADDRESS" char[15];
       "IPV6" char[39];
     };
     taggedstruct{
       "MAX_BUS_LOAD"  ulong; /* maximum available bus */
				     /* load in percent */
       "MAX_BIT_RATE"  ulong; /* Network speed which is */ 
                              /* the base for MAX_BUS_LOAD in Mbit*/

     };

  };

/************************* end of TCP_IP *******************/


/***********************************************************/
/*                                                         */
/* ASAP2 meta language for XCP on TCP_IP V1.2              */
/*                                                         */
/*                                                         */
/*   Datatypes:                                            */
/*                                                         */
/*   A2ML       description                                */
/*   ----------------------------------------------------- */
/*   uchar      unsigned 8  Bit                            */
/*   char       signed 8 Bit                               */
/*   uint       unsigned integer 16 Bit                    */
/*   int        signed integer 16 Bit                      */
/*   ulong      unsigned integer 32 Bit                    */
/*   long       signed integer 32 Bit                      */
/*   float      float 32 Bit IEEE 745                      */
/*                                                         */
/***********************************************************/
/************************ start of UDP_IP ******************/

  struct UDP_IP_Parameters {

     uint; /* XCP on UDP_IP version */
           /* e.g. "1.2" = 0x0102 */
     uint; /* PORT */

     taggedunion {
       "HOST_NAME" char[256];
       "ADDRESS" char[15];
       "IPV6" char[39];
     };
     taggedstruct{
       "MAX_BUS_LOAD"  ulong; /* maximum available bus */
				     /* load in percent */
       "MAX_BIT_RATE"  ulong; /* Network speed which is */ 
                              /* the base for MAX_BUS_LOAD in Mbit*/

     };

  };

/*************************** end of UDP ********************/


/***********************************************************/
/*                                                         */
/* ASAP2 meta language for XCP on FLX V1.2                 */
/*                                                         */
/*                                                         */
/*   Datatypes:                                            */
/*                                                         */
/*   A2ML       description                                */
/*   ----------------------------------------------------- */
/*   uchar      unsigned 8  Bit                            */
/*   char       signed 8 Bit                               */
/*   uint       unsigned integer 16 Bit                    */
/*   int        signed integer 16 Bit                      */
/*   ulong      unsigned integer 32 Bit                    */
/*   long       signed integer 32 Bit                      */
/*   float      float 32 Bit IEEE 745                      */
/*                                                         */
/***********************************************************/
/************************ start of FLX *********************/
  
  enum packet_assignment_type {
               "NOT_ALLOWED",
               "FIXED",
               "VARIABLE_INITIALISED",
               "VARIABLE"
               }; /* end of packet_assignment_type */
  
  struct buffer {
  
    uchar;  /* FLX_BUF */
   
    taggedstruct {
  
      "MAX_FLX_LEN_BUF" taggedunion {
               "FIXED" uchar;    /* constant value */
               "VARIABLE" uchar; /* initial value */
               }; /* end of MAX_FLX_LEN_BUF */
  
      block "LPDU_ID" taggedstruct {
  
        "FLX_SLOT_ID" taggedunion {
               "FIXED" uint;
               "VARIABLE" taggedstruct{
                   "INITIAL_VALUE" uint;
                   };
               }; /* end of FLX_SLOT_ID */
  
        "OFFSET" taggedunion {
               "FIXED" uchar;
               "VARIABLE" taggedstruct{
                   "INITIAL_VALUE" uchar;
                   };
               }; /* end of OFFSET */
  
        "CYCLE_REPETITION" taggedunion {
               "FIXED" uchar;
               "VARIABLE" taggedstruct{
                   "INITIAL_VALUE" uchar;
                   };
               }; /* end of CYCLE_REPETITION */
  
        "CHANNEL" taggedunion {
               "FIXED" enum {
                        "A" = 0,
                        "B" = 1
                       };
               "VARIABLE" taggedstruct{
                   "INITIAL_VALUE" enum {
                                    "A" = 0,
                                    "B" = 1
                                   };
                   };
               }; /* end of CHANNEL */
  
         }; /* end of LPDU_ID */
  
      block "XCP_PACKET" taggedstruct {
  
        "CMD" enum packet_assignment_type;          /* end of CMD          */
        "RES_ERR" enum packet_assignment_type;  /* end of RES_ERR */
        "EV_SERV" enum packet_assignment_type;  /* end of EV_SERV  */
        "DAQ" enum packet_assignment_type;           /* end of DAQ           */
        "STIM" enum packet_assignment_type;          /* end of STIM          */
       
         }; /* end of XCP_PACKET */
    }; 
  
  }; /* end of buffer */
  
  struct FLX_Parameters {
  
      uint;                              /* XCP on FlexRay version  */
                                           /* e.g. "1.0" = 0x0100 */
  
      uint;                          /* T1_FLX [ms] */
  
      char[256];                     /* FIBEX-file including CHI information */
                                     /* including extension    */
                                     /* without path */
  
      char[256];                     /* Cluster-ID */
  
      uchar;                         /* NAX */
  
      enum { 
        "HEADER_NAX"               = 0,
        "HEADER_NAX_FILL"          = 1,
        "HEADER_NAX_CTR"           = 2,
        "HEADER_NAX_FILL3"         = 3,
        "HEADER_NAX_CTR_FILL2"     = 4,
        "HEADER_NAX_LEN"           = 5,
        "HEADER_NAX_CTR_LEN"       = 6,
        "HEADER_NAX_FILL2_LEN"     = 7,
        "HEADER_NAX_CTR_FILL_LEN"  = 8
      };
   
  
      enum { 
        "PACKET_ALIGNMENT_8"  = 0,
        "PACKET_ALIGNMENT_16" = 1,
        "PACKET_ALIGNMENT_32" = 2
      };
  
      taggedunion {
        block "INITIAL_CMD_BUFFER" struct buffer;
      };
  
      taggedunion {    
        block "INITIAL_RES_ERR_BUFFER" struct buffer;
      };
  
      taggedstruct {
  
        (block "POOL_BUFFER" struct buffer)*;
  
      };
  
  };
  
/************************* end of FLX **********************/


    block "IF_DATA" taggedunion if_data {
/***************************************************************************/
/*                                                                         */
/*   ETAS GmbH                                                             */
/*                                                                         */
/*   ASAP2 Meta Language for ETAS ETK Bypass                               */
/*   assumes ASAP2 V1.31 or higher                                         */
/*                                                                         */
/*                                                                         */
/*   Change History:                                                       */
/*                                                                         */
/*   Version  Date        Author     Modification                          */
/*   ===================================================================   */
/*   V1.0     2001-07-01  ETAS/PAC   Official ETAS Version                 */
/*                                   included in RTIO / Tip-EXP            */
/*                                   Equal to RB/DS V1.0                   */
/*   V1.1     2007-01-16  Wenzel     TP_BLOB version 0x0101                */
/*                                   - added: BYPASS_CONFIGURATION         */
/*                                                                         */
/*   V1.2     2010-04-20  Kreikenbohm TP_BLOB version 0x0102               */
/*                        Wrobel     - added: SOFTWARE_REVISION            */
/*                                   - deleted: old stuff                  */
/*                                                                         */
/*   V1.2.1   2013-04-29  Wrobel     - deleted usage of POSSIBLE_SOURCES   */
/*                                     without any following number        */
/*                                   - fixed some text formatting          */
/*                                                                         */
/***************************************************************************/

"ASAP1B_Bypass" taggedstruct {

  block "TP_BLOB" struct {
    uint;           /* Bypass Version, High Byte: Version                  */
                    /*                 Low Byte : subversion (dec.)        */
    uint;           /* Blob Version,   0x0102                              */
                    /*                 High Byte: Version                  */
                    /*                 Low Byte : subversion (dec.)        */
    taggedstruct {
      "BYPASS_CONFIGURATION" struct {
        uint;                    /* BASE_OFFSET_VALUE                      */
                                 /*   value: (0/2) valid for Distab 12     */
                                 /*   value: (0/8) valid for Distab 13     */
                                 /* Allows to define the Bypass Settings   */
                                 /* used in the bypass tool.               */
        taggedstruct {
          "FAR_ADDRESS" struct {
            ulong;               /* FAR_ADDRESS_BEGIN                      */
                                 /*   address value                        */
            ulong;               /* FAR_ADDRESS_LENGTH                     */
                                 /*   size value                           */
          };
          "ADDRESS_MAPPING" enum {
                                 /* [Mask16Bit, DPP0, DPP1, DPP2, DPP3]    */
                                 /* Distab12 only! Ignored for Distab 13ff.*/
            "Mask16Bit" =0,
            "DPP0"      =1,
            "DPP1"      =2,
            "DPP2"      =3,
            "DPP3"      =4
          };
          "SOFTWARE_REVISION" struct {
                                 /* Defines the expected software revision, used for the bypass consistency check. */
                                 /* Different software versions must have different strings here.                  */
                                 /* Optional; if defined it is taken prior to the EPK value by bypass systems.     */
            ulong;               /* SOFTWARE_REVISION_ADDRESS              */
                                 /* start address of the subsequent string */
            char[256];           /* SOFTWARE_REVISION_VALUE                */
                                 /* the software revision as ASCII string  */
          };
        };
      };
    };
  };

  block "KP_BLOB" struct {
    taggedstruct {

      "BUFFER_OFFSET"    char[256];  /* parameter value represents         */
                                     /* Offset value for transfer of       */
                                     /* Stimuli Value from the             */
                                     /* Data buffer into the ECU code      */
                                     /* Can be used in the ECU code        */
                                     /* also as a switch                   */
                                     /* for bypassed / not bypassed        */
                                     /* if the base offset value           */
                                     /* is not equal zero.                 */
                                     /* Base Offset != 0                   */
                                     /* Then  = 0 -> not bypassed          */
                                     /*      != 0 -> bypassed              */

      "SOURCE_ID"        char[256];  /* parameter value represents         */
                                     /* stimulus channel                   */

      "BIT_OFFSET"       char[256];  /* parameter value represents         */
                                     /* mask in case of bit objects        */

      "POSSIBLE_SOURCES" ( uint )*;  /* list of all channels, where this   */
                                     /* intervention point is usable.      */
                                     /* at least one number has to be given*/
                   /* special case:                                        */
                   /* keyword omitted = intervention point is usable       */
                   /*                   in all available channels          */
    };
  };

};  
/*********************************************************************************/
/*                                                                               */
/*   ASAP2 Meta description for ETK/XETK                                         */
/*                                                                               */
/*   Used data types:                                                            */
/*                                                                               */
/*   A2ML       ASAP2          Windows  Explanation                              */
/*   ---------------------------------------------------------                   */
/*   uchar      UBYTE          BYTE     unsigned 8 Bit                           */
/*   char       SBYTE          char     signed 8 Bit                             */
/*   uint       UWORD          WORD     unsigned integer 16 Bit                  */
/*   int        SWORD          int      signed integer 16 Bit                    */
/*   ulong      ULONG          DWORD    unsigned integer 32 Bit                  */
/*   long       SLONG          LONG     signed integer 32 Bit                    */
/*   float      FLOAT32_IEEE            float 32 Bit                             */
/*                                                                               */
/*                                                                               */
/*   AML Version V1.0, 2008                                                      */
/*                                                                               */
/*   Change History:                                                             */
/*                                                                               */
/*   Version  Date           Author          Modification                        */
/*   ========================================================================    */
/*   V1.0.1   26-Oct-2007    ETAS-PHW        Added Advanced Code Check           */
/*                                           parameters                          */
/*   V1.0.2   28-May-2008    ETAS-PSW        ASAP1B_Bypass removed               */
/*   V1.1.0   16-Dec-2008    ETAS-PHW        Added global version to device list */
/*                                           Added display names to device list  */
/*                                           Removed TP_BLOB version             */
/*                                           Removed QP_BLOB version             */
/*                                           Added Trace Windows and Triggers    */
/*   V1.2.0   26-Nov-2010    ETAS-NE         Added Accumulated measurement       */
/*                                           - flag "DISTAB_COLLECTION_MODE"     */
/*                                             for display table in TP-Blob      */
/*                                           - new block "ACCUMULATION_MODE" in  */
/*                                             QP_BLOB with parameters for       */
/*                                             accumulated measurement           */
/*                                           Added Stimulation Raster Support    */
/*                                           Added One-Shot-Measurement Support  */
/*   V1.3.0   03-Nov-2011    ETAS-NE         ETK_XETK_LIST - ETK:                */
/*                                           - add CONFIG features.              */
/*                                           - either ETK_CFG or CONFIG feature  */
/*                                             shall be defined.                 */
/*   V2.0     13-Apr-2012    ETAS-NE         Add project identification:         */
/*                                              - PROJECT_IDENTIFICATION         */
/*                                           Add data freeze definitions:        */
/*                                             - reserved memory segments:       */
/*                                               WRITE_AT_DATA_UPDATE            */
/*                                               USE_FLASH, USE_ECU_FLASH, ERASE */
/*                                             - TP_BLOB: DATA_FREEZE            */
/*                                           Add DISTAB17 definitions in TP_BLOB:*/
/*                                             - ECU_EVENT_LIST                  */
/*                                             - TABLE_ALIGNMENT                 */
/*                                             - EVENT_CONFIG_OUTPUT_AREA        */
/*                                             - DATA_ACQUISITION                */
/*                                             - ECU_PROPERTY                    */
/*                                             - TRIGGER_CFG                     */
/*                                           Change QP_BLOB according DISTAB17:  */
/*                                             - renaming: raster -> event       */
/*                                             - add ECU_PROPERTY                */
/*                                           Allow only one block TIMER_CFG      */
/*                                           Allow ETK specific TRACE_TRIGGER_CFG*/
/*                                           Add / change page switching:        */
/*                                             - add OMD page switch: OMD        */
/*                                           Add user specific error code text:  */
/*                                             - ECU_DEFINED_ERRORCODES          */
/*   V2.1.0   04-Apr-2013    ETAS-NE         ETK_XETK_LIST                       */
/*                                             - add FETK                        */
/*   V2.2.0   25-Sep-2015    ETAS-NE         Added ECU_ID for Trace Triggers     */
/*                                           Added configuration features for    */
/*                                           acquisition channels                */
/*   V2.2.1   07-Nov-2016    ETAS-NE         Bugfix in QP_BLOB-TRG_TYPE          */
/*   V2.3.0   17-Jul-2017    ETAS-NE         Allow ETK specific TRACE_WINDOW     */
/*                                                                               */
/*********************************************************************************/

/*********************************************************************************/
/*                                                                               */
/* For a correct working of the (X)ETK, the following MEMORY_SEGMENTs            */
/* have to  be specified in the section 'MOD_PAR' of the ASAP2 file:             */
/*                                                                               */
/*  /begin MEMORY_SEGMENT                                                        */
/*     Dataxxxx ""  DATA FLASH <mem. location> <address> <size> <mirrors>        */
/*  /end MEMORY_SEGMENT                                                          */
/*                                                                               */
/*  /begin MEMORY_SEGMENT                                                        */
/*     Codexxxx ""  CODE FLASH <mem. location> <address> <size> <mirrors>        */
/*  /end MEMORY_SEGMENT                                                          */
/*                                                                               */
/*  /begin MEMORY_SEGMENT                                                        */
/*     ExRAM "ExRAM for DISTAB" VARIABLES RAM EXTERN <address><size><mirrors>    */
/*  /end MEMORY_SEGMENT                                                          */
/*                                                                               */
/*********************************************************************************/ 

 "ETK_XETK" struct
  {
    taggedstruct
    {
      block "ETK_XETK_LIST" struct
      {
        /* defines the version of the used AML */
        enum
        {
          "ETK_XETK_AML_VERSION_2_3_0" = 0x020300
        };

        taggedstruct
        {
          "PROJECT_IDENTIFICATION" char[256];

                                /* The ETK_XETK_ID is used as reference (ETK_XETK_REF)*/
                                /* by other IF_DATA XETK feature descriptions.        */
                                /* Therefor it must be unique within ETK and XETK.    */
                                /* It is intended that numbers beginning with "1"     */
                                /* are used. The "0" is reserved for future use.      */
          (block "ETK"  struct
          {
            ulong;                /* ETK_XETK_ID         the unique identifier        */
            enum                  /* DEVICE_COMM_SPEED   fix comm speed on ETK line   */
            {                     /*                     to 8/100 MBit/s              */
              "INTERFACE_SPEED_8MBIT"   = 1,
              "INTERFACE_SPEED_100MBIT" = 2
            };

            taggedstruct
            {
              "ETK_CFG" (uchar)*; /* config string for existing ETKs                   */

              ("CONFIG" struct
              {
                char[256];        /* DEVICE_PARAM        parameter                     */
                char[256];        /* DEVICE_PARAM_VALUE  value                         */
              })*;

              "RESET_CFG" ulong;  /* reset config word. not used for serial ETKs       */
              "DISPLAY_NAME" char[256]; /* name for display */
            };
          })*;

          (block "XETK" struct
          {
            ulong;                /* ETK_XETK_ID  the unique identifier                */
            taggedstruct
            {
              ("CONFIG" struct
              {
                char[256];        /* DEVICE_PARAM        parameter                     */
                char[256];        /* DEVICE_PARAM_VALUE  value                         */
              })*;
              "DISPLAY_NAME" char[256]; /* name for display */
            };
          })*;

          (block "FETK" struct
          {
            ulong;                /* ETK_XETK_FETK_ID  the unique identifier                */
            taggedstruct
            {
              ("CONFIG" struct
              {
                char[256];        /* DEVICE_PARAM        parameter                     */
                char[256];        /* DEVICE_PARAM_VALUE  value                         */
              })*;
              "DISPLAY_NAME" char[256]; /* name for display */
            };
          })*;

          block "RASTER_CHECK" struct
          {
            taggedstruct
            {
              "OFFLINE_DEVICE" ulong; /* default device used for offline raster check, displayed in INCA HWC*/
            };
            enum /* default for online raster check */
            {
              "ONLINE_RESPECT_OFFLINE_LIMIT" = 1,
              "ONLINE_USE_CONNECTED_DEVICE_ONLY" = 2
            };
          };
        };
      };

      /* Description of an address mapping between addresses in the view of the */
      /* EPROM of the ECU (and ASAP2) and the addresses in the scope of the ETK */
      /* IF_DATA section used with MEMORY_SEGMENT (can be missing if no         */
      /* differences between the 2 views)                                       */

      ("ADDRESS_MAPPING" struct
      {
        ulong;              /* Start address of MEMORY_SEGMENT */
        ulong;              /* mapped start address for ETK    */
        ulong;              /* Length of mapped address range  */
        taggedstruct
        {
          "ETK_XETK_REF" (ulong)*; /* references to used ETKs  */
        };
      })*;

      /* IF_DATA section used with MEMORY_SEGMENT                             */
      /* defines whether the memory is located (emulated) in the XETK or      */
      /* or whether the XETK accesses the memory via serial interface, e.g.   */
      /* debug interface                                                      */
      (block "ETK_XETK_ACCESS" struct
      {
        taggedunion
        {
          "NOT_RELEVANT_FOR_ETK_XETK";      /* do not touch the segment                    */
          "ETK_XETK_EMULATION_MEMORY";      /* XETK DPR, memory is located in XETK         */
          "SERIAL_INTERFACE" struct         /* e.g. debug interface, memory located in ECU */
          {
            taggedstruct
            {
              "PHYSICAL_ADDRESS" ulong;
            };
          };
        };
        taggedstruct
        {
          "ETK_XETK_REF" (ulong)*; /* references to used ETKs  */
        };
      })*;

      /* IF_DATA section used with RESERVED MEMORY_SEGMENT to control data freeze */
      "WRITE_AT_DATA_UPDATE" struct
      {
        enum
        {
          "USE_FILE" = 0,
          "USE_ECU_FLASH" = 1,
          "ERASE" = 2
        };
      };    /* if set, the segment shall be freezed while data freeze */
      "ETK_XETK_REF" (ulong)*; /* references to used ETKs         */

      /* description of the trace window */
      (block "TRACE_WINDOW" struct
      {
        ulong;      /* START_ADDRESS  start address of the trace window */
        ulong;      /* SIZE           size of the trace window          */
        taggedstruct
        {
            "PHYSICAL_ADDRESS" ulong;
        };
        taggedstruct {
          ("CONFIG" struct
          {
            char[256];        /* TRACE_PARAM        parameter           */
            char[256];        /* TRACE_PARAM_VALUE  value               */
          })*;
        };
        taggedstruct
        {
           "ETK_XETK_REF" (ulong)*; /* references to used ETKs  */
        };
      })*;


      "DEFAULT_RASTERS" (ulong)*; /* used in MEASUREMENT definitions; refers  */
                                  /* to the RSTR_ID field of the QP_BLOB      */

      block "TP_BLOB" struct
      {
        enum                   /* BYTE_ORDER */
        {
          "BYTE_ORDER_MSB_FIRST" = 1,
          "BYTE_ORDER_MSB_LAST" = 2
        };

        taggedstruct {
          block "DISTAB_CFG" struct
          {
            uint;             /* DISTAB_NBR        distab version */
            taggedstruct
            {
              "DISTAB_12_DAT_MOD" enum
              {
                "DAT_MOD_BYTE" = 1,
                "DAT_MOD_WORD" = 2
              };
            };
            taggedstruct
            {
              "DISTAB_COLLECTION_VERSION" enum
              { /* Main switch: accumulated measurement parameter in QP-BLOB allowed  */
                "STANDARD" = 0,              /* default value,if mising               */
                "ACCUMULATED_VERSION_1" = 1  /* Distab header defined for version 1   */
              };
            };
          };

          (block "ECU_EVENT_LIST" struct
          {
            ulong; /* start address of ECU event list        */
            taggedstruct
            {
              "ETK_XETK_REF" (ulong)*;
            };
          })*;

          "TABLE_ALIGNMENT" enum { /* alignment of event config and data area */
            "ALIGNMENT_2_BYTE" = 2,
            "ALIGNMENT_4_BYTE" = 4,
            "ALIGNMENT_8_BYTE" = 8,
            "ALIGNMENT_16_BYTE" = 16
          };

          (block "EVENT_CONFIG_OUTPUT_AREA" struct
          {
            ulong; /* start of event config area */
            ulong; /* size in bytes of event config area */
            ulong; /* start of event output area */
            ulong; /* size in bytes of event output area */
            taggedstruct
            {
              "ETK_XETK_REF" (ulong)*; /* references to used ETKs            */
            };
          })*;

          (block "DATA_ACQUISITION" struct
          {
            taggedstruct
            {
              ("PRIORITY_RANGE" struct
              {
                ulong;  /* first priority */
                ulong;  /* last priority */
              })*;
              "ETK_XETK_REF" (ulong)*; /* references to used ETKs            */
            };
          })*;

          (block "ECU_PROPERTY" struct {
            taggedstruct
            {
              "OVERALL_PERFORMANCE" struct
              {
                ulong;       /* overall variables per second */
                ulong;       /* overall bytes per second     */
              };
              ("CORE_PERFORMANCE" struct
              {
                ulong;     /* core                       */
                ulong;     /* variables per second       */
                ulong;     /* bytes per second           */
              })*;
              "ETK_XETK_REF" (ulong)*; /* references to used ETKs */
            };
          })*;

          /* List of triggers provided by the ECU for services */
          (block "TRIGGER_CFG" struct
          {
            taggedstruct
            {
              ("TRIGGER" struct
              {
                ulong;        /* TRG_NBR: the number of the hardware trigger */
                taggedunion { /* TRG_TYPE: trigger type */
                  "DIRECT";
                  "INDIRECT";
                };
                taggedstruct {
                  "ECU_ID" struct {
                    uint; /* ECU_ID, to be written in trigger of the event configuration */
                  };
                };
              })*;
              "ETK_XETK_REF" (ulong)*; /* references to used ETKs            */
            };
          })*;

          block "TIMER_CFG" struct
          {
            /* Description of Timers used for triggering  */

            taggedstruct
            {
              ("TIMER" struct {
                uint;            /* TIMER_ID          Timer number (start with 1) */
                ulong;           /* TIMER_TIME        Time in us                  */
              })*;
            };
          };

          (block "TRACE_TRIGGER_CFG" struct
          {
            taggedstruct
            {
              ("TRACE_TRIGGER" struct
              {
                /* Description of Trace trigger                                                       */
                uint;               /* TRACE_TRIGGER_ID  Trace Trigger number (start with 1)          */
                ulong;              /* ADDRESS           Address of write access to raise the trigger */
                taggedstruct
                {
                  ("CONFIG" struct
                  {
                    char[256];        /* TRACE_TRIGGER_PARAM        parameter   */
                    char[256];        /* TRACE_TRIGGER_PARAM_VALUE  value       */
                  })*;
                };
                taggedstruct {
                    "ECU_ID" struct {
                    uint; /* ECU_ID, to be written in trigger of the event configuration (offset in case of TBV) */
                  };
                };
              })*;
              "ETK_XETK_REF" (ulong)*; /* references to used ETKs               */
            };
          })*;

          (block "RESERVED_MEMORY" struct
          {
            /* Description of 'reserved ranges' (especially in the data or code   */
            /* ranges; e.g. location of the display tables) that are excluded     */
            /* from checksum verification. If the 3 display tables stand close    */
            /* together, the size of the reserved memory is calculated by the     */
            /* following formula:                                                 */
            /*          size = (highest start address of the 3 distabs)           */
            /*                  + ((size of this distab) + 2) * 4                 */
            /*                  - (lowest start address of the 3 distabs)         */

            ulong;           /* RES_MEM_ADDR       Start address                  */
            ulong;           /* RES_MEM_LEN        Length in bytes                */
            enum {           /* RES_MEM_LOCATION   Location                       */
              "INTERN"  = 0,
              "EXTERN"  = 1
            };
            enum {           /* RES_MEM_APPL       application                    */
              "MEASUREMENT" = 0,
              "BYPASS"    = 1
            };
            enum {           /* RES_MEM_USAGE      usage                          */
              "CHECKSUM_EXCLUDE_ONLY" = 0,
              "ECU_DISTAB_INPUT"      = 1,
              "ECU_DISTAB_OUTPUT"     = 2,
              "ECU_DISTAB_INOUT"      = 3
            };
            taggedstruct
            {
              "ETK_XETK_REF" (ulong)*; /* references to used ETKs                 */
            };
          })*;

          (block "MAILBOX" struct
          {
            /* Description of the ETK mailbox that is used for communication      */
            /* between the ECU and the application program (e.g. for programming  */
            /* data into the ECU flash)                                           */

            ulong;           /* ETK_MBX_TEST_PATTERN  Test pattern for the ECU to    */
                             /*                       detect a valid mailbox         */
            enum {           /* ETK_MBX_IN_MEM_PAGE   Memory page (code, data,       */
                             /*                       external RAM) used for         */
                             /*                       communication from application */
                             /*                       program to ECU                 */
              "CODE"  = 1,
              "DATA"  = 2,
              "RAM" = 3
            };
            ulong;           /* ETK_MBX_IN_BUF_ADDR   Base address of buffer for       */
                             /*                       communication application -> ECU */
            ulong;           /* ETK_MBX_IN_BUF_LEN    Length of buffer for             */
                             /*                       communication application -> ECU */
            enum {           /* ETK_MBX_OUT_MEM_PAGE  Memory page (code, data,         */
                             /*                       external RAM) used for           */
                             /*                       communication ECU -> application */
              "CODE"  = 1,
              "DATA"  = 2,
              "RAM" = 3
            };
            ulong;           /* ETK_MBX_OUT_BUF_ADDR  Base address of buffer for       */
                             /*                       communication ECU -> application */
            ulong;           /* ETK_MBX_OUT_BUF_LEN   Length of buffer for             */
                             /*                       communication ECU -> application */
            ulong;           /* ETK_MBX_TYPE          Mailbox type                     */

            enum {           /* ETK_MBX_VERSION       Mailbox version                  */
              "MB_VERSION_1_0" = 0x100
            };
            taggedstruct {               /*     references to used ETKs       */
              "ETK_XETK_REF" (ulong)*;   /*     ref to ETK_XETK_ID            */
            };
          })*;

          block "TRIGGER_SEGMENT_BASE" struct
          {
            ulong;           /* TRGSEGAD      Trigger segment address */
            taggedstruct
            {
              "ETK_XETK_REF" (ulong)*; /* references to used ETKs     */
            };
          };

          block "CODE_CHK" struct {
            /* A check, whether program and data are matching can be performed,   */
            /* if the ECU copies a certain 'program identifier' (e.g. the code    */
            /* checksum) into the external RAM and the same identifier is stored  */
            /* in the data range. The ETK driver can read and compare both        */
            /* identifier and issue an error message, if the both identifiers do  */
            /*  not match.                                                        */

            ulong;           /* CDE_CHK_INT_ADDR   ETK: address of program        */
                             /*                    identifier in the data         */
                             /*                    range PRG_DATA                 */
            ulong;           /* CDE_CHK_EXT_ADDR   ETK: address of program        */
                             /*                    identifier in the              */
                             /*                    external RAM PRG_ERAM          */
            uint;            /* CDE_CHK_LEN        ETK: length of program         */
                             /*                    identifier in the data         */
                             /*                    range (max. 32 bytes)          */
            taggedstruct
            {
              "PATTERN_REFRESH_TIMEOUT" struct
              {
                uint;          /* CDE_CHK_TIM timeout in ms                       */
              };
            };
            /* If all parameters contain 0x0 values, no check is performed        */

            taggedstruct
            {
                "ERROR_BEHAVIOR" enum {     /* reaction of MC tool to ECU when    */
                "PERMANENT_RESET" = 0,      /* code check fails                   */
                "NO_RESET"        = 1
              };

              "ETK_XETK_REF" (ulong)*; /* references to used ETKs                 */
            };
          };

          (block "PRESENCE_PATTERN" struct
          {
            ulong;           /* address of ETK recognition pattern        */
            taggedstruct
            {
              "PATTERN" (uchar)*;      /* bytes used for presence check   */
              "ETK_XETK_REF" (ulong)*; /* references to used ETKs         */
            };
          })*;

          block "COLDSTART_HANDSHAKE" struct
          {
            ulong;           /* COLDSTART_PATTERN_ADDR  address of ETKS cold    */
                             /*                         start pattern           */
            taggedstruct {
              "WAIT" (uchar)*;   /* pattern                                     */

              "READY" (uchar)*;  /* pattern                                     */

              "ETK_XETK_REF" (ulong)*; /* references to used ETKs               */
            };
          };

          block "PAGE_SWITCH_METHOD" struct
          {
            ulong;               /* Page Switch Method version                    */
            taggedstruct {
              "MAILBOX" struct {
                ulong;           /* MBX_VERSION          Version of mailbox       */
                ulong;           /* MBX_PAGE_SETUP_TIME  max time the ECU needs   */
                                 /*                      to set up page in ms     */
                ulong;           /* MBX_ADDR             Start address of table   */
              };

              "AUTOSTART_BEHAVIOR" enum {
                "LAST_ACTIVE_PAGE" = 0, /* Table to be filled by INCA with info */
                                        /* for the current active page          */
                "ALWAYS_WP"        = 1, /* Request field to be filled by INCA   */
                                        /* always with info for working page    */
                "ALWAYS_RP"        = 2  /* Request field to be filled by INCA   */
                                        /* always with info for reference page  */
              };

              "OCT_WORKINGPAGE" struct {
                ulong;       /* OCT_TYPE         Type of table                  */
                ulong;       /* OCT_ADDR         Start address of table         */
                ulong;       /* OCT_LEN          max Length of table in byte    */
              };

              "OCT_REFERENCEPAGE" struct {
                ulong;       /* OCT_TYPE         Type of table                  */
                ulong;       /* OCT_ADDR         Start address of table         */
                ulong;       /* OCT_LEN          max Length of table in byte    */
              };

              "OMD" struct {
                ulong;       /* OMD_ADDRESS                 Address of OMD                               */
                ulong;       /* OMD_CID                     CID of OMD                                   */
                ulong;       /* OMD_VERSION                 Version of OMD table                         */
                ulong;       /* OMD_MAX_LEN                 Max. length of OMD in bytes                  */
                ulong;       /* OMD_NUMBER_OF_EMU_HANDLES   Number of EMU handles in table.              */
                             /*                             Value should match with the uC capabilities. */
              };

              "CODE_CHK_PATTERN_WP" struct {
                ulong;     /* CDE_CHK_WP_ADDR  address of code check pattern in working page */
              };

              "ETK_XETK_REF" (ulong)*; /* references to used ETKs */
            };
          };

          block "ECU_DEFINED_ERRORCODES" struct
          {
            taggedstruct {
              ("ERROR_ENTRY" struct {
              ulong;                /* Error code; must be unique!                                 */
              char[256];            /* Error message used by INCA for the code previously defined. */
              })*;
            };
          };


          block "CAL_WAKEUP" taggedstruct
          {
            "CAL_WAKEUP_PIN" ulong;     /* 1 = wake up enabled, 0 = disabled  */
            "CAL_TOOL_PRESENT" struct {
              ulong;               /* CAL_TOOL_PATTERN_ADDR    address for the pattern        */
              ulong;               /* CAL_TOOL_PATTERN         pattern                        */
              ulong;               /* CAL_TOOL_ECU_TIMEOUT     ECU timeout for shut down in s */
            };
            "ETK_XETK_REF" (ulong)*;
          };

          (block "DATA_FREEZE" taggedstruct
          {
            ("CONFIG" struct {
              char[256]; /* DATA freeze config feature parameter   */
              char[256]; /* DATA freeze config feature value       */
            })*;
            "ETK_XETK_REF" (ulong)*;
          })*;

        };
      };

      (block "SOURCE" struct
      {
        /* Description of the acquisition (trigger) levels supplied by the ECU  */

        struct
        {
          char [100];        /* Source name                                     */
          int;               /* CSE unit according to Asap1b (minimal period    */
                             /* duration) of the acqisition raster              */
          long;              /* Minimal period number measured in the CSE unit  */
        };
        taggedstruct
        {
          block "QP_BLOB" struct
          {
            uint;  /* RSTR_ID         unique id. Is referred to in the measurement sections       */
            uint;  /* RSTR_PRIO       event priority, higher number = higher priority             */
            ulong; /* RSTR_MIN_TIME   worst case minimum raster time in us, 0 is not considered in the raster check */
            taggedstruct {
              (block "ETK_XETK_SPECIFIC" struct
              {
                taggedunion {            /* TRG_GEN raster trigger generation                     */
                  "TRG_NBR" struct
                  {
                    uint;                /* hardware trigger number                               */
                  };
                  "TIMER_REF" struct
                  {
                    uint;                /* TIMER_REF         reference to TIMER_ID               */
                  };
                  "TRACE_TRIGGER_REF" struct
                  {
                    uint;                /* TRACE_TRIGGER_REF reference to trace TRACE_TRIGGER_ID */
                  };
                  "STIM_EVENT" struct
                  {
                    uint;                /* STIM_EVENT the "event" for the stimulation action */
                  };
                  "START_MEASUREMENT_EVENT" struct
                  {
                    uint;                /* the "event" generated at the start of the measurement */
                  };

                };
                taggedstruct {           /* TRG_TYPE          trigger type                   */
                  "DIRECT";
                  "INDIRECT" struct{
                    ulong;               /* TRG_FLG_ADDR      Flag for indirect trigger      */
                  };
                };

                taggedstruct {
                    ("CONFIG" struct {
                        char[256]; /* SOURCE config feature parameter */
                        char[256]; /* SOURCE config feature value */
                    })*;
                };

                taggedstruct
                { /* definition for Accumulation mode; */
                  block "ACCUMULATION_MODE" struct
                  {
                    uint;  /* SUB_SAMPLES no. of samples to be collected  */
                           /* before trigger to ETK is generated          */
                    taggedstruct
                    {
                      /* Measurement Variable size restrictions.                        */
                      /* If missing ECU supports all  for accumulated measurement.      */
                      /* Can be used multiple times to exclude different variable sizes */
                      ("DATA_TYPE_RESTRICTION" enum
                      {
                        "NO_BYTES"   = 1,  /* no byte values allowed   */
                        "NO_2BYTES"  = 2,  /* no 2 byte values allowed */
                        "NO_4BYTES"  = 3,  /* no 4 byte values allowed */
                        "NO_8BYTES"  = 4   /* no 8 byte values allowed */
                      })*;

                      /* Method for alignment of sub sample entries */
                      "SUB_SAMPLE_BUFFER_ALIGNMENT" enum
                      {
                        "_2BYTES" = 1,  /* 2 bytes */
                        "_4BYTES" = 2,  /* 4 bytes */
                        "_8BYTES" = 3   /* 8 bytes */
                      };
                    };
                  };
                };

                taggedstruct {
                  block "DISTAB_LAYOUT" struct {
                    ulong;                   /* DSPL_ADDRTBL_ADDR address of display address     */
                                             /*                   table                          */
                    uint;                    /* DSPL_ADDRTBL_MAX  maximum number of variables    */
                                             /*                   in display address table       */
                    ulong;                   /* DSPL_OUTTBL_ADDR  address of display output      */
                                             /*                   table                          */
                    uint;                    /* DSPL_OUTTBL_LEN   maximum size of display output */
                                             /*                   table in bytes                 */
                  };

                  block "BYPASS_LAYOUT" struct {
                    ulong;               /* BYPS_OUTTBL_ADDR  address of the bypass output   */
                                         /*                   table                          */
                    ulong;               /* BYPS_OUTTBL_LEN   maximum size of bypass output  */
                                         /*                   table in byte                  */
                  };

                  /* special entries to make this raster usable for 3rd party tools:       */

                  "RESERVED_RASTER_DISTAB_SETUP_XETK";  /* INCA configures the XETK raster */
                                                        /* for use with 3rd party tool     */
                                                        /* XETK sets up DISTAB             */
                  "RESERVED_RASTER_DISTAB_IGNORE_XETK"; /* INCA configures the XETK raster */
                                                        /* for use with 3rd party tool     */
                                                        /* XETK ignores DISTAB             */
                                                        /* (does not setup DISTAB)         */
                };

                taggedstruct {
                  block "ECU_PROPERTY" struct {
                    taggedstruct {
                      "PERFORMANCE" struct
                      {
                        ulong;     /* core                       */
                        ulong;     /* variables per second       */
                        ulong;     /* bytes per second           */
                      };
                      "NOT_ALLOWED_8_BITS";  /* 8 bit variables are not allowed               */
                      "NOT_ALLOWED_16_BITS"; /* 16 bit variables are not allowed              */
                      "NOT_ALLOWED_32_BITS"; /* 32 bit variables are not allowed              */
                      "NOT_ALLOWED_64_BITS"; /* 64 bit variables are not allowed              */
                    };
                  };
                };
				
                taggedstruct {
                  "ETK_XETK_REF" (ulong)*; /* references to used ETKs                        */
                };

              })*;
            };
          };
        };
      })*;
    };
  };/*******************************************************************************************/
/*                                                                                         */
/*   ASAP2 Meta description for Service Based Bypass                                       */
/*   ETAS GmbH                                                                             */
/*                                                                                         */
/*  History                                                                                */
/*  -------                                                                                */
/*  10.11.2008 Kgr (V1.0.0) first released version                                         */
/*                                                                                         */
/*  06.03.2009 Wb  (V2.0.0) provide separate array for enable / disable function execution */
/*                          this version is not compatible with version 1.0.0!             */
/*                                                                                         */
/*  22.01.2010 Wb  (V3.0.0) provide the Execution Clustering mechanism                     */
/*                          to reduce the resource consumption                             */
/*  06.05.2010 Wb           changed from EXECUTION_CLUSTER to SP_CLUSTER                   */
/*                          and SP_CLUSTER_GROUP                                           */
/*  25.08.2010 Wb           added IMPLEMENTED_SBB_VERSIONS block                           */
/*                          to separate AML and SBB version                                */
/*  26.08.2010 Wb           removed erroneous SERVICE_AML_VERSION_2_0_0 enum entry         */
/*                                                                                         */
/*  12.04.2012 Wb  (V3.1.0) replaced TRIGGER_ETK by DISTAB 17 compatible                   */
/*                              DATA_ACQUISITION and TRIGGER_CFG definitions               */
/*                          added optional HOOKED attribute to SERVICE_POINT definition    */
/*                                                                                         */
/*  23.04.2014 Thd (V3.1.1) enhanced AML definition to support SBB 2.1.0                   */
/*                              (Distab 17 on SBB V2.0)                                    */
/*                                                                                         */
/*******************************************************************************************/

"SERVICE_BASED_BYPASS" struct {

    taggedstruct {
        block "SERVICES" struct {
            enum { /* current ServiceAmlVersion */
                "SERVICE_AML_VERSION_3_1_1" = 30101
            };
            uchar;     /* BaseOffsetValue: added to the Hooked Service Point and Hooked Based Bypass signal's Offset Label Value */
                       /* 0 and 8 supported for DISTAB 13 and 16 */
                       /* 0 and 4 is supported for DISTAB 17 */
                       /* This entry will be removed in a future AML version. */
                       /* Please use BASE_OFFSET_VALUE definition in the ASAP1B_Bypass AML instead. */
            uint;      /* NumSrvPts: number of implemented Service Points */
            char[256]; /* SrvPtResId: name of the CHARACTERISTIC array */
                       /* where the resource Id incremented by 1 for each service point is stored. */
                       /* The number of the service point serves as index into this array. */
            char[256]; /* SrvPtEnabled: name of the Characteristic array which holds the enable flag for all used Service Points */
                       /* The resource ID of the service point serves as index into this array. */
            char[256]; /* TimeOutMaxPre: name of the Characteristic array which holds the maximum time out value for all used Service Points' pre-raster */
                       /* The resource ID of the service point serves as index into this array. */
            char[256]; /* TimeOutMaxPost: name of the Characteristic array which holds the maximum time out value for all used Service Points' post-raster */
                       /* The resource ID of the service point serves as index into this array. */
            enum {     /* DblBufUsed: does the DisTab utilize double buffer scheme, which may not be required */
                "DOUBLE_BUFFERING_NOT_USED" = 0x0,
                "DOUBLE_BUFFERING_USED" = 0x1       /* this is currently the only supported value */
            };
            char[256]; /* DisableFctExec: name of the CHARACTERISTIC array */
                       /* where the flag for disabling the execution of the original function of the Service Point is defined. */
                       /* The number of the service point serves as index into this array. */
            taggedstruct {
                block "IMPLEMENTED_SBB_VERSIONS" taggedstruct  {
                    /* Select the subset of SBB versions, which the ECU implements. It is mandatory to define at least one version. */
                    "SBB_V2_0"; /* supported with DISTAB 13/16 */
                    "SBB_V2_1"; /* supported with DISTAB 17 */
                    "SBB_V3_0"; /* supported with DISTAB 13/16 */
                    "SBB_V3_1"; /* supported with DISTAB 17 */
                };
            };

            taggedstruct {
                "RESOURCE_IDS_SERVICE_POINT" char[256]; /* ResIdSrvPt: optional name of the CHARACTERISTIC array */
            };                                          /* where the service point number for each */
                                                        /* resource ID is stored. This is the reverse table of SERVICE_POINTS_RESOURCE_ID */
                                                        /* and serves as lookup table for Measurement&Calibration applications. */

            taggedstruct { /* List of service points provided by the ECU */
                (block "SERVICE_POINT" struct {
                    int;                                /* Number: Service Point's number; counted from 1 */
                    char[256];                          /* Name: Service Point's name */
                    taggedstruct {
                        "PRIORITY" uint;                /* service point priority: a number 0..0xFFFF defining the priority of this service point to be taken into account when assigning trigger ressources. The higher the number, the higher the priority. High priority service point will be triggered by high priority triggers. */
                        "SP_CLUSTER" uint;              /* service point cluster: all service points with the same number here are assumed to be executed with the same priority in the ECU and with other priority than all other service points. This enables automatic optimizations allocating resources to this service point. The higher the number, the higher the priority of the cluster.*/
                                                        /* number range 0..0xFFFF */
                                                        /* only relevant from SBB_V3_0 on*/
                        "SP_CLUSTER_GROUP" uint;        /* service point cluster group: all service points with the same number here are assumed to be executed concurrently in the ECU and all other service points can not interfere with these from this group. This enables automatic optimizations allocating resources to this service point. */
                                                        /* number range 0..0xFFFF */
                                                        /* only relevant from SBB_V3_0 on*/
                        "HOOKED";                       /* If defined, the ECU has implemented hooked MEASUREMENTs for this service point. */
                                                        /* Can be used for SBB_V2_1 and from SBB_V3_1 on. */
                    };
                })*;
            };

            taggedstruct { /* Future versions may also provide SBB_PRECONFIGURED_STRUCTURE; it is possible, that an ECU implements multiple modes. */
                "SBB_DYNAMIC_STRUCTURE" struct {								
                    uint;       /* SBBDynStrucVer: SBB dynamic structure version is independent from SERVICE_VERSION_X_Y */
                                /* with DISTAB 13/16 only version 1 is supported */
                                /* with DISTAB 17 only version 2 is supported */
                    ulong;      /* ResWorkArea: resource working area address, where resource blocks and address and data tables are allocated. Located e.g. in ETK FLASH for all ETK types  */
                    ulong;      /* ResWorkAreaLength: length of the resource working area in bytes */
                    ulong;      /* EcuWrtblResWorkArea: where RAM resource blocks and data tables are allocated. Located e.g. in ETK RAM for parallel ETKs and ECU RAM for serial ETKs */
                    ulong;      /* EcuWrtblResWorkAreaLength: length of the ECU writable resource working area in bytes */

                    /* List of triggers provided by the ECU for services */
                    taggedunion {
                        /* this variant has to be used for DISTAB 13, i.e. SBB V2 and V3.0 */
                        block "TRIGGER_COMBINED_WITH_CHANNEL" taggedstruct {
                            (block "TRIGGER_ETK" struct {
                                uint;         /* TRG_NBR: the number of the hardware trigger (1..32) */
                                uint;         /* RSTR_PRIO: raster priority (1..32), higher number = higher priority */
                                taggedunion { /* TRG_TYPE: trigger type */
                                    "DIRECT";
                                    "INDIRECT";
                                };
                                taggedstruct {
                                  "ETK_XETK_REF" (ulong)*; /* reference to ETKs if used together with an ETK_XETK AML*/
                                };
                            })*;
                        };

                        /* this variant has to be used from DISTAB 17 on, i.e. for SBB_V2_1 and from SBB_V3_1 on */
                        block "TRIGGER_SEPARATED_FROM_CHANNEL" taggedstruct {
                            (block "TRIGGER_CFG" struct {
                                taggedstruct {
                                    ("TRIGGER" struct {
                                        ulong;        /* TRG_NBR: the number of the hardware trigger (1..32) */
                                        taggedunion { /* TRG_TYPE: trigger type */
                                            "DIRECT";
                                            "INDIRECT";
                                        };
                                        taggedstruct {
                                            "ECU_ID" struct {
                                                uint; /* ECU_ID, optional, to be used to define the trigger for the ECU driver (0..0xFFFF) */
                                            };
                                        };
                                    })*;
                                    "ETK_XETK_REF" (ulong)*; /* references to used ETKs if used together with an ETK_XETK AML */  
                                };
                            })*;

                            /* List of data acquisition channels provided by the ECU for services */
                            (block "DATA_ACQUISITION" struct {
                                taggedstruct {
                                    ("PRIORITY_RANGE" struct {
                                        ulong;  /* first priority (1..32), higher number = higher priority */
                                        ulong;  /* last priority  (1..32), higher number = higher priority */
                                                /* first priority <= last priority                         */
                                    })*;
                                    "ETK_XETK_REF" (ulong)*; /* references to used ETKs if used together with an ETK_XETK AML */  
                                };
                            })*;
                        };
                    };
                };
            };
        };
    };
};

/************* start of XCP on different Transport Layers *******************/

  "XCPplus" struct {
    uint;
    taggedstruct Common_Parameters ; /* default parameters */
  
    taggedstruct { /* transport layer specific parameters  */
                   /* overruling of the default parameters */
  
      (block "XCP_ON_CAN" struct {
  
        struct CAN_Parameters ;                   /* specific for CAN      */
        taggedstruct Common_Parameters;           /* overruling of default */
        taggedstruct {
          "TRANSPORT_LAYER_INSTANCE" char[101];
        };   
  
      })*;
  
      (block "XCP_ON_TCP_IP" struct {
  
        struct TCP_IP_Parameters ;                /* specific for TCP_IP   */
        taggedstruct Common_Parameters;           /* overruling of default */
        taggedstruct {
          "TRANSPORT_LAYER_INSTANCE" char[101];
        };
  
      })*;
  
      (block "XCP_ON_UDP_IP" struct {
  
        struct UDP_IP_Parameters ;                /* specific for UDP      */
        taggedstruct Common_Parameters;           /* overruling of default */
        taggedstruct {
          "TRANSPORT_LAYER_INSTANCE" char[101];
        };
  
      })*;
  
      (block "XCP_ON_FLX" struct {
  
        struct FLX_Parameters ;                   /* specific for FLX      */
        taggedstruct Common_Parameters;           /* overruling of default */
        taggedstruct {
          "TRANSPORT_LAYER_INSTANCE" char[101];
        };
  
      })*;
  
    };
  
  };
  
/************* end of XCP on different Transport Layers ********************/


    }; 
  /end A2ML

  /begin MOD_PAR "RC40_LARGE_IFX4_BSW2003_40NM"
    VERSION "V01_28"
    ADDR_EPK 0x80800228
    EPK "54/1/RC27_18/0/RC40_LARGE_IFX4_BSW2003_40NM//V01_28///"
    CUSTOMER_NO "0"
    USER "APPLICATOR"
    PHONE_NO ""
    ECU "RC27_18"
    CPU_TYPE "IFX"
    /begin MEMORY_SEGMENT Pst80000000 "" RESERVED FLASH INTERN 0x80000000 0x20 -1 -1 -1 -1 -1 


  
     /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80000020 "" RESERVED FLASH INTERN 0x80000020 0xFFE0 -1 -1 -1 -1 -1 


  
     /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80070000 "" RESERVED FLASH INTERN 0x80070000 0x50000 -1 -1 -1 -1 -1 


  
     /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst800C0000 "" CODE FLASH INTERN 0x800C0000 0x73F400 -1 -1 -1 -1 -1 

       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA



        /begin IF_DATA XCPplus 0x0102
          /begin SEGMENT
            7       /* segment logical number */
            0x01       /* number of pages */
            0x00       /* address extension */
            0x00       /* compression method */
            0x00       /* encryption method */
            /begin CHECKSUM
                XCP_CRC_32 /* checksum: add bytes to 16bit result */
                MAX_BLOCK_SIZE 0xFFFFFFFF
            /end CHECKSUM

            /begin PAGE
              0x00       /* page number */
              ECU_ACCESS_WITH_XCP_ONLY
              XCP_READ_ACCESS_WITH_ECU_ONLY
              XCP_WRITE_ACCESS_NOT_ALLOWED
            /end PAGE
          /end SEGMENT
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst807FF400 "" RESERVED FLASH INTERN 0x807FF400 0xA20 -1 -1 -1 -1 -1 


  
     /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80809620 "" RESERVED FLASH INTERN 0x80809620 0x169E0 -1 -1 -1 -1 -1 


      /begin IF_DATA ETK_XETK
           WRITE_AT_DATA_UPDATE USE_FILE
       ETK_XETK_REF 1 2 3 4 5 7 8
       /end IF_DATA
  
     /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80900000 "" RESERVED FLASH INTERN 0x80900000 0xFC000 -1 -1 -1 -1 -1 


  
     /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst809FC000 "" RESERVED FLASH INTERN 0x809FC000 0x4000 -1 -1 -1 -1 -1 


  
     /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Dst80800000 "" DATA FLASH INTERN 0x80800000 0x9620 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA




        /begin IF_DATA XCPplus 0x0102
          /begin SEGMENT
            8       /* segment logical number */
            0x02       /* number of pages */
            0x00       /* address extension */
            0x00       /* compression method */
            0x00       /* encryption method */
            /begin CHECKSUM
                XCP_CRC_32 /* checksum: add bytes to 16bit result */
                MAX_BLOCK_SIZE 0xFFFFFFFF
            /end CHECKSUM

            /begin PAGE
              0x00       /* page number */
              ECU_ACCESS_DONT_CARE
              XCP_READ_ACCESS_DONT_CARE
              XCP_WRITE_ACCESS_NOT_ALLOWED
            /end PAGE
            /begin PAGE
              0x01       /* page number */
              ECU_ACCESS_DONT_CARE
              XCP_READ_ACCESS_DONT_CARE
              XCP_WRITE_ACCESS_WITH_ECU_ONLY
            /end PAGE
          /end SEGMENT
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamF0138000 "" VARIABLES RAM INTERN 0xF0138000 0x2FFD -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            0       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamF0140000 "" VARIABLES RAM INTERN 0xF0140000 0x2FFD -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            1       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamF0148000 "" VARIABLES RAM INTERN 0xF0148000 0x2FFD -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            2       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamF0150000 "" VARIABLES RAM INTERN 0xF0150000 0x2FFD -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            3       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamF0158000 "" VARIABLES RAM INTERN 0xF0158000 0x2FFD -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            4       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamF0160000 "" VARIABLES RAM INTERN 0xF0160000 0x2FFD -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            5       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamF0168000 "" VARIABLES RAM INTERN 0xF0168000 0x2FFD -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            6       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamAFE00000 "" VARIABLES RAM INTERN 0xAFE00000 0x80000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            9       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamB0040000 "" VARIABLES RAM INTERN 0xB0040000 0x20000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            10       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamB0060000 "" VARIABLES RAM INTERN 0xB0060000 0x20000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            11       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Ram70100000 "" VARIABLES RAM INTERN 0x70100000 0x10000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            12       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Ram60100000 "" VARIABLES RAM INTERN 0x60100000 0x10000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            13       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Ram50100000 "" VARIABLES RAM INTERN 0x50100000 0x10000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            14       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Ram40100000 "" VARIABLES RAM INTERN 0x40100000 0x10000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            15       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Ram70000000 "" VARIABLES RAM INTERN 0x70000000 0x3C000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            16       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Ram60000000 "" VARIABLES RAM INTERN 0x60000000 0x3C000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            17       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Ram50000000 "" VARIABLES RAM INTERN 0x50000000 0x18000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            18       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Ram40000000 "" VARIABLES RAM INTERN 0x40000000 0x18000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            19       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamB0000000 "" VARIABLES RAM INTERN 0xB0000000 0x10000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            20       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamB0010000 "" VARIABLES RAM INTERN 0xB0010000 0x10000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            21       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamB0020000 "" VARIABLES RAM INTERN 0xB0020000 0x10000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            22       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamB0030000 "" VARIABLES RAM INTERN 0xB0030000 0x10000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            23       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamB0400000 "" VARIABLES RAM INTERN 0xB0400000 0x10000 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            24       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamB93F09B8 "" VARIABLES RAM INTERN 0xB93F09B8 0xF648 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            25       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamB93E0000 "" CALIBRATION_VARIABLES RAM INTERN 0xB93E0000 0x109B8 -1 -1 -1 -1 -1 
       /begin IF_DATA ETK_XETK
           /begin ETK_XETK_ACCESS
              SERIAL_INTERFACE
           /end ETK_XETK_ACCESS
       /end IF_DATA
      /begin IF_DATA XCPplus 0x0102
        /begin SEGMENT
            26       /* segment logical number */
          0x00       /* number of pages        */
          0x00       /* address extension      */
          0x00       /* compression method     */
          0x00       /* encryption method      */
        /end SEGMENT
      /end IF_DATA
    /end MEMORY_SEGMENT

    /begin CALIBRATION_METHOD
      /* name calibration methode         */ "DataSetId"
      /* version calibration metode       */ 256
      /begin CALIBRATION_HANDLE
        /* adr data set id characteristic */ 0x808090A4
      /end CALIBRATION_HANDLE
    /end CALIBRATION_METHOD

    /begin CALIBRATION_METHOD
      /* Method name              */    "FixedSizeMoveableEmuRAM"
      /* Method version           */    1

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    0
        /* Original RAM Address   */    0xB9000000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    1
        /* Original RAM Address   */    0xB9020000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    2
        /* Original RAM Address   */    0xB9040000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    3
        /* Original RAM Address   */    0xB9060000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    4
        /* Original RAM Address   */    0xB9080000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    5
        /* Original RAM Address   */    0xB90A0000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    6
        /* Original RAM Address   */    0xB90C0000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    7
        /* Original RAM Address   */    0xB90E0000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    8
        /* Original RAM Address   */    0xB9100000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    9
        /* Original RAM Address   */    0xB9120000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    10
        /* Original RAM Address   */    0xB9140000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    11
        /* Original RAM Address   */    0xB9160000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    12
        /* Original RAM Address   */    0xB9180000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    13
        /* Original RAM Address   */    0xB91A0000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    14
        /* Original RAM Address   */    0xB91C0000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    15
        /* Original RAM Address   */    0xB91E0000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    16
        /* Original RAM Address   */    0xB9200000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    17
        /* Original RAM Address   */    0xB9220000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    18
        /* Original RAM Address   */    0xB9240000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    19
        /* Original RAM Address   */    0xB9260000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    20
        /* Original RAM Address   */    0xB9280000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    21
        /* Original RAM Address   */    0xB92A0000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    22
        /* Original RAM Address   */    0xB92C0000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    23
        /* Original RAM Address   */    0xB92E0000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    24
        /* Original RAM Address   */    0xB9300000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    25
        /* Original RAM Address   */    0xB9320000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    26
        /* Original RAM Address   */    0xB9340000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    27
        /* Original RAM Address   */    0xB9360000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    28
        /* Original RAM Address   */    0xB9380000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    29
        /* Original RAM Address   */    0xB93A0000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    30
        /* Original RAM Address   */    0xB93C0000
        /* Page size              */    0x20000
      /end CALIBRATION_HANDLE
    /end CALIBRATION_METHOD

    /begin CALIBRATION_METHOD
      /* Method name              */    "EmuNonVolatileRam"
      /* Method version           */    1
      /begin CALIBRATION_HANDLE
        /* ENV RAM start address */          0x60036DF8
        /* ENV RAM size */                   0x2000
      /end CALIBRATION_HANDLE
    /end CALIBRATION_METHOD



    SYSTEM_CONSTANT "ACCHI_RES" "0.0001"
    SYSTEM_CONSTANT "ACCHRGRINTKT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "ACCPED_VEL_INTPOL" "1"
    SYSTEM_CONSTANT "ACCPED_VN_INTPOL" "0"
    SYSTEM_CONSTANT "ACTRLIB_IINITSPEZIAL_SY" "0"
    SYSTEM_CONSTANT "ACTRPWRSTGDRVR_SWTCONF_DIGOUT_BP" "3"
    SYSTEM_CONSTANT "ACTRPWRSTGDRVR_SWTCONF_ENA_BP" "0"
    SYSTEM_CONSTANT "ACTRPWRSTGDRVR_SWTCONF_HALFBRDGOUT_BP" "1"
    SYSTEM_CONSTANT "ACTRPWRSTGDRVR_SWTCONF_PWMOUT_BP" "2"
    SYSTEM_CONSTANT "ACTRPWRSTGDRVR_SWTCONF_PWMPINSHARE_BP" "4"
    SYSTEM_CONSTANT "ACTR_ACTVN_RPM_BP" "0"
    SYSTEM_CONSTANT "ACTR_ACTVN_T15_BP" "1"
    SYSTEM_CONSTANT "ACTR_DEACTVN_AFTPREDRVNWM_BP" "2"
    SYSTEM_CONSTANT "ACTR_DEACTVN_ENGOFFSAIL_BP" "3"
    SYSTEM_CONSTANT "ACTR_DEACTVN_PWRSTGENACOND_BP" "5"
    SYSTEM_CONSTANT "ACTR_DEACTVN_SHOFFCTRLDNE_BP" "0"
    SYSTEM_CONSTANT "ACTR_DEACTVN_SPST_BP" "1"
    SYSTEM_CONSTANT "ACTR_DEACTVN_TERMINALENGOFF_BP" "4"
    SYSTEM_CONSTANT "ACTYP_MECHELEC" "4"
    SYSTEM_CONSTANT "ADDHTR_CONST" "360"
    SYSTEM_CONSTANT "ADDLEONV_SC" "0"
    SYSTEM_CONSTANT "AFSP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "AFST_SY" "0"
    SYSTEM_CONSTANT "AFST_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "AIRCTL_NUMBUFDDTEGRLPPOS" "26"
    SYSTEM_CONSTANT "AIRHUMT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "AIRMASS_2_RES_REV" "10"
    SYSTEM_CONSTANT "AIRMSPRTIMEQ0P0003_RES" "0.0003"
    SYSTEM_CONSTANT "AIRMSQ0P1_RES" "0.1"
    SYSTEM_CONSTANT "AIRMSQ0P1_RES_REV" "10"
    SYSTEM_CONSTANT "AIRPIN_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "AIRPOUT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "AIRSYS_AREAEFFONE" "1"
    SYSTEM_CONSTANT "AIRSYS_AREAEFFONE_SY" "1"
    SYSTEM_CONSTANT "AIRSYS_MINDEADTIME_SY" "1"
    SYSTEM_CONSTANT "AIRSYS_TEMPTHRPST" "300"
    SYSTEM_CONSTANT "AIRSYS_TEMPTHRPST_SY" "300"
    SYSTEM_CONSTANT "AIRTIN_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "AIRTOUT_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "ALTCRNT_LIM_RES" "0.25"
    SYSTEM_CONSTANT "ALTCRNT_OUT_RES" "0.125"
    SYSTEM_CONSTANT "ALTLD_RES" "3.125"
    SYSTEM_CONSTANT "ALTVLTG_OFS" "10.6"
    SYSTEM_CONSTANT "ALTVLTG_RES_SY" "0.1"
    SYSTEM_CONSTANT "ALT_CHPTEMP_OFS" "-32"
    SYSTEM_CONSTANT "ALT_CHPTEMP_RES" "8"
    SYSTEM_CONSTANT "AMPC_RES_REV" "10"
    SYSTEM_CONSTANT "AMPT_NOXLDUNLD_RES" "0.0001"
    SYSTEM_CONSTANT "AMPT_NOXLDUNLD_RES_REV" "10000"
    SYSTEM_CONSTANT "AMPT_NOXRGN_MIN" "0"
    SYSTEM_CONSTANT "AMPT_NOXRGN_RES" "0.0005"
    SYSTEM_CONSTANT "AMPT_NOXRGN_RES_REV" "2000"
    SYSTEM_CONSTANT "AMPT_NOX_RES" "1e-005"
    SYSTEM_CONSTANT "AMPT_NOX_RES_REV" "100000"
    SYSTEM_CONSTANT "AMPT_RES_2" "3.2e-005"
    SYSTEM_CONSTANT "AMPT_RES_2_REV" "31250"
    SYSTEM_CONSTANT "AMPT_SOX1_MIN" "0"
    SYSTEM_CONSTANT "AMPT_SOX1_RES" "0.003"
    SYSTEM_CONSTANT "ARBLD_SC" "1"
    SYSTEM_CONSTANT "ARVERS_SC" "2"
    SYSTEM_CONSTANT "ASMOD_FACRSTOICH" "14.5"
    SYSTEM_CONSTANT "ASMOD_HTFLW_RES" "2"
    SYSTEM_CONSTANT "ASMOD_NUMEOMCOEMI_SY" "3"
    SYSTEM_CONSTANT "ASMOD_PHC" "3"
    SYSTEM_CONSTANT "ASMOD_QLMBD" "100"
    SYSTEM_CONSTANT "ASMOD_RGN" "4"
    SYSTEM_CONSTANT "ASMOD_RM" "2"
    SYSTEM_CONSTANT "ATS_BRK_APP_SC" "0"
    SYSTEM_CONSTANT "ATS_ENGSPDMON_SUPPORT" "1"
    SYSTEM_CONSTANT "ATS_RCCACT_SC" "0"
    SYSTEM_CONSTANT "ATS_RCCSUPPORT" "0"
    SYSTEM_CONSTANT "ATS_SPCTMR_SC" "0"
    SYSTEM_CONSTANT "BASEMAP_INTRPNFAC_FIVE" "5"
    SYSTEM_CONSTANT "BASEMAP_INTRPNFAC_SIX" "6"
    SYSTEM_CONSTANT "BRKBSTP2_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "BRKBSTP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "BSWLIB_TRAPLOG_SC" "0"
    SYSTEM_CONSTANT "BSW_GENN_SC" "0"
    SYSTEM_CONSTANT "BYPASS_SY" "1"
    SYSTEM_CONSTANT "CACDSPLP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CACDSP_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CACDSTLP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CACDST_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CACUSP_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CACUST_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CALORIFIC_VALUE" "42.5"
    SYSTEM_CONSTANT "CALORY_RES_REV" "1"
    SYSTEM_CONSTANT "CALWUP_SY" "1"
    SYSTEM_CONSTANT "CAMLIFT_RES_REV" "256"
    SYSTEM_CONSTANT "CAMPAR_A_RES_REV" "1024"
    SYSTEM_CONSTANT "CAMSFT_ACTRINTKB2_SC" "0"
    SYSTEM_CONSTANT "CAMSFT_ACTROUTLB2_SC" "0"
    SYSTEM_CONSTANT "CAMSFT_ADPNCLB_SC" "0"
    SYSTEM_CONSTANT "CAMSFT_LOCKDIAGINTK_SC" "0"
    SYSTEM_CONSTANT "CAMSFT_LOCKDIAGOUTL_SC" "0"
    SYSTEM_CONSTANT "CAMSFT_VARIINTK_SC" "2"
    SYSTEM_CONSTANT "CAMSFT_VARIOUTL_SC" "2"
    SYSTEM_CONSTANT "CAMSLP_RES_REV" "1024"
    SYSTEM_CONSTANT "CANIPCORETYPE_SC" "0"
    SYSTEM_CONSTANT "CANNM_SC" "1"
    SYSTEM_CONSTANT "CANSM_SC" "1"
    SYSTEM_CONSTANT "CANTP_SC" "1"
    SYSTEM_CONSTANT "CANTSYN_SC" "0"
    SYSTEM_CONSTANT "CAN_MDS_SC" "0"
    SYSTEM_CONSTANT "CARBMDLYR19UPD2016_SC" "0"
    SYSTEM_CONSTANT "CASI1_SSP_SY" "0"
    SYSTEM_CONSTANT "CASI2_SSP_SY" "0"
    SYSTEM_CONSTANT "CASO1_SSP_SY" "0"
    SYSTEM_CONSTANT "CASO2_SSP_SY" "0"
    SYSTEM_CONSTANT "CASTYP_SY" "6"
    SYSTEM_CONSTANT "CAS_ADAP_SY" "1"
    SYSTEM_CONSTANT "CAS_ANGLE_SY" "1"
    SYSTEM_CONSTANT "CAS_BACKUPVAR_SY" "0"
    SYSTEM_CONSTANT "CAS_BACKUP_SY" "1"
    SYSTEM_CONSTANT "CAS_CY30CONF_SY" "0"
    SYSTEM_CONSTANT "CAS_DIAG_SY" "0"
    SYSTEM_CONSTANT "CAS_I1_SY" "1"
    SYSTEM_CONSTANT "CAS_I2_SY" "0"
    SYSTEM_CONSTANT "CAS_MAX" "2"
    SYSTEM_CONSTANT "CAS_O1_SY" "0"
    SYSTEM_CONSTANT "CAS_O2_SY" "0"
    SYSTEM_CONSTANT "CCACHPDST_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CCACLPDST_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CDGEN_ENV_SC" "2"
    SYSTEM_CONSTANT "CELPRJ_SIMPLEMDLENA_SC" "1"
    SYSTEM_CONSTANT "CENGDST_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CENGUST2_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CENGUST_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CHDT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CHRCTL_EIAECD_SY" "0"
    SYSTEM_CONSTANT "CJ721_SC" "0"
    SYSTEM_CONSTANT "CJ722_SC" "0"
    SYSTEM_CONSTANT "CJ950_SY" "0"
    SYSTEM_CONSTANT "CJ960_SC" "0"
    SYSTEM_CONSTANT "CJ970_SC" "0"
    SYSTEM_CONSTANT "CMBTYP_DS" "0"
    SYSTEM_CONSTANT "CMBTYP_GS" "1"
    SYSTEM_CONSTANT "CMBTYP_SY" "0"
    SYSTEM_CONSTANT "CMPRHP2DST_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CNVTCOEFFCATAIR_RES_REV" "50"
    SYSTEM_CONSTANT "COENG_FINISH" "5"
    SYSTEM_CONSTANT "COENG_ST_AUTOSTOPPING" "64"
    SYSTEM_CONSTANT "COENG_ST_FINISH" "16384"
    SYSTEM_CONSTANT "COENG_ST_READY" "4"
    SYSTEM_CONSTANT "COENG_ST_RUNNING" "1024"
    SYSTEM_CONSTANT "COENG_ST_STANDBY" "0"
    SYSTEM_CONSTANT "COENG_ST_STARTING" "16"
    SYSTEM_CONSTANT "COENG_ST_STOPPING" "4096"
    SYSTEM_CONSTANT "COEOM_INJCRVMI1NUMMAP_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVMI1NUMSWTDES_SY" "1"
    SYSTEM_CONSTANT "COEOM_INJCRVMI1NUMSWTMAX_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVMI1NUMSWTSET_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPII1NUMMAP_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPII1NUMSWTDES_SY" "1"
    SYSTEM_CONSTANT "COEOM_INJCRVPII1NUMSWTMAX_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPII1NUMSWTSET_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPII2NUMMAP_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPII2NUMSWTDES_SY" "1"
    SYSTEM_CONSTANT "COEOM_INJCRVPII2NUMSWTMAX_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPII2NUMSWTSET_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI1NUMMAP_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI1NUMSWTDES_SY" "1"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI1NUMSWTMAX_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI1NUMSWTSET_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI2NUMMAP_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI2NUMSWTDES_SY" "1"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI2NUMSWTMAX_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI2NUMSWTSET_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI3NUMMAP_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI3NUMSWTDES_SY" "1"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI3NUMSWTMAX_SY" "0"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI3NUMSWTSET_SY" "0"
    SYSTEM_CONSTANT "COEOM_TYP_SY" "1"
    SYSTEM_CONSTANT "COMDIA_RTEENA_SC" "1"
    SYSTEM_CONSTANT "COMM_SC" "1"
    SYSTEM_CONSTANT "COMPACCPED_ON" "1"
    SYSTEM_CONSTANT "COMPACCPED_SY" "0"
    SYSTEM_CONSTANT "COMVERS_SC" "0"
    SYSTEM_CONSTANT "COM_ENADTCINFO_SC" "0"
    SYSTEM_CONSTANT "COM_SC" "1"
    SYSTEM_CONSTANT "CONDRDSFLDP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CONDRDSFLDT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CONDRUSCOOLTT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CONDRUSFLDT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CONV_MGS2KGS" "1000000"
    SYSTEM_CONSTANT "COOLTPIN_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "COOLTPOUT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "COOLTTIN_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "COOLTTOUT_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "COOLTTRADROUT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CPUDEVICE_SC" "14"
    SYSTEM_CONSTANT "CPUVENDOR_SC" "1"
    SYSTEM_CONSTANT "CRCSP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CRKCSPABSLT_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CRSSENSTYP_SY" "1"
    SYSTEM_CONSTANT "CRSTYP_SY" "0"
    SYSTEM_CONSTANT "CRS_ANGLECOR_SY" "0"
    SYSTEM_CONSTANT "CRS_BACKUP_CASTYP_SY" "1"
    SYSTEM_CONSTANT "CRS_BACKUP_DYN_SY" "0"
    SYSTEM_CONSTANT "CRS_BACKUP_SY" "2"
    SYSTEM_CONSTANT "CRS_CY30CONF_SY" "0"
    SYSTEM_CONSTANT "CRS_DIAG_DETAIL_SY" "0"
    SYSTEM_CONSTANT "CRS_DIAG_SYNCINJLOST_SY" "0"
    SYSTEM_CONSTANT "CRS_MIAP_SY" "0"
    SYSTEM_CONSTANT "CRS_SSP_SY" "0"
    SYSTEM_CONSTANT "CRS_TAA_SY" "0"
    SYSTEM_CONSTANT "CRS_TOOTHAVRG_SY" "0"
    SYSTEM_CONSTANT "CRYPTOLIB_SC" "0"
    SYSTEM_CONSTANT "CTEGRCLRDS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CTEGRCLRLPUS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CTEGRCLRUS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CTEVCHRGRDS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CTEVEMDS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CTEVHTRDS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CTEVHTREXCHGDS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CTEVHTRUS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "CTEVINVRUS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CTEVLEDS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "CURR_RES" "1"
    SYSTEM_CONSTANT "CVN_USE_DATA" "1"
    SYSTEM_CONSTANT "CVN_USE_EEP" "0"
    SYSTEM_CONSTANT "CVN_USE_ENVRAM" "1"
    SYSTEM_CONSTANT "CVN_USE_MEM" "1"
    SYSTEM_CONSTANT "CY326_SC" "1"
    SYSTEM_CONSTANT "CY327_SY" "0"
    SYSTEM_CONSTANT "CY329_SC" "0"
    SYSTEM_CONSTANT "CYL_MAX" "4"
    SYSTEM_CONSTANT "DCCHRGRINTKT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "DCS_OVRDS_ENGPRT" "1"
    SYSTEM_CONSTANT "DDRC_DTRFRZINFHEALDEB_SY" "1"
    SYSTEM_CONSTANT "DDRC_DTRUPDSUP_SY" "0"
    SYSTEM_CONSTANT "DDRC_NUM_DFC_EVTROW" "0"
    SYSTEM_CONSTANT "DDRC_NUM_DFC_EVTROW_SML" "0"
    SYSTEM_CONSTANT "DDRC_NUM_DFC_EVTUD" "0"
    SYSTEM_CONSTANT "DDRC_NUM_DFC_EVTUD_SML" "0"
    SYSTEM_CONSTANT "DDRC_NUM_DFC_TIROW" "103"
    SYSTEM_CONSTANT "DDRC_NUM_DFC_TIROW_SML" "0"
    SYSTEM_CONSTANT "DDRC_NUM_DFC_TIUD" "616"
    SYSTEM_CONSTANT "DDRC_NUM_DFC_TIUD_SML" "0"
    SYSTEM_CONSTANT "DDRC_STENAMON_SIZE" "145"
    SYSTEM_CONSTANT "DDVOL_RES" "10"
    SYSTEM_CONSTANT "DEDIA_DBG_SC" "1"
    SYSTEM_CONSTANT "DEDIA_VRNTCONF_SY" "0"
    SYSTEM_CONSTANT "DELIB_CMN_STMONACTRCOORRSIMPLE_ATSACTV_BP" "0"
    SYSTEM_CONSTANT "DELIB_CMN_STMONACTRCOORRSIMPLE_ATSINTVALLWD_BP" "1"
    SYSTEM_CONSTANT "DELIB_CMN_STMONACTRELECDRVRSIMPLE_ATSINTVALLWD_BP" "1"
    SYSTEM_CONSTANT "DELIB_CMN_STMONACTRELECDRVRSIMPLE_PSACTVN_BP" "0"
    SYSTEM_CONSTANT "DELIB_CMN_STMONVRNTCODSIMPLE_FULLDEACTV_BP" "0"
    SYSTEM_CONSTANT "DELIB_CMN_STMONVRNTCODSIMPLE_OLDEACTV_BP" "1"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRCOORRSIMPLE_ENA_BP" "0"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRCOORRSIMPLE_SIGINV_BP" "1"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRELECDRVRSIMPLE_ENA_BP" "0"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRELECMONSIMPLE_DIAGTESTPLSDI_BP" "3"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRELECMONSIMPLE_DIGMON_BP" "2"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRELECMONSIMPLE_ENA_BP" "0"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRELECMONSIMPLE_PWMMON_BP" "1"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRHLDILIMNSIMPLE_ENA_BP" "0"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRPSDRVRSIMPLE_BATTCORRN_BP" "3"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRPSDRVRSIMPLE_DIGOUT_BP" "2"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRPSDRVRSIMPLE_ENA_BP" "0"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFACTRPSDRVRSIMPLE_PWMOUT_BP" "1"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFFIR_ENA_BP" "0"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFPLL_ENA_BP" "0"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFPLL_HEMENA_BP" "1"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFVRNTCODSIMPLE_FULLDEACTV_BP" "0"
    SYSTEM_CONSTANT "DELIB_CMN_SWTCONFVRNTCODSIMPLE_OLDEACTV_BP" "1"
    SYSTEM_CONSTANT "DELIB_DBG_SC" "0"
    SYSTEM_CONSTANT "DELIB_DEVDRVROUTPDUTYCYCRAMP_ENA_BP" "0"
    SYSTEM_CONSTANT "DELIB_DSQACTVT_SC" "0"
    SYSTEM_CONSTANT "DELIB_DYNSDLDEACTV_SC" "0"
    SYSTEM_CONSTANT "DELIB_ELECACTRTYPAVL_SC" "1"
    SYSTEM_CONSTANT "DELIB_ELECACTR_STMONELECDIAG_IBASDOLTESTRATACTV_BP" "4"
    SYSTEM_CONSTANT "DELIB_ENGDATENG_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "DELIB_FACPRECTLDWNTEMPCORRSIZECUR_SC" "2"
    SYSTEM_CONSTANT "DELIB_FACPRECTLUPTEMPCORRSIZECUR_SC" "2"
    SYSTEM_CONSTANT "DELIB_FACTQLOSSCMPSIZECUR_SC" "2"
    SYSTEM_CONSTANT "DELIB_GLBSRVGRDTLIMN_SWTCONF_ENABLE_BP" "0"
    SYSTEM_CONSTANT "DELIB_GLBSRVGRDTLIMN_SWTCONF_TSTRACTV_BP" "1"
    SYSTEM_CONSTANT "DELIB_GLBSRVSPFIL_SWTCONF_ENABLE_BP" "0"
    SYSTEM_CONSTANT "DELIB_HVDDC_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "DELIB_MDLEXHSNSRAVL_SC" "0"
    SYSTEM_CONSTANT "DELIB_PMINLRNSIZECUR_SC" "2"
    SYSTEM_CONSTANT "DELIB_RACTRLIM2SIZECUR_SC" "2"
    SYSTEM_CONSTANT "DELIB_RACTRLIMSIZECUR_SC" "2"
    SYSTEM_CONSTANT "DELIB_RDIAVALMINSIZECUR_SC" "2"
    SYSTEM_CONSTANT "DELIB_RPRECTLDWNMAINMAPSIZEX_SC" "2"
    SYSTEM_CONSTANT "DELIB_RPRECTLDWNMAINMAPSIZEY_SC" "2"
    SYSTEM_CONSTANT "DELIB_RPRECTLDWNMAPSIZEX_SC" "2"
    SYSTEM_CONSTANT "DELIB_RPRECTLDWNMAPSIZEY_SC" "2"
    SYSTEM_CONSTANT "DELIB_RPRECTLUPMAINMAPSIZEX_SC" "2"
    SYSTEM_CONSTANT "DELIB_RPRECTLUPMAINMAPSIZEY_SC" "2"
    SYSTEM_CONSTANT "DELIB_RPRECTLUPMAPSIZEX_SC" "2"
    SYSTEM_CONSTANT "DELIB_RPRECTLUPMAPSIZEY_SC" "2"
    SYSTEM_CONSTANT "DELIB_RPSMAXMAPSIZEX_SC" "2"
    SYSTEM_CONSTANT "DELIB_RPSMAXMAPSIZEY_SC" "2"
    SYSTEM_CONSTANT "DELIB_SENTCALULINSIZECUR_SC" "2"
    SYSTEM_CONSTANT "DELIB_SENT_SNSRERR_BP" "2"
    SYSTEM_CONSTANT "DELIB_SIMPLESWTAVL_SC" "0"
    SYSTEM_CONSTANT "DELIB_STCFCTACTR_ENA_BP" "0"
    SYSTEM_CONSTANT "DELIB_STCFCTACTR_FILDIR_BP" "2"
    SYSTEM_CONSTANT "DELIB_STCFCTACTR_TRLPTRDIR_BP" "1"
    SYSTEM_CONSTANT "DELIB_STDACTRTYPAVL_SC" "1"
    SYSTEM_CONSTANT "DELIB_STDACTRVDMON_DIGPWRSTGDIAG_FIRSTTMRCYC" "1"
    SYSTEM_CONSTANT "DELIB_STDACTRVDMON_DIGPWRSTGDIAG_SECTMRCYC" "2"
    SYSTEM_CONSTANT "DELIB_STDACTRVDMON_DIGPWRSTGDIAG_START" "0"
    SYSTEM_CONSTANT "DELIB_STDACTRVDMON_DIGPWRSTGDIAG_WAIT" "3"
    SYSTEM_CONSTANT "DELIB_STDACTR_VDMONLIB_FALSE" "0"
    SYSTEM_CONSTANT "DELIB_STDACTR_VDMONLIB_TRUE" "1"
    SYSTEM_CONSTANT "DELIB_STDIAGCURR_OLSCG_BP" "1"
    SYSTEM_CONSTANT "DELIB_STDIAGCURR_SWT_BP" "0"
    SYSTEM_CONSTANT "DELIB_STDSENSTYPAVL_SC" "1"
    SYSTEM_CONSTANT "DELIB_STFIXADJVAL_CHKSUM_ERR_BP" "0"
    SYSTEM_CONSTANT "DELIB_STFIXADJVAL_INTEGER_ERR_BP" "1"
    SYSTEM_CONSTANT "DELIB_STFIXADJVAL_RANGE_ERR_BP" "2"
    SYSTEM_CONSTANT "DELIB_STGRDTLIMNENVRL_CLNVRFYACTV_BP" "2"
    SYSTEM_CONSTANT "DELIB_STGRDTLIMNENVRL_ECU_POSTDRIVE_BP" "5"
    SYSTEM_CONSTANT "DELIB_STGRDTLIMNENVRL_ECU_PREDRIVE_BP" "4"
    SYSTEM_CONSTANT "DELIB_STGRDTLIMNENVRL_ENG_NOT_CRANKING_BP" "8"
    SYSTEM_CONSTANT "DELIB_STGRDTLIMNENVRL_ENG_NOT_RUNNING_BP" "9"
    SYSTEM_CONSTANT "DELIB_STGRDTLIMNENVRL_ENG_NOT_STOPPING_BP" "10"
    SYSTEM_CONSTANT "DELIB_STGRDTLIMNENVRL_INDEPENDENT_OF_ENVCOND_BP" "0"
    SYSTEM_CONSTANT "DELIB_STGRDTLIMNENVRL_LRN_ACTIVE_BP" "3"
    SYSTEM_CONSTANT "DELIB_STGRDTLIMNENVRL_T15_OFF_BP" "7"
    SYSTEM_CONSTANT "DELIB_STGRDTLIMNENVRL_T15_ON_BP" "6"
    SYSTEM_CONSTANT "DELIB_STGRDTLIMNENVRL_TEMP_VALID_NOT_REACHED_BP" "1"
    SYSTEM_CONSTANT "DELIB_STMONGOVROUTPRAMP_LNRGOVRLMT_BP" "0"
    SYSTEM_CONSTANT "DELIB_STMONGRDTLIMN_ININDONE_BP" "0"
    SYSTEM_CONSTANT "DELIB_STMONRCOIL_INIDONE_BP" "0"
    SYSTEM_CONSTANT "DELIB_STMONRCOIL_RPL_BP" "1"
    SYSTEM_CONSTANT "DELIB_TIDIAGDISSIZECUR_SC" "2"
    SYSTEM_CONSTANT "DELIB_TOTALSNSR_SC" "8"
    SYSTEM_CONSTANT "DELIB_UTOFFSADJCLSDSIZECRV_SC" "2"
    SYSTEM_CONSTANT "DELIB_UTOFFSADJOPENDSIZECRV_SC" "2"
    SYSTEM_CONSTANT "DELIB_VARIANT" "0"
    SYSTEM_CONSTANT "DELIB_VERSION" "1620"
    SYSTEM_CONSTANT "DENSFINE_RES_REV" "500"
    SYSTEM_CONSTANT "DEVLIB_4WINDIACMPNENA_SY" "0"
    SYSTEM_CONSTANT "DEVLIB_ACTRPRTCMPNENA_SY" "0"
    SYSTEM_CONSTANT "DEVLIB_DBG_SY" "1"
    SYSTEM_CONSTANT "DEVLIB_DEFECT_RAMP_ACTIVE_BP" "4"
    SYSTEM_CONSTANT "DEVLIB_DEFECT_RAMP_COMPLETED_BP" "3"
    SYSTEM_CONSTANT "DEVLIB_DGK_ACTV" "1"
    SYSTEM_CONSTANT "DEVLIB_DGK_NOTACTV" "0"
    SYSTEM_CONSTANT "DEVLIB_DIACTLLINECMPNENA_SY" "0"
    SYSTEM_CONSTANT "DEVLIB_FRZVAL_MODE" "1"
    SYSTEM_CONSTANT "DEVLIB_HBRGENA_SY" "0"
    SYSTEM_CONSTANT "DEVLIB_HEALING_RAMP_ACTIVE_BP" "2"
    SYSTEM_CONSTANT "DEVLIB_HEALING_RAMP_DESIRED_BP" "1"
    SYSTEM_CONSTANT "DEVLIB_JMPVAL_MODE" "2"
    SYSTEM_CONSTANT "DEVLIB_PHYSRNGCHK_SY" "1"
    SYSTEM_CONSTANT "DEVLIB_PSOFFOPNLD_SY" "1"
    SYSTEM_CONSTANT "DEVLIB_PSSTATEMOCSOPINI_SY" "0"
    SYSTEM_CONSTANT "DEVLIB_PWRSTGSTATEMOCSOPCHK_SY" "0"
    SYSTEM_CONSTANT "DEVLIB_RMPVAL_MODE" "4"
    SYSTEM_CONSTANT "DEVLIB_SENSVAL_MODE" "0"
    SYSTEM_CONSTANT "DFC_CALPRMSTATDISBLMSK_SC" "0"
    SYSTEM_CONSTANT "DFC_CTLDISBLLAYOUT_SY" "1"
    SYSTEM_CONSTANT "DFC_CTLMSKBYTES_SY" "1"
    SYSTEM_CONSTANT "DFC_CTLMSK_RESCANCMSK" "1"
    SYSTEM_CONSTANT "DFC_CTLMSK_RESINIMSK" "1"
    SYSTEM_CONSTANT "DFC_DISBLMSKBYTES_SY" "1"
    SYSTEM_CONSTANT "DFC_SETSTATDITHOAPI_SC" "0"
    SYSTEM_CONSTANT "DFES_ACTVENHMTSIMCONDPID9F_SC" "0"
    SYSTEM_CONSTANT "DFES_ACTVSIMRCDNPID03_SC" "0"
    SYSTEM_CONSTANT "DFES_ADDLMILMOD_SC" "0"
    SYSTEM_CONSTANT "DFES_ADDWARNLMP_SY" "1"
    SYSTEM_CONSTANT "DFES_AGINGCTR_VAR1" "0"
    SYSTEM_CONSTANT "DFES_BLKENTRY_SY" "0"
    SYSTEM_CONSTANT "DFES_COMMILDEB_SY" "0"
    SYSTEM_CONSTANT "DFES_DTCCFMD_SC" "0"
    SYSTEM_CONSTANT "DFES_DTCTFSLC_SC" "0"
    SYSTEM_CONSTANT "DFES_DTCTNCSLC_SC" "0"
    SYSTEM_CONSTANT "DFES_DTC_TSTFAIL_SY" "0"
    SYSTEM_CONSTANT "DFES_ENVDATA2HEAL_SY" "0"
    SYSTEM_CONSTANT "DFES_EOBDCV_SY" "0"
    SYSTEM_CONSTANT "DFES_EOLCLR_SY" "1"
    SYSTEM_CONSTANT "DFES_EXTDFLT_SY" "0"
    SYSTEM_CONSTANT "DFES_IRV_SY" "0"
    SYSTEM_CONSTANT "DFES_MILBLINKDEB_SC" "0"
    SYSTEM_CONSTANT "DFES_MONITORING_LEN_SY" "1"
    SYSTEM_CONSTANT "DFES_NUMENTRIES_SY" "32"
    SYSTEM_CONSTANT "DFES_NUM_COMMON_ENV_DID" "0"
    SYSTEM_CONSTANT "DFES_NUM_COMMON_ENV_SIGNALS" "0"
    SYSTEM_CONSTANT "DFES_NUM_ENTRY_U8_BITBASE" "5"
    SYSTEM_CONSTANT "DFES_NUM_ENV_BLK" "2"
    SYSTEM_CONSTANT "DFES_NUM_ENV_BYT" "14"
    SYSTEM_CONSTANT "DFES_NUM_ENV_DID" "0"
    SYSTEM_CONSTANT "DFES_NUM_ENV_SIGNALS" "6"
    SYSTEM_CONSTANT "DFES_NUM_EXFRZFR_BYT" "0"
    SYSTEM_CONSTANT "DFES_NUM_EXFRZFR_SIG" "0"
    SYSTEM_CONSTANT "DFES_NUM_FRFR_DID" "4"
    SYSTEM_CONSTANT "DFES_NUM_FRZFR_BYT" "4"
    SYSTEM_CONSTANT "DFES_OFFROADDRVGTIFLCTRIG_SC" "0"
    SYSTEM_CONSTANT "DFES_OFFROADTITRIGFLTCNTR_SC" "1"
    SYSTEM_CONSTANT "DFES_PDTC_SY" "1"
    SYSTEM_CONSTANT "DFES_PRVTSTRDLT_SY" "0"
    SYSTEM_CONSTANT "DFES_SELFHEAL_SC" "0"
    SYSTEM_CONSTANT "DFES_SIMCOND_READONLY" "0"
    SYSTEM_CONSTANT "DFES_SIMRCONDFLTDEB_SC" "0"
    SYSTEM_CONSTANT "DFES_SUPRTFASTBLINK_SC" "0"
    SYSTEM_CONSTANT "DFES_VIS_BUF_SY" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECCTRLLINEDIAGCPTENA_SC" "0"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAGENA_SC" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_CTRLNOT" "0"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_CTRLSWTOFF" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_CTRLSWTOFFDIAG" "3"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_CTRLTESTPLS" "2"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_DIAG_OK" "0"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_DIAG_TRO_SIGNOTINI" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRCURRLIMN" "9"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRCURRREDN" "10"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRINI_FAIL_ERRARYFULL" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRINI_FAIL_INVLDERRTYPE" "2"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRINI_FAIL_MPLDFC" "3"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRINI_FAIL_MPLERRTYP" "4"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRINI_SUC" "0"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERROPENLOAD" "7"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERROVERT" "6"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRSCB1" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRSCB2" "2"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRSCG1" "3"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRSCG2" "4"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRSCOL" "5"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_ERRUNDRU" "8"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLABORT" "4"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLABORT_ACCPT" "0"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLABORT_REJ_OLDIAGNOTACTV" "4"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLABORT_REJ_OLERRNOTINI" "3"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLABORT_REJ_OLMODINCOR" "2"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLABORT_REJ_SIGNOTINI" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLMODACTV" "2"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLMODNOTCFG" "0"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLMODSWTOFF" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLNOTREQD" "0"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLOVER" "3"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLREQD" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLREQ_ACCPT" "0"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLREQ_REJ_OLDIAGACTV" "4"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLREQ_REJ_OLERRNOTINI" "3"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLREQ_REJ_OLMODINCOR" "2"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLREQ_REJ_SIGNOTINI" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_OLRUNNG" "2"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_SETOLMOD_FAIL_INVLDMOD" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_SETOLMOD_FAIL_OLMODNOTSWIL" "2"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_SETOLMOD_SUC" "0"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_SIGNALTYPE_HBR" "0"
    SYSTEM_CONSTANT "DIAACTR_ELECHBRDGDIAG_SIGNALTYPE_HLFBR" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECPSDIAGCMPNENA_SC" "1"
    SYSTEM_CONSTANT "DIAACTR_ELECPSDIAGERRINFO_SC" "0"
    SYSTEM_CONSTANT "DIAACTR_ERRTYPE_NRMAX" "4"
    SYSTEM_CONSTANT "DIAACTR_ERRTYPE_OL" "3"
    SYSTEM_CONSTANT "DIAACTR_ERRTYPE_OT" "4"
    SYSTEM_CONSTANT "DIAACTR_ERRTYPE_SCB" "1"
    SYSTEM_CONSTANT "DIAACTR_ERRTYPE_SCG" "2"
    SYSTEM_CONSTANT "DIAACTR_ERRTYPE_UNDEFINED" "0"
    SYSTEM_CONSTANT "DIAACTR_SIGTYPE_DIGOUT" "1"
    SYSTEM_CONSTANT "DIAACTR_SIGTYPE_PMD" "3"
    SYSTEM_CONSTANT "DIAACTR_SIGTYPE_PWMOUT" "2"
    SYSTEM_CONSTANT "DIAACTR_SIGTYPE_UNDEFINED" "0"
    SYSTEM_CONSTANT "DIABAS_ATSLRGIDSUPRT_SC" "0"
    SYSTEM_CONSTANT "DIABAS_ATSSUSP_SC" "1"
    SYSTEM_CONSTANT "DIABAS_ATS_SC" "1"
    SYSTEM_CONSTANT "DIABAS_AVS_SY" "1"
    SYSTEM_CONSTANT "DIABAS_BSWVERS_SC" "22"
    SYSTEM_CONSTANT "DIABAS_CALIDCVNCTRL_SC" "0"
    SYSTEM_CONSTANT "DIABAS_CALIDCVNLENSEQ_SC" "0"
    SYSTEM_CONSTANT "DIABAS_CRCTAB_SY" "0"
    SYSTEM_CONSTANT "DIABAS_ETCINTSTATE_SC" "0"
    SYSTEM_CONSTANT "DIABAS_IFFLOATSIG_SC" "0"
    SYSTEM_CONSTANT "DIABAS_PNDRPRTMOD2_SC" "0"
    SYSTEM_CONSTANT "DIABAS_PRMIDAUTVIEW_SC" "0"
    SYSTEM_CONSTANT "DIABAS_SCRCTL_RCNT_RESET_SY" "0"
    SYSTEM_CONSTANT "DIABAS_SRV8_SC" "0"
    SYSTEM_CONSTANT "DIAGCOM_CALCAN_SC" "0"
    SYSTEM_CONSTANT "DIAGCOM_CANFD_SC" "1"
    SYSTEM_CONSTANT "DINH_DEF25DEB0DI_SC" "0"
    SYSTEM_CONSTANT "DINH_FID_VIEW_SC" "0"
    SYSTEM_CONSTANT "DINH_NEWTRIPWITHFCMCLR_SC" "0"
    SYSTEM_CONSTANT "DIPO_SY" "1"
    SYSTEM_CONSTANT "DISTAB_SY" "1"
    SYSTEM_CONSTANT "DIUMPR_500MD_SY" "0"
    SYSTEM_CONSTANT "DIUMPR_COLDSTARTDEN_SC" "0"
    SYSTEM_CONSTANT "DIUMPR_CTGEN_READONLY" "0"
    SYSTEM_CONSTANT "DIUMPR_CTGEN_TIFUENGOPMIN_RW" "1"
    SYSTEM_CONSTANT "DIUMPR_DATAFROMCAN_SC" "0"
    SYSTEM_CONSTANT "DIUMPR_DSTTRVLDSNCERST_SC" "0"
    SYSTEM_CONSTANT "DIUMPR_EVAPDENOMTIPRPSYSOFF_SC" "0"
    SYSTEM_CONSTANT "DIUMPR_EVAPDEN_SY" "0"
    SYSTEM_CONSTANT "DIUMPR_FUENGOPERTI_SC" "0"
    SYSTEM_CONSTANT "DIUMPR_IGNCYCTMR_SC" "0"
    SYSTEM_CONSTANT "DIUMPR_J1939_SC" "0"
    SYSTEM_CONSTANT "DIUMPR_J1979_NUM_GROUPS" "8"
    SYSTEM_CONSTANT "DIUMPR_NUMDENOMIDXGRP_SY" "0"
    SYSTEM_CONSTANT "DIUMPR_NUMMSGGRPS" "0"
    SYSTEM_CONSTANT "DIUMPR_NUMRATCFG" "0"
    SYSTEM_CONSTANT "DIUMPR_NUMRATCLB" "40"
    SYSTEM_CONSTANT "DIUMPR_NUMSIGCLB" "40"
    SYSTEM_CONSTANT "DIUMPR_NUM_GROUPS_SY" "8"
    SYSTEM_CONSTANT "DM_SOX2_RES_FL" "0.004"
    SYSTEM_CONSTANT "DOIP_SC" "1"
    SYSTEM_CONSTANT "DPDIFFTMP_RES" "100"
    SYSTEM_CONSTANT "DPDIFF_RES" "0.1"
    SYSTEM_CONSTANT "DPRC_100" "100"
    SYSTEM_CONSTANT "DPRC_M_100" "-100"
    SYSTEM_CONSTANT "DRESFLW_RES" "0.001"
    SYSTEM_CONSTANT "DRESFLW_RES_REV" "1000"
    SYSTEM_CONSTANT "DRVPRGSWT_NUMMODE" "0"
    SYSTEM_CONSTANT "DRVPRGSWT_NUMSPRT" "0"
    SYSTEM_CONSTANT "DRVPRGSWT_NUMWNTR" "0"
    SYSTEM_CONSTANT "DSCHED_COEOMEXT_SC" "0"
    SYSTEM_CONSTANT "DSCHED_COEOM_SY" "1"
    SYSTEM_CONSTANT "DSCHED_DFCSPEC_SY" "0"
    SYSTEM_CONSTANT "DSCHED_FIDMAXPRIOLST_SY" "0"
    SYSTEM_CONSTANT "DSCHED_FTI_SY" "0"
    SYSTEM_CONSTANT "DSCHED_PRIOACTVJMP_SY" "1"
    SYSTEM_CONSTANT "DSCHED_PRIODFCSTLDF_SY" "0"
    SYSTEM_CONSTANT "DSCHED_PRIODFCSTTST_SY" "0"
    SYSTEM_CONSTANT "DSCHED_PRIOPHYSURGENCY_SY" "1"
    SYSTEM_CONSTANT "DSCHED_PRIORMPCALC_SY" "1"
    SYSTEM_CONSTANT "DSCHED_RATECALC_SY" "0"
    SYSTEM_CONSTANT "DSCHED_WTT_SY" "0"
    SYSTEM_CONSTANT "DSM2AUTOSAR_ASWPF_SC" "0"
    SYSTEM_CONSTANT "DSM2AUTOSAR_DCMIF_SC" "0"
    SYSTEM_CONSTANT "DSM2AUTOSAR_DEMBSWERRORBUFFERSIZE" "30"
    SYSTEM_CONSTANT "DSM2AUTOSAR_DEMJ1939EXFRZFRSUPP" "1"
    SYSTEM_CONSTANT "DSM2AUTOSAR_DEV_ERROR_DETECT" "1"
    SYSTEM_CONSTANT "DSM2AUTOSAR_NRDEMCLIENT" "2"
    SYSTEM_CONSTANT "DSM2AUTOSAR_NRDEMCLIENTFULLSUPPORT" "2"
    SYSTEM_CONSTANT "DSM2AUTOSAR_NRDEMCLIENTNOFULLSUPPORT" "0"
    SYSTEM_CONSTANT "DSM2AUTOSAR_NRDEMCLIENTRTESUPPORT" "0"
    SYSTEM_CONSTANT "DSM2AUTOSAR_SC" "1"
    SYSTEM_CONSTANT "DSM2AUTOSAR_SECFCM_SC" "0"
    SYSTEM_CONSTANT "DSM2SG_DFC_SY" "0"
    SYSTEM_CONSTANT "DSM2SG_DSQ_SY" "0"
    SYSTEM_CONSTANT "DSM2SG_EXCH_SC" "0"
    SYSTEM_CONSTANT "DSM2SG_FID_SY" "0"
    SYSTEM_CONSTANT "DSMAUX_READONLY" "0"
    SYSTEM_CONSTANT "DSMAUX_ROEBUFLEN" "0"
    SYSTEM_CONSTANT "DSMAUX_ROEBUFUSEENVRAM" "0"
    SYSTEM_CONSTANT "DSMAUX_TCSORT_SY" "0"
    SYSTEM_CONSTANT "DSMBAS_CENSUPPDIUMPR_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_CENSUPPDTR_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_DTRRPRTDI_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_ENASIMRCDN_SC" "1"
    SYSTEM_CONSTANT "DSMBAS_ENVTLBLKUPD_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_KEYONCYCFLCTRIG_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_NODFP_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_NODIAGCSDL_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_NODTR_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_PNDRPRTMOD2_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_PREFAILDINTDEB_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_REINIMETHSELN_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_SELPID41BHVR_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_SRVLAMPSCTRLSTGY_SC" "0"
    SYSTEM_CONSTANT "DSMBAS_TESTFAILDSNCELSTCLR_SC" "0"
    SYSTEM_CONSTANT "DSMBDEP_SY" "0"
    SYSTEM_CONSTANT "DSMCONF_DEBMULDCY_SC" "0"
    SYSTEM_CONSTANT "DSMCONF_DEM_DTC_LABELS_UDS" "2"
    SYSTEM_CONSTANT "DSMCONF_DFCCTTSTD" "0"
    SYSTEM_CONSTANT "DSMCONF_DTCTABLE_DTCM" "1"
    SYSTEM_CONSTANT "DSMCONF_DTCTABLE_DTCSAE" "1"
    SYSTEM_CONSTANT "DSMCONF_DTCTABLE_DTCX" "0"
    SYSTEM_CONSTANT "DSMCONF_DTCTABLE_J1939FMI" "1"
    SYSTEM_CONSTANT "DSMCONF_NUM_CLASSES" "4"
    SYSTEM_CONSTANT "DSMCONF_SUPGLBCTLMSK" "0"
    SYSTEM_CONSTANT "DSMCONF_SUPGLBDBLV" "1"
    SYSTEM_CONSTANT "DSMCONF_SUPGLBDISBLMSK" "0"
    SYSTEM_CONSTANT "DSMCONF_SUPGLBDTCFUNCUNIT" "0"
    SYSTEM_CONSTANT "DSMCONF_SUPGLBDTCGROUP" "0"
    SYSTEM_CONSTANT "DSMCONF_SUPGLBDTCSEVERITY" "0"
    SYSTEM_CONSTANT "DSMCONF_SUPGLBENVREF" "0"
    SYSTEM_CONSTANT "DSMCONF_SUPGLBFAULTTYP" "0"
    SYSTEM_CONSTANT "DSMCONF_SUPGLBFLTCLS" "0"
    SYSTEM_CONSTANT "DSMCONF_SUPGLBOBDFAULTTYP" "0"
    SYSTEM_CONSTANT "DSMCONF_SUP_DFC_STUNCFMDTHISKEYONCYC" "0"
    SYSTEM_CONSTANT "DSMCONF_SUP_TNPSCPU" "0"
    SYSTEM_CONSTANT "DSMCONF_SUP_TNPSDTCC" "0"
    SYSTEM_CONSTANT "DSMDFC_BAS16BITARYSIZE" "82"
    SYSTEM_CONSTANT "DSMDUR_ENACOND_LDF_SC" "0"
    SYSTEM_CONSTANT "DSMDUR_GLB_CNT_ENBL" "4"
    SYSTEM_CONSTANT "DSMDUR_MIL_GLB_SY" "0"
    SYSTEM_CONSTANT "DSMDUR_SUPPID4D_SC" "0"
    SYSTEM_CONSTANT "DSMDUR_SUPPID4E_SC" "0"
    SYSTEM_CONSTANT "DSMDUR_SUPRTPID93_SC" "0"
    SYSTEM_CONSTANT "DSMRDY_ENA_FLSYSFORCELABEL_SC" "0"
    SYSTEM_CONSTANT "DSMRDY_ENGSPEC_SY" "1"
    SYSTEM_CONSTANT "DSMRDY_ENVCOND_SUP" "1"
    SYSTEM_CONSTANT "DSMRDY_FIDINH_SUP" "1"
    SYSTEM_CONSTANT "DSMRDY_FLSYSNONCONT" "0"
    SYSTEM_CONSTANT "DSMRDY_INHP41_SY" "0"
    SYSTEM_CONSTANT "DSMRDY_J1939_SY" "0"
    SYSTEM_CONSTANT "DSMRDY_PID41DIDLY_SC" "0"
    SYSTEM_CONSTANT "DSMRDY_PTORST_SC" "0"
    SYSTEM_CONSTANT "DSMRDY_READONLY" "0"
    SYSTEM_CONSTANT "DSMRDY_READONLYGRP" "0"
    SYSTEM_CONSTANT "DSMRDY_SIZE_LST_AC" "1"
    SYSTEM_CONSTANT "DSMRDY_SIZE_LST_BP" "100"
    SYSTEM_CONSTANT "DSMRDY_SIZE_LST_ComprCmpnt" "100"
    SYSTEM_CONSTANT "DSMRDY_SIZE_LST_EGR" "50"
    SYSTEM_CONSTANT "DSMRDY_SIZE_LST_EGSens" "100"
    SYSTEM_CONSTANT "DSMRDY_SIZE_LST_FlSys" "50"
    SYSTEM_CONSTANT "DSMRDY_SIZE_LST_HCCat" "100"
    SYSTEM_CONSTANT "DSMRDY_SIZE_LST_Misf" "50"
    SYSTEM_CONSTANT "DSMRDY_SIZE_LST_NOxCat" "100"
    SYSTEM_CONSTANT "DSMRDY_SIZE_LST_PMFlt" "100"
    SYSTEM_CONSTANT "DSMRDY_SIZE_LST_Resv" "1"
    SYSTEM_CONSTANT "DSMRDY_STDCONFIG" "1"
    SYSTEM_CONSTANT "DSMRDY_SUPPID41_SY" "0"
    SYSTEM_CONSTANT "DSMRDY_VERS_SC" "1"
    SYSTEM_CONSTANT "DSM_B1CNTRSPDUP_SC" "0"
    SYSTEM_CONSTANT "DSM_B1CNTR_SC" "0"
    SYSTEM_CONSTANT "DSM_CHINA6PDTC_SC" "0"
    SYSTEM_CONSTANT "DSM_CONF_SUP_DFC_STCLCTLDF" "0"
    SYSTEM_CONSTANT "DSM_CONF_SUP_DSMRDY_CT" "0"
    SYSTEM_CONSTANT "DSM_CONF_SUP_DSMRDY_XWHY" "1"
    SYSTEM_CONSTANT "DSM_DISBLGRPSIZE_SY" "0"
    SYSTEM_CONSTANT "DSM_DOBD_SC" "0"
    SYSTEM_CONSTANT "DSM_DSM2SG_SY" "0"
    SYSTEM_CONSTANT "DSM_DTRINTCOMPUVLDN_SC" "0"
    SYSTEM_CONSTANT "DSM_FAILCNT_SY" "0"
    SYSTEM_CONSTANT "DSM_FAULTSEQ_SY" "0"
    SYSTEM_CONSTANT "DSM_FLTTYP_SC" "0"
    SYSTEM_CONSTANT "DSM_HDOBD_SY" "0"
    SYSTEM_CONSTANT "DSM_INHRLS_SY" "0"
    SYSTEM_CONSTANT "DSM_MDOBD_SY" "0"
    SYSTEM_CONSTANT "DSM_NUMDFC" "1311"
    SYSTEM_CONSTANT "DSM_NUMFID" "25"
    SYSTEM_CONSTANT "DSM_PDTCTSTRA_SY" "0"
    SYSTEM_CONSTANT "DSM_TESTMODDIAGCODLAMP_SC" "0"
    SYSTEM_CONSTANT "DSM_WUCDET_SY" "0"
    SYSTEM_CONSTANT "DSM_WWHOBDCV_SY" "0"
    SYSTEM_CONSTANT "DTR_LEGIFC_SY" "0"
    SYSTEM_CONSTANT "DTR_NUM_ELEMENTS" "1"
    SYSTEM_CONSTANT "DTTEMP_300" "300"
    SYSTEM_CONSTANT "DTTEMP_M_300" "-300"
    SYSTEM_CONSTANT "DTY_CYC_ZERO" "0"
    SYSTEM_CONSTANT "DT_KELV_RES" "0.1"
    SYSTEM_CONSTANT "DVOL_RES" "0.1"
    SYSTEM_CONSTANT "D_FLCONS_RES" "0.01"
    SYSTEM_CONSTANT "ECBVLV_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "ECUOFF_TMR_SY" "0"
    SYSTEM_CONSTANT "ECUTYP_SC" "2"
    SYSTEM_CONSTANT "ECU_GENR_SY" "6"
    SYSTEM_CONSTANT "EEPROM_RESET_CALIB" "3"
    SYSTEM_CONSTANT "EEPROM_RESET_INACTIVE" "2"
    SYSTEM_CONSTANT "EGREVAPRUSFLDP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EGRVLVINSDT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EGRVLVI_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EGRVLVLPI_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EGTCOND_ACTV_BP" "0"
    SYSTEM_CONSTANT "EGTSWT_FACT" "16384000"
    SYSTEM_CONSTANT "EGTSWT_FACT_S16" "16384"
    SYSTEM_CONSTANT "EGTSWT_NRM_EXP" "14"
    SYSTEM_CONSTANT "EGTSWT_RES" "6.103515625e-008"
    SYSTEM_CONSTANT "EGTSWT_RES_S16" "6.103515625e-005"
    SYSTEM_CONSTANT "EMGYSHOFFIN2_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EMGYSTRTSWT2_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "ENADATASETID_CALPAR_SC" "1"
    SYSTEM_CONSTANT "ENERGY_J_HI_RES" "1"
    SYSTEM_CONSTANT "ENERGY_Q0P0001_RES" "0.0001"
    SYSTEM_CONSTANT "ENERGY_Q0P0001_RES_REV" "10000"
    SYSTEM_CONSTANT "ENERGY_Q0P001_RES" "0.001"
    SYSTEM_CONSTANT "ENERGY_Q0P001_RES_REV" "1000"
    SYSTEM_CONSTANT "ENERGY_RES" "1"
    SYSTEM_CONSTANT "ENGCMPTMTT_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "ENGDA_CTFLD_NUM" "1"
    SYSTEM_CONSTANT "ENGMIDT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "ENGOILT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "ENGRESTRT_SY" "0"
    SYSTEM_CONSTANT "ENGSPD_SWTENA_SY" "0"
    SYSTEM_CONSTANT "ENRGPERMASS_RES" "0.1"
    SYSTEM_CONSTANT "ENVP_TYPAVL_SY" "1"
    SYSTEM_CONSTANT "ENVRAM_RESET_ACTIVE" "1"
    SYSTEM_CONSTANT "ENVT_TYPAVL_SY" "1"
    SYSTEM_CONSTANT "EPMBCA_FACSEGTIMEACC_CURX_SC" "4"
    SYSTEM_CONSTANT "EPMBCR_DTINCSTRT_CURX_SC" "2"
    SYSTEM_CONSTANT "EPMBCR_FACWEIGHTPAS_DSTX_SC" "2"
    SYSTEM_CONSTANT "EPMBCR_FACWEIGHT_DSTX_SC" "2"
    SYSTEM_CONSTANT "EPMCAS_DIAGSRC2_SC" "0"
    SYSTEM_CONSTANT "EPMCAS_FACPLAUS_DSTX_SC" "3"
    SYSTEM_CONSTANT "EPMCAS_NUMSEGLEN_SC" "10"
    SYSTEM_CONSTANT "EPMCAS_NUMSEG_SC" "10"
    SYSTEM_CONSTANT "EPMCAS_PHINCOR_CURX_SC" "6"
    SYSTEM_CONSTANT "EPMCAS_PHITEMPADAPCORSIZEDSTX_SC" "5"
    SYSTEM_CONSTANT "EPMCAS_PHITEMPCOR05_DSTX_SC" "3"
    SYSTEM_CONSTANT "EPMCAS_PRODCORRNVAL_SC" "0"
    SYSTEM_CONSTANT "EPMCAS_REFADPNTSTRENARESP_SC" "0"
    SYSTEM_CONSTANT "EPMCAS_REFADPNTSTR_SC" "0"
    SYSTEM_CONSTANT "EPMCAS_SELNDIAGFAILRADPN_SC" "0"
    SYSTEM_CONSTANT "EPMCRS_DGIPLSCORRNACTVD_SC" "0"
    SYSTEM_CONSTANT "EPMCRS_DIAGDETAILEXTD_SC" "0"
    SYSTEM_CONSTANT "EPMCRS_DIAGSRC_SC" "0"
    SYSTEM_CONSTANT "EPMCRS_DIAGSYNCLOST_SC" "0"
    SYSTEM_CONSTANT "EPMCRS_ENASIGLVLDIAG_SC" "0"
    SYSTEM_CONSTANT "EPMCRS_MAXAXISPNTSTIPLSCRV_SC" "0"
    SYSTEM_CONSTANT "EPMCRS_NRENGSPDSEGPLAUS_SC" "4"
    SYSTEM_CONSTANT "EPMCRS_NUMINCOUT_SC" "15"
    SYSTEM_CONSTANT "EPMCRS_PLSWIDTHAPPLACTVD_SC" "0"
    SYSTEM_CONSTANT "EPMCRS_RESLTOTREV_SC" "0"
    SYSTEM_CONSTANT "EPMCRS_REVSTRTCONT_SC" "1"
    SYSTEM_CONSTANT "EPMCRS_TIINCOUTPVBL_SC" "1"
    SYSTEM_CONSTANT "EPMCRS_TIINCOUT_SC" "0"
    SYSTEM_CONSTANT "EPMERR_NRERRINFOARY_SC" "3"
    SYSTEM_CONSTANT "EPMHCRS_NUMINC" "60"
    SYSTEM_CONSTANT "EPMHWE_RTM_SY" "0"
    SYSTEM_CONSTANT "EPMRRS_IGNLOCKRELSIMDT_SC" "0"
    SYSTEM_CONSTANT "EPMRRS_SY" "2"
    SYSTEM_CONSTANT "EPMRRS_TITEMP_CURX_SC" "3"
    SYSTEM_CONSTANT "EPMRVSROTYMETH_SY" "1"
    SYSTEM_CONSTANT "EPMSYN_INJRLS_SC" "0"
    SYSTEM_CONSTANT "EPMSYN_PHIINCCOR_CURX_SC" "4"
    SYSTEM_CONSTANT "EPMTDC_PRODCORRNVAL_SC" "0"
    SYSTEM_CONSTANT "EPM_ATS_SY" "0"
    SYSTEM_CONSTANT "EPM_CAMSFTSNSRDEACTVN_SC" "0"
    SYSTEM_CONSTANT "EPM_CUSTADP_SC" "0"
    SYSTEM_CONSTANT "EPM_DGIDIRCORRN_SC" "1"
    SYSTEM_CONSTANT "EPM_DGIDIRFRCD_SC" "1"
    SYSTEM_CONSTANT "EPM_DGIDYNCHG_SC" "1"
    SYSTEM_CONSTANT "EPM_DGIPLSRNG_SC" "1"
    SYSTEM_CONSTANT "EPM_HIRESLSEGLENCAL_SC" "0"
    SYSTEM_CONSTANT "EPM_INDCAMSFTCFG_SC" "0"
    SYSTEM_CONSTANT "EPM_KEEPDGISYNC_SC" "1"
    SYSTEM_CONSTANT "EPM_MEASURE_SY" "2"
    SYSTEM_CONSTANT "EPM_NRAGEVE_SC" "0"
    SYSTEM_CONSTANT "EPM_RVSROTPRED_SC" "0"
    SYSTEM_CONSTANT "EPM_SPD_CALC_SY" "0"
    SYSTEM_CONSTANT "EPM_STRTSELECT_SC" "0"
    SYSTEM_CONSTANT "EPM_STRTWOCAMSFTSIGDETN_SC" "0"
    SYSTEM_CONSTANT "EPM_SYNCSLV_SY" "0"
    SYSTEM_CONSTANT "EPM_TDCDSTCLB_SC" "0"
    SYSTEM_CONSTANT "EPM_TIMING_SY" "0"
    SYSTEM_CONSTANT "ERCLNTVLVT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "ERRLMP_ATSINTVMOD_SY" "0"
    SYSTEM_CONSTANT "ERRLMP_CALCSTMILALWAYS_SY" "0"
    SYSTEM_CONSTANT "ERRLMP_CUST_SY" "0"
    SYSTEM_CONSTANT "ERRLMP_DCU_MSK" "8"
    SYSTEM_CONSTANT "ERRLMP_MILBLINK_MSK" "2"
    SYSTEM_CONSTANT "ERRLMP_MILCONTNS_MSK" "1"
    SYSTEM_CONSTANT "ERRLMP_MILONDEM_MSK" "8"
    SYSTEM_CONSTANT "ERRLMP_MILSHO_MSK" "4"
    SYSTEM_CONSTANT "ERRLMP_MSG_MSK" "1"
    SYSTEM_CONSTANT "ERRLMP_NOREQ_MSK" "0"
    SYSTEM_CONSTANT "ERRLMP_PSPRS_SY" "0"
    SYSTEM_CONSTANT "ERRLMP_RDY_MSK" "16"
    SYSTEM_CONSTANT "ERRLMP_UNIFY_SC" "0"
    SYSTEM_CONSTANT "ERRLMP_VLDTSTDSQ_SC" "0"
    SYSTEM_CONSTANT "ESC_ACTVTSYNCHAINCFG_SC" "2"
    SYSTEM_CONSTANT "ESC_ACTVTSYNTSKCHAIN_SC" "0"
    SYSTEM_CONSTANT "ESC_DT_NESTING_DEPTH" "12"
    SYSTEM_CONSTANT "ESC_ENAPROCGROUP_SC" "0"
    SYSTEM_CONSTANT "ESC_NRAGEVEWCYC_SC" "0"
    SYSTEM_CONSTANT "ESC_NRTSKAGEVE_SC" "0"
    SYSTEM_CONSTANT "ESC_SAMPLETICALCN_SC" "0"
    SYSTEM_CONSTANT "ESC_SELNCAMSFTTSKACTVN_SC" "0"
    SYSTEM_CONSTANT "ESC_SELNMETHSYNSDL_SC" "0"
    SYSTEM_CONSTANT "ESC_SELNNOTSTDTISYNCNTSK_SC" "0"
    SYSTEM_CONSTANT "ESC_SELSAMPLETICFGMETHOD_SC" "0"
    SYSTEM_CONSTANT "ESC_SWTSYNRTMEASMT_SC" "0"
    SYSTEM_CONSTANT "ESC_SYNCTASK_SC" "1"
    SYSTEM_CONSTANT "ETA_THM_ENG_ONE" "1"
    SYSTEM_CONSTANT "ETCLB_NUM_RAILP_CLB_PNT" "2"
    SYSTEM_CONSTANT "ETCTL_ACTV_BP" "0"
    SYSTEM_CONSTANT "ETC_Act_SY" "1"
    SYSTEM_CONSTANT "ETHIPCORETYPE_SC" "2"
    SYSTEM_CONSTANT "ETHSWT_SC" "0"
    SYSTEM_CONSTANT "ETHTSYN_SC" "0"
    SYSTEM_CONSTANT "ETH_SC" "1"
    SYSTEM_CONSTANT "ETKS_SY" "1"
    SYSTEM_CONSTANT "ETS_INJPOI1" "4"
    SYSTEM_CONSTANT "ETS_LEAN_SY" "0"
    SYSTEM_CONSTANT "ETS_NSC_SY" "0"
    SYSTEM_CONSTANT "ETS_NUMINPMSK_SY" "0"
    SYSTEM_CONSTANT "ETS_PFLT1_SY" "0"
    SYSTEM_CONSTANT "ETS_PFLT2_1" "31"
    SYSTEM_CONSTANT "ETS_PFLT2_SY" "0"
    SYSTEM_CONSTANT "ETS_PHC_SY" "0"
    SYSTEM_CONSTANT "ETS_SOX_SY" "0"
    SYSTEM_CONSTANT "EVAPRDSMIXFLDP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EVAPRDSMIXFLDT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EVTYP_SY" "0"
    SYSTEM_CONSTANT "EXHEVAPRDSFLDT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EXHEVAPRDSGAST_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EXHEVAPRUSFLDP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EXHEVAPRUSFLDT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EXHEVAPRUSGAST_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EXHFLPLPI_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "EXHPPFLT_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "FACT16_EXP" "16"
    SYSTEM_CONSTANT "FACT16_RES_REV" "65536"
    SYSTEM_CONSTANT "FACT1_ZERO" "0"
    SYSTEM_CONSTANT "FACT26_EXP" "26"
    SYSTEM_CONSTANT "FACT26_RES_REV" "67108864"
    SYSTEM_CONSTANT "FACT6_RES_REV" "500"
    SYSTEM_CONSTANT "FACT9_RES_REV" "5000"
    SYSTEM_CONSTANT "FACTLOW1_RES_REV" "25"
    SYSTEM_CONSTANT "FACT_NSCAGETOT_RES" "3"
    SYSTEM_CONSTANT "FACT_NSCAGE_RES" "0.001"
    SYSTEM_CONSTANT "FACT_NSCEFF_RES" "0.0001"
    SYSTEM_CONSTANT "FACT_NSCEFF_RES_REV" "10000"
    SYSTEM_CONSTANT "FACT_NSC_MAX" "1"
    SYSTEM_CONSTANT "FACT_NSC_MIN" "0"
    SYSTEM_CONSTANT "FACT_NSC_RES" "0.001"
    SYSTEM_CONSTANT "FACT_NSC_RES_REV" "1000"
    SYSTEM_CONSTANT "FACT_OIL_VOLSNGLDIFF" "32000"
    SYSTEM_CONSTANT "FACT_Q0P001_RES" "0.001"
    SYSTEM_CONSTANT "FACT_Q0P001_RES_REV" "1000"
    SYSTEM_CONSTANT "FACT_VOLNSC_RES" "1e-006"
    SYSTEM_CONSTANT "FAC_AG_CRS_HI_RESO" "128"
    SYSTEM_CONSTANT "FAC_MASSINJ_TO_QNTINJ" "10000"
    SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_0" "1000"
    SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_1" "1500"
    SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_2" "2500"
    SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_3" "5000"
    SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_RES" "100"
    SYSTEM_CONSTANT "FAC_T_INC_PER_DUR_HI_RESO" "256"
    SYSTEM_CONSTANT "FADEOUT_INITFADEOUT_BP" "0"
    SYSTEM_CONSTANT "FANCTL_HOTLMP" "0"
    SYSTEM_CONSTANT "FANCTL_HOTLMPWRN" "1"
    SYSTEM_CONSTANT "FDE_SC" "0"
    SYSTEM_CONSTANT "FINAL_DEFECT" "0"
    SYSTEM_CONSTANT "FLCONS1_RES" "0.01"
    SYSTEM_CONSTANT "FLCONS2_RES" "1"
    SYSTEM_CONSTANT "FLCONS2_RES_HIGH_REV" "20"
    SYSTEM_CONSTANT "FLCONS2_RES_REV" "1"
    SYSTEM_CONSTANT "FLCONS3_MIN" "0"
    SYSTEM_CONSTANT "FLCONS_SDET_MIN" "0.01"
    SYSTEM_CONSTANT "FLEXPSCTRLRNR_SC" "1"
    SYSTEM_CONSTANT "FLFLTDSP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "FLMNG_R_STOICH_CONF" "14.5"
    SYSTEM_CONSTANT "FLOATIFRESLSELN_SC" "0"
    SYSTEM_CONSTANT "FLOWFCTCRITAIR" "0.48417899"
    SYSTEM_CONSTANT "FLVOL_RES" "0.05"
    SYSTEM_CONSTANT "FLXR_SY" "0"
    SYSTEM_CONSTANT "FRARTP_SC" "0"
    SYSTEM_CONSTANT "FRNM_SC" "0"
    SYSTEM_CONSTANT "FRTP_SC" "0"
    SYSTEM_CONSTANT "FRTSYN_SC" "0"
    SYSTEM_CONSTANT "FSPDSFLDP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "FUELP_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "FUELT2_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "FUELT_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "GBXOILP_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "GBXOILT_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "GDI_SY" "0"
    SYSTEM_CONSTANT "GEAR0" "0"
    SYSTEM_CONSTANT "GEAR1" "1"
    SYSTEM_CONSTANT "GEAR2" "2"
    SYSTEM_CONSTANT "GEAR3" "3"
    SYSTEM_CONSTANT "GEAR4" "4"
    SYSTEM_CONSTANT "GEAR5" "5"
    SYSTEM_CONSTANT "GEAR6" "6"
    SYSTEM_CONSTANT "GEAR7" "7"
    SYSTEM_CONSTANT "GLBDA_ACTRACTVN_SC" "0"
    SYSTEM_CONSTANT "GLWCTL_TIME_MS_RES" "10"
    SYSTEM_CONSTANT "GSSYS_TYPEEXHFLW_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPPCR_SY" "1"
    SYSTEM_CONSTANT "HCMPT_Q0P0000004_ZERO" "0"
    SYSTEM_CONSTANT "HEATRCORET_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "HEAT_CAPACITY_RES_REV" "10"
    SYSTEM_CONSTANT "HEM_SY" "0"
    SYSTEM_CONSTANT "HESRV_CSTNCCHKECU1" "1"
    SYSTEM_CONSTANT "HESRV_CSTNCCHKECU2" "2"
    SYSTEM_CONSTANT "HESRV_HCU" "3"
    SYSTEM_CONSTANT "HESRV_HETYP_SY" "255"
    SYSTEM_CONSTANT "HESRV_NOTUSED" "0"
    SYSTEM_CONSTANT "HESRV_VCU" "2"
    SYSTEM_CONSTANT "HEVCHGR_SY" "0"
    SYSTEM_CONSTANT "HEVPLINAVL_SC" "0"
    SYSTEM_CONSTANT "HEVTYP_SY" "0"
    SYSTEM_CONSTANT "HPDIFF_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "HPIN_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "HPOUTPRR_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "HTANKP_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "HTANKT_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "HTIN_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "HTOUT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "HVACHEATPMPP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "HVACHEATPMPT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "HVACSPT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "HWDPD_SC" "0"
    SYSTEM_CONSTANT "HYDSTORGHIPT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "HYDSTORGLOPT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "HYDSYSHIPTSEC_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "HYDSYSLOPT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "I15031SRV9NOXBIN_SC" "0"
    SYSTEM_CONSTANT "I15031SRV9VT_SC" "1"
    SYSTEM_CONSTANT "I15031SRV9VT_STORGRSTBHVR_SC" "1"
    SYSTEM_CONSTANT "I15031_CVNALG_SC" "1"
    SYSTEM_CONSTANT "I15031_CVN_CRC_DIABAS" "1"
    SYSTEM_CONSTANT "I15031_CVN_CRC_SECULIBS" "2"
    SYSTEM_CONSTANT "I15031_CVN_SHA_BCL" "3"
    SYSTEM_CONSTANT "I15031_CVN_SHA_HSM" "4"
    SYSTEM_CONSTANT "I15031_CVN_TIMER" "12000"
    SYSTEM_CONSTANT "I15031_ELEMSTRTSIZE_SC" "257"
    SYSTEM_CONSTANT "I15031_EXTCVNSTORGBHVR_SC" "1"
    SYSTEM_CONSTANT "I15031_ITID_RANGE_ARRAY_SIZE" "8"
    SYSTEM_CONSTANT "I15031_OBD_CNTL_SC" "2"
    SYSTEM_CONSTANT "I15031_PID6B_SC" "0"
    SYSTEM_CONSTANT "I15031_PID6F_SC" "0"
    SYSTEM_CONSTANT "I15031_PID94_SC" "0"
    SYSTEM_CONSTANT "I15031_PID_RANGE_ARRAY_SIZE" "8"
    SYSTEM_CONSTANT "I15031_SRV8_SY" "0"
    SYSTEM_CONSTANT "I15031_SRV9_VT_CAL_SUPP" "0"
    SYSTEM_CONSTANT "I15031_ST_SUPP_PID_SC" "0"
    SYSTEM_CONSTANT "I15031_VISYSIZE_SC" "256"
    SYSTEM_CONSTANT "I27145_CANID_SC" "0"
    SYSTEM_CONSTANT "I27145_SC" "0"
    SYSTEM_CONSTANT "IDEAL_GAS_VOL" "22.4"
    SYSTEM_CONSTANT "IDLSHTDWN_SY" "0"
    SYSTEM_CONSTANT "IGNCL_QAG_SY" "2"
    SYSTEM_CONSTANT "INIT_ZERO" "0"
    SYSTEM_CONSTANT "INJCRV_ANGLE" "0"
    SYSTEM_CONSTANT "INJCRV_INJMASSPIIFACT_SY" "1"
    SYSTEM_CONSTANT "INJCRV_TIME" "1"
    SYSTEM_CONSTANT "INJMSQ0P1_RES" "0.1"
    SYSTEM_CONSTANT "INJMSQ0P2_RES" "0.2"
    SYSTEM_CONSTANT "INJSYS_INJRLSSETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJSYS_POI1SETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJSYS_POI2SETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJSYS_POI3SETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJTIME_US_ZERO" "0"
    SYSTEM_CONSTANT "INJVLV_ABE_ACTIVE" "0"
    SYSTEM_CONSTANT "INJVLV_ABE_NOTACTIVE" "1"
    SYSTEM_CONSTANT "INJ_MASS100_MAX" "100"
    SYSTEM_CONSTANT "INJ_MASSCYC_MAX" "327.67"
    SYSTEM_CONSTANT "INJ_MASSCYC_MIN" "0"
    SYSTEM_CONSTANT "INJ_MASSCYC_RES" "0.01"
    SYSTEM_CONSTANT "INJ_MASSCYC_RES_INV" "100"
    SYSTEM_CONSTANT "INJ_MASSCYC_RES_REV" "100"
    SYSTEM_CONSTANT "INJ_MASSCYC_ZERO" "0"
    SYSTEM_CONSTANT "INJ_MASSINJ_RES" "0.01"
    SYSTEM_CONSTANT "INJ_MASSMIN_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPII1_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPII2_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPII3_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPOI0_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPOI1_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPOI2_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPOI3_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASS_MAX" "327.67"
    SYSTEM_CONSTANT "INJ_MASS_MIN" "0"
    SYSTEM_CONSTANT "INJ_MASS_ONE" "1"
    SYSTEM_CONSTANT "INJ_MASS_RES" "0.01"
    SYSTEM_CONSTANT "INJ_MASS_RES_INV" "100"
    SYSTEM_CONSTANT "INJ_MASS_ZERO" "0"
    SYSTEM_CONSTANT "INJ_QNTINJ_MAX" "100"
    SYSTEM_CONSTANT "INJ_QNTINJ_MIN" "0"
    SYSTEM_CONSTANT "INJ_QNTINJ_RES" "0.01"
    SYSTEM_CONSTANT "INJ_QNTINJ_ZERO" "0"
    SYSTEM_CONSTANT "INJ_QNT_RES" "0.1"
    SYSTEM_CONSTANT "INTKAIRT_INTKMNFLD_SC" "0"
    SYSTEM_CONSTANT "INTKAIRT_SNSR1POS_SC" "0"
    SYSTEM_CONSTANT "INTKAIRT_SNSR2POS_SC" "0"
    SYSTEM_CONSTANT "INTKAIRT_SNSR3POS_SC" "0"
    SYSTEM_CONSTANT "INTKAIRT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "IOEXTDEV_CJ260_SC" "0"
    SYSTEM_CONSTANT "IOEXTDEV_PORTEXP_SC" "0"
    SYSTEM_CONSTANT "IPDUM_SC" "1"
    SYSTEM_CONSTANT "IUMPR_SY" "1"
    SYSTEM_CONSTANT "IUMPR_VERS_SY" "1"
    SYSTEM_CONSTANT "I_COIL_MAX" "5000"
    SYSTEM_CONSTANT "I_COIL_MIN" "0"
    SYSTEM_CONSTANT "J1939NM_SC" "0"
    SYSTEM_CONSTANT "J1939RM_SC" "0"
    SYSTEM_CONSTANT "J1939TP_SC" "0"
    SYSTEM_CONSTANT "KAPPADRYAIR" "1.4"
    SYSTEM_CONSTANT "KAPPA_DRYAIR" "1.4"
    SYSTEM_CONSTANT "KD_PRAIL2Q_1_MAX" "0.5"
    SYSTEM_CONSTANT "KD_PRAIL2Q_1_NRM" "4"
    SYSTEM_CONSTANT "KD_PRC_RES" "0.000125"
    SYSTEM_CONSTANT "KGH_TO_KGS" "3600"
    SYSTEM_CONSTANT "KI_PRAIL2Q_1_MAX" "2"
    SYSTEM_CONSTANT "KI_PRAIL2Q_1_NRM" "1"
    SYSTEM_CONSTANT "KLINE_SY" "0"
    SYSTEM_CONSTANT "KP_LMBDREC2INJMASS_1_MAX" "250"
    SYSTEM_CONSTANT "KP_LMBDREC2INJMASS_1_NRM" "2"
    SYSTEM_CONSTANT "KP_LMBDREC2INJMASS_1_RES_REV" "4"
    SYSTEM_CONSTANT "KP_PRAIL2Q_1_MAX" "0.2"
    SYSTEM_CONSTANT "KP_PRAIL2Q_1_NRM" "2"
    SYSTEM_CONSTANT "L9779_SC" "0"
    SYSTEM_CONSTANT "L9959_SC" "0"
    SYSTEM_CONSTANT "L9966_SC" "2"
    SYSTEM_CONSTANT "LAMBDAREC_RESVAL" "0.001"
    SYSTEM_CONSTANT "LAMBDA_INJMASS_RES" "1450"
    SYSTEM_CONSTANT "LAMBDA_MIN" "0"
    SYSTEM_CONSTANT "LAMBDA_ONE" "1"
    SYSTEM_CONSTANT "LAMBDA_REC_ZERO" "0"
    SYSTEM_CONSTANT "LAMBDA_TEN" "10"
    SYSTEM_CONSTANT "LAMBDA_ZERO" "0"
    SYSTEM_CONSTANT "LAMCTLDESVAL_NUM" "2"
    SYSTEM_CONSTANT "LAMCTLGOV_NUM" "2"
    SYSTEM_CONSTANT "LAMCTLMON_DVT_MAX" "10"
    SYSTEM_CONSTANT "LAMCTLMON_NUM_RM" "2"
    SYSTEM_CONSTANT "LAMCTLMON_TIME_MAX" "20"
    SYSTEM_CONSTANT "LAMCTLPRECTL_NUM" "2"
    SYSTEM_CONSTANT "LAMCTL_ACTVMONFDBKCTL_BP" "1"
    SYSTEM_CONSTANT "LAMCTL_DFL" "0"
    SYSTEM_CONSTANT "LAMCTL_SWTACTV_BP" "0"
    SYSTEM_CONSTANT "LDCOM_SC" "0"
    SYSTEM_CONSTANT "LENGTH_MM_RES" "1"
    SYSTEM_CONSTANT "LENGTH_M_PER_KM" "1000"
    SYSTEM_CONSTANT "LINIPCORETYPE_SC" "1"
    SYSTEM_CONSTANT "LIN_SY" "1"
    SYSTEM_CONSTANT "LLIM_ACTIVE" "3"
    SYSTEM_CONSTANT "LLIM_OFF" "1"
    SYSTEM_CONSTANT "LLIM_STANDBY" "2"
    SYSTEM_CONSTANT "LSM_SY" "0"
    SYSTEM_CONSTANT "LSU_CT_SENSORS" "1"
    SYSTEM_CONSTANT "LSU_CT_SENSORS_MAX" "4"
    SYSTEM_CONSTANT "LSU_CT_SENSORS_SY" "1"
    SYSTEM_CONSTANT "LSU_CT_SENSORS_TWFLW_SYS" "1"
    SYSTEM_CONSTANT "MASS_CONV_G2MG" "1000"
    SYSTEM_CONSTANT "MASS_CONV_KG2G" "1000"
    SYSTEM_CONSTANT "MASS_MOL_EG" "28.5"
    SYSTEM_CONSTANT "MASS_Q1_RES_REV" "1"
    SYSTEM_CONSTANT "MDG1CPUDEVICE_SC" "14"
    SYSTEM_CONSTANT "MDG1CPUSTEP_SC" "110"
    SYSTEM_CONSTANT "MDG1CPUVENDOR_SC" "1"
    SYSTEM_CONSTANT "MEM_CENDIAGACTVD_SC" "1"
    SYSTEM_CONSTANT "MEM_DIAGACTVDEXTD_SC" "0"
    SYSTEM_CONSTANT "MILLMP_ENGSTRTWITH2SECCDN_SC" "0"
    SYSTEM_CONSTANT "MOCCOM_CO_CPUNEW_MSK" "1"
    SYSTEM_CONSTANT "MOCCOM_CO_NUM_ANSW" "16"
    SYSTEM_CONSTANT "MOCCOM_CO_PCPNEW_MSK" "4"
    SYSTEM_CONSTANT "MOCCOM_CO_PFCNEW_MSK" "2"
    SYSTEM_CONSTANT "MOCCPU_IT_SY" "5"
    SYSTEM_CONSTANT "MOCEMM_CO_ARYSIZE_SWERRPINREQ" "10"
    SYSTEM_CONSTANT "MOCEMM_CO_BACKWCMBPLTYMANYCORE_SHIFT" "24"
    SYSTEM_CONSTANT "MOCEMM_CO_CORE0_LCKSTEPCHK_ERROR" "7"
    SYSTEM_CONSTANT "MOCEMM_CO_CORE1_LCKSTEPCHK_ERROR" "8"
    SYSTEM_CONSTANT "MOCEMM_CO_CORE2_LCKSTEPCHK_ERROR" "11"
    SYSTEM_CONSTANT "MOCEMM_CO_CORE3_LCKSTEPCHK_ERROR" "12"
    SYSTEM_CONSTANT "MOCEMM_CO_HWLT_FWCHK_ERROR" "1"
    SYSTEM_CONSTANT "MOCEMM_CO_HWLT_LBIST_ERROR" "10"
    SYSTEM_CONSTANT "MOCEMM_CO_HWLT_MBIST_ERROR" "9"
    SYSTEM_CONSTANT "MOCEMM_CO_HWLT_MONBIST_ERROR" "3"
    SYSTEM_CONSTANT "MOCEMM_CO_HWLT_SFFDCHK_ERROR" "4"
    SYSTEM_CONSTANT "MOCEMM_CO_HWLT_STDBYSMUALVTEST_ERROR" "2"
    SYSTEM_CONSTANT "MOCEMM_CO_HWLT_TEMPCHK_ERROR" "5"
    SYSTEM_CONSTANT "MOCEMM_CO_HWLT_UCBCHK_ERROR" "6"
    SYSTEM_CONSTANT "MOCEMM_CO_NO_ERROR" "0"
    SYSTEM_CONSTANT "MOCEMM_CO_NROFALRMREG" "22"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_HW" "255"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_MOCADC" "9"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_MOCCOM" "0"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_MOCEMM" "3"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_MOCGTM" "7"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_MOCMEM" "1"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_MOCMPU" "10"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_MOCSCC" "8"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_MOCSOP" "2"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_MOFWDA" "4"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_OCWDATEST" "5"
    SYSTEM_CONSTANT "MOCEMM_CO_REQERRPIN_ID_SWSHRL2" "6"
    SYSTEM_CONSTANT "MOCFC_GTMCLKMON_SC" "0"
    SYSTEM_CONSTANT "MOCFC_GTMCONNTYP_SC" "1"
    SYSTEM_CONSTANT "MOCFC_NRCYCBLK_SC" "2"
    SYSTEM_CONSTANT "MOCFC_NRFASTCYCBLK_SC" "0"
    SYSTEM_CONSTANT "MOCFC_POSTBLDCHKS_SC" "0"
    SYSTEM_CONSTANT "MOCFC_SCCERRREACTN_SC" "1"
    SYSTEM_CONSTANT "MOCGTM_NRCMPERRBITS" "4"
    SYSTEM_CONSTANT "MOCIWDH_CO_CNTTSKTMESYNC" "1"
    SYSTEM_CONSTANT "MOCMEMSTRTUP_CO_TESTREQ" "51"
    SYSTEM_CONSTANT "MOCMEM_CONF_NOF_RAMCHK" "32"
    SYSTEM_CONSTANT "MOCMEM_CONF_NOF_ROMCHK" "250"
    SYSTEM_CONSTANT "MOCMEM_CO_CHKSUM_VAL_START" "4294967295"
    SYSTEM_CONSTANT "MOCMEM_CO_FASTROM_TEST_ERRSIMN" "50"
    SYSTEM_CONSTANT "MOCMEM_CO_NOCHECK" "85"
    SYSTEM_CONSTANT "MOCMEM_CO_PATTERN" "2863311530"
    SYSTEM_CONSTANT "MOCMEM_CO_PATTERN_55_IDX" "1"
    SYSTEM_CONSTANT "MOCMEM_CO_PATTERN_AA_IDX" "0"
    SYSTEM_CONSTANT "MOCMEM_CO_PATTERN_CPL" "1431655765"
    SYSTEM_CONSTANT "MOCMEM_CO_PATTERN_NUMBER" "2"
    SYSTEM_CONSTANT "MOCMEM_CO_RAM_TEST_ERRSIMN" "51"
    SYSTEM_CONSTANT "MOCMEM_CO_ROM_TEST_ERRSIMN" "51"
    SYSTEM_CONSTANT "MOCMEM_CO_STACK_CSA_TEST_ERRSIMN" "50"
    SYSTEM_CONSTANT "MOCMM_ABESHTOFFPAHTESTENA_SC" "1"
    SYSTEM_CONSTANT "MOCMM_CANSHOFFPAHTESTENA_SC" "0"
    SYSTEM_CONSTANT "MOCMM_FRSHOFFPAHTESTENA_SC" "0"
    SYSTEM_CONSTANT "MOCMM_HWLAYOUT_SC" "1"
    SYSTEM_CONSTANT "MOCMM_MCUINJSHTOFFPAHTESTENA_SC" "0"
    SYSTEM_CONSTANT "MOCMM_NROKRESP_SC" "0"
    SYSTEM_CONSTANT "MOCMM_NRTRCV_SC" "3"
    SYSTEM_CONSTANT "MOCMM_UCHIP_SC" "0"
    SYSTEM_CONSTANT "MOCPFC_CO_RINGBUFLENTISYNCN" "3"
    SYSTEM_CONSTANT "MOCSOP_CO_ACTIVE" "0"
    SYSTEM_CONSTANT "MOCSOP_CO_CANTESTICO_MSK" "1"
    SYSTEM_CONSTANT "MOCSOP_CO_CANTEST_WDAERR_MSK" "1"
    SYSTEM_CONSTANT "MOCSOP_CO_COM_MP_ARRAY_SIZE" "12"
    SYSTEM_CONSTANT "MOCSOP_CO_FRTESTICO_MSK" "2"
    SYSTEM_CONSTANT "MOCSOP_CO_FRTEST_WDAERR_MSK" "2"
    SYSTEM_CONSTANT "MOCSOP_CO_INACTIVE" "1"
    SYSTEM_CONSTANT "MOCSOP_CO_INHBLINE_ACTV" "0"
    SYSTEM_CONSTANT "MOCSOP_CO_INHBLINE_INACTV" "1"
    SYSTEM_CONSTANT "MOCSOP_CO_INJTESTICO_MSK" "1"
    SYSTEM_CONSTANT "MOCSOP_CO_INJTEST_WDAERR_MSK" "1"
    SYSTEM_CONSTANT "MOCSOP_CO_INJ_MP_ARRAY_SIZE" "10"
    SYSTEM_CONSTANT "MOCSOP_CO_MP_ARRAY_SIZE" "25"
    SYSTEM_CONSTANT "MOCSOP_CO_NO_OF_CTRL_LINES" "2"
    SYSTEM_CONSTANT "MOCSOP_CO_NO_OF_FB_LINES" "6"
    SYSTEM_CONSTANT "MOCSOP_CO_NO_OF_INHIBIT_LINES" "3"
    SYSTEM_CONSTANT "MOCSOP_CO_NO_OF_MAIN_PVMT_SIGNALS" "1"
    SYSTEM_CONSTANT "MOEXE_CO_NUM_CPUSEQ" "1"
    SYSTEM_CONSTANT "MOLMASS_RES" "0.01"
    SYSTEM_CONSTANT "MOMENT_INERTIA_RES" "100"
    SYSTEM_CONSTANT "MoXEMM_CO_CLEAR_ERROR" "65535"
    SYSTEM_CONSTANT "MO_2ECU_BP" "0"
    SYSTEM_CONSTANT "MO_AXLEHEV_BP" "2"
    SYSTEM_CONSTANT "MO_CMNDSLGSLSW_SC" "1"
    SYSTEM_CONSTANT "MO_ECOM_MSK" "128"
    SYSTEM_CONSTANT "MO_EMEM_MSK" "8"
    SYSTEM_CONSTANT "MO_EPCP_MSK" "64"
    SYSTEM_CONSTANT "MO_ERAM_MSK" "1"
    SYSTEM_CONSTANT "MO_EROMSPG_MSK" "2"
    SYSTEM_CONSTANT "MO_EROMXPG_MSK" "4"
    SYSTEM_CONSTANT "MO_EXTDTSK_SC" "0"
    SYSTEM_CONSTANT "MO_FRDMINTFRMETHOD_SC" "0"
    SYSTEM_CONSTANT "MO_HEV_BP" "0"
    SYSTEM_CONSTANT "MO_LBISTENA_SC" "0"
    SYSTEM_CONSTANT "MO_MAXVALINDCR_SC" "0"
    SYSTEM_CONSTANT "MO_NRSLOTS_SC" "1"
    SYSTEM_CONSTANT "MO_NRUSEDCORESFTY_SC" "2"
    SYSTEM_CONSTANT "MO_PHEV_BP" "1"
    SYSTEM_CONSTANT "MO_PRCMAX_SY" "256"
    SYSTEM_CONSTANT "MO_RAMCHKTYP_SC" "1"
    SYSTEM_CONSTANT "MO_REQRAMCHKEXT_MSK" "32"
    SYSTEM_CONSTANT "MO_REQROMCHKEXT_MSK" "16"
    SYSTEM_CONSTANT "MO_ROM_SY" "0"
    SYSTEM_CONSTANT "MO_SGR_BP" "3"
    SYSTEM_CONSTANT "MO_VDD5MONHWTYP_SC" "1"
    SYSTEM_CONSTANT "MRLY_STACTDSQENA_SC" "0"
    SYSTEM_CONSTANT "MSPERVOL_RES" "0.001"
    SYSTEM_CONSTANT "MSPERVOL_RES_REV" "1000"
    SYSTEM_CONSTANT "MS_O2_RES" "0.001"
    SYSTEM_CONSTANT "MS_O2_RES_REV" "1000"
    SYSTEM_CONSTANT "MS_SOXLDTOT_RES" "0.5"
    SYSTEM_CONSTANT "MS_SOXLDTOT_RES_FL" "0.5"
    SYSTEM_CONSTANT "MS_SOXLDTOT_RES_REV" "2"
    SYSTEM_CONSTANT "MS_SOXNOX_RES" "1e-005"
    SYSTEM_CONSTANT "MS_SOXNOX_RES_REV" "100000"
    SYSTEM_CONSTANT "MS_SOX_RES" "0.000305"
    SYSTEM_CONSTANT "MULTIHSS_SC" "0"
    SYSTEM_CONSTANT "M_NOXLD_LORES_RES" "0.004"
    SYSTEM_CONSTANT "M_NOXLD_LORES_RES_REV" "250"
    SYSTEM_CONSTANT "M_SOOT_RES1" "0.004"
    SYSTEM_CONSTANT "M_SOOT_RES1_REV" "250"
    SYSTEM_CONSTANT "NOINIDRV_SC" "0"
    SYSTEM_CONSTANT "NOREINI_SC" "1"
    SYSTEM_CONSTANT "NORM_AIRMASS_INJCRV_FACT1" "1280"
    SYSTEM_CONSTANT "NORM_DVOL_X_DT" "360000"
    SYSTEM_CONSTANT "NORM_HCMPTQ0P00000042HCMPT" "4"
    SYSTEM_CONSTANT "NORM_HCMPTQ0P82HCMPT" "8"
    SYSTEM_CONSTANT "NORM_MNOXLOAD2LR" "400"
    SYSTEM_CONSTANT "NORM_Q_BY_RHO" "1000"
    SYSTEM_CONSTANT "NORM_SEC_US" "1000000"
    SYSTEM_CONSTANT "NORM_TIME2LR" "100"
    SYSTEM_CONSTANT "NOXFLWEG_RES" "0.025"
    SYSTEM_CONSTANT "NOXFLW_RES" "0.001"
    SYSTEM_CONSTANT "NOXMASSFLW_RES" "0.001"
    SYSTEM_CONSTANT "NOXMASSFLW_RES_REV" "1000"
    SYSTEM_CONSTANT "NOX_FLD" "10"
    SYSTEM_CONSTANT "NOX_RES" "1"
    SYSTEM_CONSTANT "NRM_DVOL_X_DT" "360000"
    SYSTEM_CONSTANT "NRM_DVOL_X_DT_HIGH" "18000"
    SYSTEM_CONSTANT "NRM_EXPO_AG_CRS_HI_RESO" "7"
    SYSTEM_CONSTANT "NRM_EXPO_T_INC_PER_DUR_HI_RESO" "8"
    SYSTEM_CONSTANT "NRM_EXP_RES_TRIGO_FUNC" "12"
    SYSTEM_CONSTANT "NRM_Q_BY_RHO" "1000"
    SYSTEM_CONSTANT "NRM_VOL_L_TO_UL" "20"
    SYSTEM_CONSTANT "NSCDS_CT_SENSORS" "1"
    SYSTEM_CONSTANT "NSCLD_MTOTSTRTRGN_MIN" "0.001"
    SYSTEM_CONSTANT "NSCLD_RDCAGTMIN" "-1e-005"
    SYSTEM_CONSTANT "NSCMON_TIAFTLM_MAX" "65.536"
    SYSTEM_CONSTANT "NSCMON_UBINLAM_MAX" "2000"
    SYSTEM_CONSTANT "NSCRGN_TIME_100_RES" "0.01"
    SYSTEM_CONSTANT "NSC_ACTV_BP" "1"
    SYSTEM_CONSTANT "NSC_AMPTNOXLDUNLD_MAX" "0"
    SYSTEM_CONSTANT "NSC_AMPTNOXLDUNLD_MIN" "-10"
    SYSTEM_CONSTANT "NSC_AMPTNOXRGN_MAX" "0"
    SYSTEM_CONSTANT "NSC_AMPTNOX_MIN" "0"
    SYSTEM_CONSTANT "NSC_CT_SENSORS" "0"
    SYSTEM_CONSTANT "NSC_CT_SENSORS_SY" "0"
    SYSTEM_CONSTANT "NSC_CT_SENSORS_TWFLW_SYS" "0"
    SYSTEM_CONSTANT "NSC_MSO2_MIN" "0"
    SYSTEM_CONSTANT "NSC_MSPERVOL_MIN" "0"
    SYSTEM_CONSTANT "NSC_MSSOXNOX_MAX" "0.1"
    SYSTEM_CONSTANT "NSC_MSSOXNOX_MIN" "0"
    SYSTEM_CONSTANT "NSC_NOXMASSFLW_MIN" "0"
    SYSTEM_CONSTANT "NSC_NOX_ZERO" "0"
    SYSTEM_CONSTANT "NSC_SWTACTV_BP" "0"
    SYSTEM_CONSTANT "NSC_TIMEMAX_SY" "327.5"
    SYSTEM_CONSTANT "NUMCYLACT_SY" "4"
    SYSTEM_CONSTANT "NUMCYLCAL_SY" "1"
    SYSTEM_CONSTANT "NUMCYLMAX_SY" "4"
    SYSTEM_CONSTANT "NUMPSICCHP_SY" "1"
    SYSTEM_CONSTANT "NUM_CHIP" "1"
    SYSTEM_CONSTANT "O2MPT_RES_REV" "100"
    SYSTEM_CONSTANT "O2_RES" "1e-005"
    SYSTEM_CONSTANT "OBD_PHYSMEDM_SY" "0"
    SYSTEM_CONSTANT "OBS_SY" "0"
    SYSTEM_CONSTANT "OCWDA_CO_UBATTLOWLIM" "8000"
    SYSTEM_CONSTANT "OILCOOLRDST_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "OILLVL_MMQ0P004_RES" "0.004"
    SYSTEM_CONSTANT "OILLVL_MMQ0P004_RESREV" "250"
    SYSTEM_CONSTANT "OILMFL_MGPS_Q0P1_RES" "0.1"
    SYSTEM_CONSTANT "OILMFL_MGPS_Q0P1_RES_REV" "10"
    SYSTEM_CONSTANT "OILMSPRCQ0P01_100" "100"
    SYSTEM_CONSTANT "OILMSPRC_Q0P01_RES" "0.01"
    SYSTEM_CONSTANT "OILMSPRC_Q0P01_RES_REV" "100"
    SYSTEM_CONSTANT "OILMS_MG_RES" "1"
    SYSTEM_CONSTANT "OILMS_MG_RES_REV" "1"
    SYSTEM_CONSTANT "OILMS_Q0P1_RES" "0.1"
    SYSTEM_CONSTANT "OILMS_Q0P1_RES_REV" "10"
    SYSTEM_CONSTANT "OILMS_Q10_RES" "10"
    SYSTEM_CONSTANT "OILP_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "OILSWMPT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "OILT_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "PAIRFLTDS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "PASSDOORRDNT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "PERMSPLYSYS_SY" "0"
    SYSTEM_CONSTANT "PEXHMNFLD_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "PFLTLD_RO2EG" "0.2315"
    SYSTEM_CONSTANT "PFLTLD_RO2EGONE" "1"
    SYSTEM_CONSTANT "PFLTLD_RO2STOICH" "0.2315"
    SYSTEM_CONSTANT "PFLTLD_RO2STOICHONE" "1"
    SYSTEM_CONSTANT "PFLTPOPPRC_RES" "0.1"
    SYSTEM_CONSTANT "PFLT_ACTV_BP" "0"
    SYSTEM_CONSTANT "PHI_COR_MAX" "10"
    SYSTEM_CONSTANT "PHI_MI_EARL" "40"
    SYSTEM_CONSTANT "PHI_MI_LATE" "-10"
    SYSTEM_CONSTANT "PHI_PII_EARL_ABS" "100"
    SYSTEM_CONSTANT "PHI_PII_EARL_REL" "90"
    SYSTEM_CONSTANT "PHI_PII_LATE_REL" "5"
    SYSTEM_CONSTANT "PHI_POI0_EARLY" "-40"
    SYSTEM_CONSTANT "PHI_POI0_LATE" "-100"
    SYSTEM_CONSTANT "PHI_POI1_EARL" "-40"
    SYSTEM_CONSTANT "PHI_POI1_LATE" "-100"
    SYSTEM_CONSTANT "PHI_POI1_ZERO" "0"
    SYSTEM_CONSTANT "PHI_POI2_LATE" "-40"
    SYSTEM_CONSTANT "PHI_ZERO" "0"
    SYSTEM_CONSTANT "PI" "3.14159265359"
    SYSTEM_CONSTANT "PII321_MI1_POI321" "0"
    SYSTEM_CONSTANT "PII321_UNDEFD_MI1_POI21" "1"
    SYSTEM_CONSTANT "PIICLB_ANGLE32FAC2ANGLE_CNV" "6553600"
    SYSTEM_CONSTANT "PIICLB_FACTS32_RES" "65536"
    SYSTEM_CONSTANT "PIICLB_INJMASSS32_RES" "6553600"
    SYSTEM_CONSTANT "PIICLB_INJMASSS32_ZERO" "0"
    SYSTEM_CONSTANT "PIICLB_RCNFDMAX" "32766"
    SYSTEM_CONSTANT "PIICLB_STATE_CALC" "2"
    SYSTEM_CONSTANT "PIICLB_STATE_CLB" "1"
    SYSTEM_CONSTANT "PIICLB_STATE_INIT" "255"
    SYSTEM_CONSTANT "PIICLB_STATE_START" "0"
    SYSTEM_CONSTANT "PIICLB_STRLS_DISABLED" "1"
    SYSTEM_CONSTANT "PIICLB_STRLS_RELEASED" "0"
    SYSTEM_CONSTANT "PIICLB_TRQBYETA2QNT32_CNV" "83886080"
    SYSTEM_CONSTANT "PIICLB_TRQDT1KDMUL" "65536000"
    SYSTEM_CONSTANT "PIICLB_TRQPERSEC_RES" "1000"
    SYSTEM_CONSTANT "PIICLB_UPDT_COL" "1"
    SYSTEM_CONSTANT "PIICLB_UPDT_SEQ" "0"
    SYSTEM_CONSTANT "PIICLB_VARIANT_NONE" "0"
    SYSTEM_CONSTANT "PIICLB_VARIANT_PIC" "1"
    SYSTEM_CONSTANT "PIICLB_VARIANT_PICALL" "2"
    SYSTEM_CONSTANT "PINTKVUS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "PMAXCTL_FACKPNRM8" "8"
    SYSTEM_CONSTANT "PMP_QNT_MAX" "1500"
    SYSTEM_CONSTANT "PMP_QNT_RES" "0.1"
    SYSTEM_CONSTANT "PMP_QNT_ZERO" "0"
    SYSTEM_CONSTANT "PNRM" "1013"
    SYSTEM_CONSTANT "POILVT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "POSMCCTL_FACKDNRM4" "4"
    SYSTEM_CONSTANT "POSMCCTL_FACKINRM2" "2"
    SYSTEM_CONSTANT "POSMCCTL_FACKPNRM32" "32"
    SYSTEM_CONSTANT "POSTDRV_SOFTRST_SY" "0"
    SYSTEM_CONSTANT "POUTLVLVDS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "PPFLTDIFFASICT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "PPFLTDIFFCH1_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "PPFLTDIFFCH2_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "PPFLTDIFF_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "PPFLTDIFF_TYPTWINFLW_SC" "0"
    SYSTEM_CONSTANT "PPFLTDS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "PPFLTUS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "PRCFACT100_FULLNEG" "-100"
    SYSTEM_CONSTANT "PRCFACT100_FULLPOS" "100"
    SYSTEM_CONSTANT "PRCFACT100_ZERO" "0"
    SYSTEM_CONSTANT "PRC_M_100" "-100"
    SYSTEM_CONSTANT "PREFSCALE_RES" "1000"
    SYSTEM_CONSTANT "PRES_AIR_MAX" "3500"
    SYSTEM_CONSTANT "PRES_AIR_MIN" "0"
    SYSTEM_CONSTANT "PRES_BAR_RES" "1"
    SYSTEM_CONSTANT "PRES_HPA_2000" "2000"
    SYSTEM_CONSTANT "PRES_RAIL_GRADHI_TO_VAL" "60"
    SYSTEM_CONSTANT "PRES_RAIL_GRAD_TO_VAL" "4"
    SYSTEM_CONSTANT "PRES_RAIL_RES" "100"
    SYSTEM_CONSTANT "PRES_RAIL_RES_REV" "100"
    SYSTEM_CONSTANT "PRES_TIME_RES" "400"
    SYSTEM_CONSTANT "PRES_TIME_RES_REV" "400"
    SYSTEM_CONSTANT "PRKGHEATR_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "PSSCP1481VAR_SC" "0"
    SYSTEM_CONSTANT "PSSC_FIATCV_SY" "0"
    SYSTEM_CONSTANT "PS_NUMSENS_SY" "0"
    SYSTEM_CONSTANT "PTACTVN_SC" "0"
    SYSTEM_CONSTANT "PTHRVLVDS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "PTRBNABSLTUS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "PTRBNDS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "PTRBNUS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "PWRSQ_TEMPSQQ0P01_RES" "0.01"
    SYSTEM_CONSTANT "PWR_HIGH_RES_REV" "10"
    SYSTEM_CONSTANT "PWR_KW_RES" "0.01"
    SYSTEM_CONSTANT "PWR_Q1_RES" "1"
    SYSTEM_CONSTANT "PWR_Q50_RES" "50"
    SYSTEM_CONSTANT "PWR_TEMPQ0P001_RES" "0.01"
    SYSTEM_CONSTANT "PWR_TEMPQ0P1_RES" "0.1"
    SYSTEM_CONSTANT "PWR_W_ZERO" "0"
    SYSTEM_CONSTANT "PWR_ZERO" "0"
    SYSTEM_CONSTANT "QCKSTRTSPCVERS_SC" "2"
    SYSTEM_CONSTANT "QNTR_EXP" "10"
    SYSTEM_CONSTANT "QNTR_MAX" "24"
    SYSTEM_CONSTANT "QNTR_MIN" "0.0009765625"
    SYSTEM_CONSTANT "QNTR_RES" "0.0009765625"
    SYSTEM_CONSTANT "QNTR_RES_REV" "1024"
    SYSTEM_CONSTANT "QNTSEL_SY" "0"
    SYSTEM_CONSTANT "Qp_RES" "10"
    SYSTEM_CONSTANT "RAIL_MEUN" "1"
    SYSTEM_CONSTANT "RAIL_PCV" "0"
    SYSTEM_CONSTANT "RAIL_PRES_ZERO" "0"
    SYSTEM_CONSTANT "RATAM_RES" "0.01"
    SYSTEM_CONSTANT "RATAM_RES_HIGH" "0.001"
    SYSTEM_CONSTANT "RATAM_RES_REV" "100"
    SYSTEM_CONSTANT "RATAM_RES_REV_HIGH" "1000"
    SYSTEM_CONSTANT "RATCM_RES" "1e-006"
    SYSTEM_CONSTANT "RATO2DRYAIR" "0.2315"
    SYSTEM_CONSTANT "RATPCRITAIR" "0.52828199"
    SYSTEM_CONSTANT "RAT_AIR_PRES_RES" "0.001"
    SYSTEM_CONSTANT "RAT_HIGH_RES" "0.001"
    SYSTEM_CONSTANT "RAT_HIGH_RES_REV" "1000"
    SYSTEM_CONSTANT "RAT_HIRES_CPP" "0.0001"
    SYSTEM_CONSTANT "RAT_HIRES_CPP_REV" "10000"
    SYSTEM_CONSTANT "RBANDSTYPE_SC" "2"
    SYSTEM_CONSTANT "RBA_SWTRACEENA_SC" "0"
    SYSTEM_CONSTANT "RBPTCEL_A_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_CLUCLSD" "0"
    SYSTEM_CONSTANT "RBPTCEL_CLUGEARDISENGMT" "5"
    SYSTEM_CONSTANT "RBPTCEL_CLUGEARSHIFT" "7"
    SYSTEM_CONSTANT "RBPTCEL_CLULNCH" "3"
    SYSTEM_CONSTANT "RBPTCEL_CLUOPEN" "1"
    SYSTEM_CONSTANT "RBPTCEL_CLUSHIFTSUPRT" "6"
    SYSTEM_CONSTANT "RBPTCEL_CLUTQTRCK" "4"
    SYSTEM_CONSTANT "RBPTCEL_CLUTRAN" "2"
    SYSTEM_CONSTANT "RBPTCEL_CNVN_F_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_CNVN_P_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_DST_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_FRQ_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_F_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_GRDTN_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_GRDTRAT_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_I_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_MOFDISCNCT_CMDCHRGCLSD" "4"
    SYSTEM_CONSTANT "RBPTCEL_MOFDISCNCT_CMDCLSD" "2"
    SYSTEM_CONSTANT "RBPTCEL_MOFDISCNCT_CMDDCHACLSD" "5"
    SYSTEM_CONSTANT "RBPTCEL_MOFDISCNCT_CMDOPEN" "0"
    SYSTEM_CONSTANT "RBPTCEL_P_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_RAT" "0"
    SYSTEM_CONSTANT "RBPTCEL_RAT_1" "100"
    SYSTEM_CONSTANT "RBPTCEL_RAT_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_RMDETNUS_BITPOSN_0" "0"
    SYSTEM_CONSTANT "RBPTCEL_SPD_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_SSWTSECVC_DISAD" "0"
    SYSTEM_CONSTANT "RBPTCEL_SSWTSECVC_ENAD" "1"
    SYSTEM_CONSTANT "RBPTCEL_TI_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_TQ_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_T_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_U_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_VF_ZR" "0"
    SYSTEM_CONSTANT "RBPTCEL_V_ZR" "0"
    SYSTEM_CONSTANT "RBR_ETH_MAX_NO_OF_LOCAL_TCP_CLIENTS_SC" "0"
    SYSTEM_CONSTANT "RBR_ETH_MAX_NO_OF_REMOTE_TCP_CLIENTS_SC" "0"
    SYSTEM_CONSTANT "RBR_ETH_MAX_NO_OF_REMOTE_UDP_ECUS_SC" "0"
    SYSTEM_CONSTANT "RBR_OUT_NUM_DGDI_SC" "3"
    SYSTEM_CONSTANT "RBR_RTS_VARIANT_SC" "1"
    SYSTEM_CONSTANT "RBR_UDS_DID_F181_CONFIGURED_IN_eC_SC" "0"
    SYSTEM_CONSTANT "RBR_UDS_DID_F18C_CONFIGURED_IN_eC_SC" "0"
    SYSTEM_CONSTANT "RBR_UDS_DID_F193_CONFIGURED_IN_eC_SC" "0"
    SYSTEM_CONSTANT "RCPTSRC_BRKPEDL" "2"
    SYSTEM_CONSTANT "RESIST_RES" "0.1"
    SYSTEM_CONSTANT "RESO_T_INC_PER_DUR_TTH_ADAP" "10"
    SYSTEM_CONSTANT "REVCNT_RES" "16"
    SYSTEM_CONSTANT "REVCNT_RES_EXP" "4"
    SYSTEM_CONSTANT "REVGEAR1" "-1"
    SYSTEM_CONSTANT "RHO_FUEL_RES" "0.1"
    SYSTEM_CONSTANT "RHUSTGYPRS_SY" "0"
    SYSTEM_CONSTANT "RMPSQRVLG_S_1000_REF" "1000"
    SYSTEM_CONSTANT "RMPSQRVLG_S_100_REF" "100"
    SYSTEM_CONSTANT "RMPSQRVLG_S_REF" "1000"
    SYSTEM_CONSTANT "RMPSQRVLG_S_RES" "65536"
    SYSTEM_CONSTANT "RMTAPP_ENBL_SY" "0"
    SYSTEM_CONSTANT "RNOX_ZERO" "0"
    SYSTEM_CONSTANT "RTS_CANOPEN_CONFIGURED_SC" "0"
    SYSTEM_CONSTANT "R_COIL_MAX" "5000"
    SYSTEM_CONSTANT "R_COIL_MIN" "0"
    SYSTEM_CONSTANT "R_RES" "1"
    SYSTEM_CONSTANT "SCALEFACDIV_RES" "200"
    SYSTEM_CONSTANT "SCR_AMPERE_RES_REV" "5"
    SYSTEM_CONSTANT "SCR_DCU17SASW_SC" "0"
    SYSTEM_CONSTANT "SCR_DTTEMP_RES_REV" "10"
    SYSTEM_CONSTANT "SCR_FLVOL_RES_REV" "20"
    SYSTEM_CONSTANT "SCR_KPA_100_RES_REV" "0.01"
    SYSTEM_CONSTANT "SCR_KPA_10_RES_REV" "0.1"
    SYSTEM_CONSTANT "SCR_NOXFLW_RES_REV" "1000"
    SYSTEM_CONSTANT "SCR_ONEMIOPPMNOX_SY" "1000000"
    SYSTEM_CONSTANT "SCR_PRES_HPA_RES_REV" "1"
    SYSTEM_CONSTANT "SCR_SY" "0"
    SYSTEM_CONSTANT "SCR_SYSVRNT_SC" "61"
    SYSTEM_CONSTANT "SCR_UC_VOLT_RES_REV" "10"
    SYSTEM_CONSTANT "SCR_VOLTQ0P0001227_RES" "0.0001220703125"
    SYSTEM_CONSTANT "SCR_VOLT_Q0P002_RES_REV" "500"
    SYSTEM_CONSTANT "SCTPMP1T_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "SD_SC" "0"
    SYSTEM_CONSTANT "SEAWTRP_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "SEAWTRT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "SECULIBS_VAR_SY" "999"
    SYSTEM_CONSTANT "SECUPCK_SC" "1"
    SYSTEM_CONSTANT "SEC_RES" "1"
    SYSTEM_CONSTANT "SENTIPCORETYPE_SC" "0"
    SYSTEM_CONSTANT "SENT_SC" "1"
    SYSTEM_CONSTANT "SETPOINTCALC_TRQBASED_SY" "0"
    SYSTEM_CONSTANT "SFTYHW_ETHSHTOFFPAHTESTENA_SC" "0"
    SYSTEM_CONSTANT "SIA_OEM" "1"
    SYSTEM_CONSTANT "SIA_RB" "0"
    SYSTEM_CONSTANT "SIGNALS_AUTOPIDTABLE_SUPPORTED" "0"
    SYSTEM_CONSTANT "SIGNALS_BIT_DATATYPE_SUPPORTED" "0"
    SYSTEM_CONSTANT "SIGNALS_EXT2INT_2DARRAY_SUPPORTED" "0"
    SYSTEM_CONSTANT "SIGNALS_FLOAT_SUPPORTED" "1"
    SYSTEM_CONSTANT "SIGNALS_FORCE_PAVAST_IMPORT_STANDARD_SUPPORTED" "0"
    SYSTEM_CONSTANT "SIGNALS_INT2EXT_2DARRAY_SUPPORTED" "0"
    SYSTEM_CONSTANT "Signals_Mode1PidSize_SY" "207"
    SYSTEM_CONSTANT "Signals_NumberPID_SY" "68"
    SYSTEM_CONSTANT "Signals_NumberSigNumExt_SY" "3"
    SYSTEM_CONSTANT "Signals_NumberSigNumIntStd_SY" "106"
    SYSTEM_CONSTANT "Signals_NumberSigNumInt_SY" "112"
    SYSTEM_CONSTANT "SIGNALS_OBDDIDSUPRT_SC" "0"
    SYSTEM_CONSTANT "SIGNALS_STDARRSIG_SUPPORTED" "0"
    SYSTEM_CONSTANT "Signals_SupportArray_Length_SY" "0"
    SYSTEM_CONSTANT "SIGNALS_VIRTUAL_BITFIELD_1003" "112"
    SYSTEM_CONSTANT "SIGQLY_FROZEN" "32"
    SYSTEM_CONSTANT "SIGQLY_INIT" "2"
    SYSTEM_CONSTANT "SIGQLY_INVALID" "64"
    SYSTEM_CONSTANT "SIGQLY_MODEL" "8"
    SYSTEM_CONSTANT "SIGQLY_NOTCALC" "1"
    SYSTEM_CONSTANT "SIGQLY_OK" "4"
    SYSTEM_CONSTANT "SIGQLY_REPLACEMENT" "16"
    SYSTEM_CONSTANT "Sig_I15031_LeanAppl_SY" "0"
    SYSTEM_CONSTANT "SOTMASSPERSEC_RES" "0.1"
    SYSTEM_CONSTANT "SOTMASSPERSEC_RES_REV" "10"
    SYSTEM_CONSTANT "SPAVEL_RES" "10"
    SYSTEM_CONSTANT "SPECHEATFINE_RES_REV" "5"
    SYSTEM_CONSTANT "SPECHEAT_RES" "2"
    SYSTEM_CONSTANT "SPECIFICHEAT_RES" "0.0001"
    SYSTEM_CONSTANT "SPECIFICHEAT_RES_REV" "10000"
    SYSTEM_CONSTANT "STOPLMP_ATSINTVMOD_SY" "0"
    SYSTEM_CONSTANT "STOPLMP_PSPRS_SY" "0"
    SYSTEM_CONSTANT "STOPLMP_REDSTOPLAMPENA_SC" "1"
    SYSTEM_CONSTANT "STRTTRQ_OFF" "0"
    SYSTEM_CONSTANT "STRTTRQ_ON" "1"
    SYSTEM_CONSTANT "STSP_SY" "0"
    SYSTEM_CONSTANT "SVS_SY" "0"
    SYSTEM_CONSTANT "SWT_DISABLED" "0"
    SYSTEM_CONSTANT "SWT_ENABLED" "1"
    SYSTEM_CONSTANT "SYC_AFTRUNDIAG_SC" "0"
    SYSTEM_CONSTANT "SYC_CAL_PERMSPLYSYS_SY" "0"
    SYSTEM_CONSTANT "SYC_CNTPOSTDRV_SC" "0"
    SYSTEM_CONSTANT "SYC_COORD_SC" "0"
    SYSTEM_CONSTANT "SYC_DRIVE" "4"
    SYSTEM_CONSTANT "SYC_ENALCYPROLG_SC" "0"
    SYSTEM_CONSTANT "SYC_FSTSWOFF_SY" "0"
    SYSTEM_CONSTANT "SYC_INI" "0"
    SYSTEM_CONSTANT "SYC_INIEND" "2"
    SYSTEM_CONSTANT "SYC_INISYN" "1"
    SYSTEM_CONSTANT "SYC_POSTDRIVE" "5"
    SYSTEM_CONSTANT "SYC_POST_OS_EXIT" "6"
    SYSTEM_CONSTANT "SYC_PREDRIVE" "3"
    SYSTEM_CONSTANT "SYC_PREDRV_NWM" "4"
    SYSTEM_CONSTANT "SYC_PROLGPREDRV_SC" "0"
    SYSTEM_CONSTANT "SYC_SYSTYP_SC" "0"
    SYSTEM_CONSTANT "SYC_T15POSTPREDRV_SWRST_SY" "0"
    SYSTEM_CONSTANT "SYSA_DSQACTVT_SC" "1"
    SYSTEM_CONSTANT "SYSB_PHYTERMINAL15_SC" "1"
    SYSTEM_CONSTANT "SYSDIAG_NRAFTRUNCOORRARRELEM_SC" "0"
    SYSTEM_CONSTANT "SY_ATMTURB" "0"
    SYSTEM_CONSTANT "SY_CNG" "0"
    SYSTEM_CONSTANT "SY_DLDP" "0"
    SYSTEM_CONSTANT "SY_DMDSTQ" "1"
    SYSTEM_CONSTANT "SY_DMTL" "0"
    SYSTEM_CONSTANT "SY_DSPACE" "0"
    SYSTEM_CONSTANT "SY_HEV" "0"
    SYSTEM_CONSTANT "SY_KORRZ" "1"
    SYSTEM_CONSTANT "SY_KT" "0"
    SYSTEM_CONSTANT "SY_LAYER" "0"
    SYSTEM_CONSTANT "SY_MDMXEXC" "1"
    SYSTEM_CONSTANT "SY_NVLD" "0"
    SYSTEM_CONSTANT "SY_PTL" "0"
    SYSTEM_CONSTANT "SY_PTO" "0"
    SYSTEM_CONSTANT "SY_SGANZ" "1"
    SYSTEM_CONSTANT "SY_SVBB" "1"
    SYSTEM_CONSTANT "SY_TEETH" "60"
    SYSTEM_CONSTANT "SY_UBSQ_W" "1"
    SYSTEM_CONSTANT "SY_WFS" "2"
    SYSTEM_CONSTANT "SY_WNBM" "1"
    SYSTEM_CONSTANT "SY_ZYLZA" "6"
    SYSTEM_CONSTANT "SY_ZYLZG" "6"
    SYSTEM_CONSTANT "T15RAWDSQENA_SC" "0"
    SYSTEM_CONSTANT "T15_WKDETN_SC" "0"
    SYSTEM_CONSTANT "TBLOWBYHEATR_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TDC_ADAP_SY" "0"
    SYSTEM_CONSTANT "TDC_UNEQLGEOM_SY" "0"
    SYSTEM_CONSTANT "TECU_SMP480SENSPRS_SC" "0"
    SYSTEM_CONSTANT "TECU_TMSGFMT_SC" "1"
    SYSTEM_CONSTANT "TEGMOD_HEATFLOWKW_RES" "100000"
    SYSTEM_CONSTANT "TEGMOD_HEATFLOW_INTER_RES" "360"
    SYSTEM_CONSTANT "TEGMOD_HEATKJ_RES" "100"
    SYSTEM_CONSTANT "TEGMOD_INTER_RES" "1"
    SYSTEM_CONSTANT "TEGRCLR2DS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "TEGRCLRDS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "TEGRCLRLPDS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TEGRCLRUS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "TEGRVLVHOTDS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TEMPCELS_ZERO" "0"
    SYSTEM_CONSTANT "TEMP_20_CELS" "20"
    SYSTEM_CONSTANT "TEMP_CELS_1200" "1200"
    SYSTEM_CONSTANT "TEMP_CELS_150" "150"
    SYSTEM_CONSTANT "TEMP_CELS_1500" "1500"
    SYSTEM_CONSTANT "TEMP_CELS_MAX" "3003.56"
    SYSTEM_CONSTANT "TEMP_CELS_MIN" "-3549.94"
    SYSTEM_CONSTANT "TEMP_CELS_M_100" "-100"
    SYSTEM_CONSTANT "TEMP_CELS_M_200" "-200"
    SYSTEM_CONSTANT "TEMP_DEFECT" "1"
    SYSTEM_CONSTANT "TEMP_KELV_1000" "1000"
    SYSTEM_CONSTANT "TEMP_KELV_1200" "1200"
    SYSTEM_CONSTANT "TEMP_KELV_M_1000" "-1000"
    SYSTEM_CONSTANT "TEMP_KELV_M_200" "-200"
    SYSTEM_CONSTANT "THRVLVI_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "THRVLVUST_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TIMEDELAY_S_2_MIN" "0.001"
    SYSTEM_CONSTANT "TIMEDELAY_S_2_NRM" "8"
    SYSTEM_CONSTANT "TIME_5S_NRM_SY" "5"
    SYSTEM_CONSTANT "TIME_DEB_10MS" "10000"
    SYSTEM_CONSTANT "TIME_DT_1000MS" "1000000"
    SYSTEM_CONSTANT "TIME_DT_100MS" "100000"
    SYSTEM_CONSTANT "TIME_DT_10MS" "10000"
    SYSTEM_CONSTANT "TIME_DT_1S" "1000000"
    SYSTEM_CONSTANT "TIME_DT_200MS" "200000"
    SYSTEM_CONSTANT "TIME_MS_10MS_RES" "10"
    SYSTEM_CONSTANT "TIME_S_100US_RES" "0.0001"
    SYSTEM_CONSTANT "TIME_S_100US_RES_REV" "10000"
    SYSTEM_CONSTANT "TIME_S_12000" "12000"
    SYSTEM_CONSTANT "TIME_S_LORES_ONE" "1"
    SYSTEM_CONSTANT "Time_s_LORES_RES" "1"
    SYSTEM_CONSTANT "Time_s_LORES_RES_REV" "1"
    SYSTEM_CONSTANT "TIME_S_LORES_ZERO" "0"
    SYSTEM_CONSTANT "TIME_S_NSCRGN_MAX" "327.66"
    SYSTEM_CONSTANT "TIME_TICK_SEC_INV" "100"
    SYSTEM_CONSTANT "TINTKVUS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "TI_PII_EARL_REL" "13000"
    SYSTEM_CONSTANT "TI_POI2_LATE_REL" "-13000"
    SYSTEM_CONSTANT "TLE7244_SC" "1"
    SYSTEM_CONSTANT "TLE75602_SC" "0"
    SYSTEM_CONSTANT "TNRM" "0"
    SYSTEM_CONSTANT "TOTENGREV_SC" "1"
    SYSTEM_CONSTANT "TOXDCAT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TOXICATDS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "TOXICATUS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "TPFLTDS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "TPFLTUS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "TPS65917_SC" "0"
    SYSTEM_CONSTANT "TRA_AST" "2"
    SYSTEM_CONSTANT "TRA_AT" "1"
    SYSTEM_CONSTANT "TRA_CVT" "3"
    SYSTEM_CONSTANT "TRA_DCT" "4"
    SYSTEM_CONSTANT "TRA_MT" "0"
    SYSTEM_CONSTANT "TRBCHINSDT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TRBHP2I_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TRBHPBYPI_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TRBHPI_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TRBLPI_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TRBNBYVLV1INSDT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TRBNBYVLV2INSDT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TRQSEL_SY" "1"
    SYSTEM_CONSTANT "TRQ_ZERO" "0"
    SYSTEM_CONSTANT "TTRBNUS_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "TTRBUSASICT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "TWALLTC_MDLAVL_SC" "0"
    SYSTEM_CONSTANT "TWCOR_HIRES_SC" "0"
    SYSTEM_CONSTANT "TWO_POW_NRM_EXP_RES_TRIGO_FUNC" "4096"
    SYSTEM_CONSTANT "TWTRCOOLRDS_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "T_EXHGS_MAX" "1050"
    SYSTEM_CONSTANT "T_EXHGS_MIN" "-45"
    SYSTEM_CONSTANT "UART_SY" "0"
    SYSTEM_CONSTANT "UCATDST2_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "UCATDST_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "UCATUST2_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "UCATUST_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "UDPNM_SC" "0"
    SYSTEM_CONSTANT "VCRTYP_SC" "0"
    SYSTEM_CONSTANT "VEHTYP_SC" "2"
    SYSTEM_CONSTANT "VEL_KMH_0" "0"
    SYSTEM_CONSTANT "VEL_KMH_300" "300"
    SYSTEM_CONSTANT "VEL_KMH_M_300" "-300"
    SYSTEM_CONSTANT "VIRTETH_SC" "0"
    SYSTEM_CONSTANT "VLVLFTI_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "VNQ6040_SC" "0"
    SYSTEM_CONSTANT "VOL_FILGLVL_RES" "1"
    SYSTEM_CONSTANT "VOL_FILGLVL_RES_REV" "1"
    SYSTEM_CONSTANT "VOL_NSC_RES" "0.0001"
    SYSTEM_CONSTANT "VOL_NSC_RES_FL" "0.0001"
    SYSTEM_CONSTANT "VOL_NSC_RES_REV" "10000"
    SYSTEM_CONSTANT "VOL_RES_REV" "100"
    SYSTEM_CONSTANT "VSWVLVI_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "V_CAM_RES_REV" "256"
    SYSTEM_CONSTANT "WDGS_CFGADPR_SC" "1"
    SYSTEM_CONSTANT "WHRCOOLTPDIF_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "WRNLMP_AMBERWARNLAMPENA_SC" "1"
    SYSTEM_CONSTANT "WRNLMP_ATSINTVMOD_SY" "0"
    SYSTEM_CONSTANT "WRNLMP_PSPRS_SY" "0"
    SYSTEM_CONSTANT "WTRCACT_TYPAVL_SC" "0"
    SYSTEM_CONSTANT "WTRCOOLTP1_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "WTRCOOLTP_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "XCORECDD_SC" "0"
    SYSTEM_CONSTANT "XCPVERS_SC" "3"
    SYSTEM_CONSTANT "XCP_SY" "1"
    SYSTEM_CONSTANT "XDI_SC" "1"
    SYSTEM_CONSTANT "ZERO" "0"
    
  /end MOD_PAR

  /begin MOD_COMMON ""
    BYTE_ORDER MSB_LAST
    ALIGNMENT_BYTE 1
    ALIGNMENT_WORD 2
    ALIGNMENT_LONG 4
    ALIGNMENT_INT64 4
    ALIGNMENT_FLOAT32_IEEE 4
    ALIGNMENT_FLOAT64_IEEE 4
    DATA_SIZE 32
  /end MOD_COMMON

    /begin IF_DATA ASAP1B_Bypass 
        /begin TP_BLOB 
          0x102        /* Bypass version */ 
          0x102      /* Blob version */ 
        /end TP_BLOB 
    /end IF_DATA 
    
  /begin IF_DATA ETK_XETK

      /begin ETK_XETK_LIST
       /* version   */ ETK_XETK_AML_VERSION_2_3_0
        /begin ETK
          1 /* ETK_XETK_ID   */
          INTERFACE_SPEED_100MBIT /* Interface   */
          CONFIG "CpuType" "TC39xED_B"
          CONFIG "EtkId" "162"
          CONFIG "EtkSubId" "0"
          CONFIG "HardwAdvId" "0"
          CONFIG "TriggerInterface" "reg"
          CONFIG "PullCalWakeup" "0"
          CONFIG "WatchdogDisable" "1"
          CONFIG "RegPollRate" "50"
          CONFIG "PowerFailDetection" "SBRAM"
          CONFIG "Startup" "reg"
          CONFIG "StartupTimeout" "-1"
          CONFIG "DebArb" "1"
          CONFIG "WatchdogPolarity" "1"
          CONFIG "DapClockSpeed" "100"
          CONFIG "DapBlock" "1"
          CONFIG "Dap2Pin" "0"
          DISPLAY_NAME "ETK-S20/21"
        /end ETK
        /begin XETK
           2 /* ETK_XETK_ID  BR-XETK-S3 */
          CONFIG "CpuType" "TC39xED_B"
          CONFIG "BaseId" "21"
          CONFIG "Extension" "1"
          CONFIG "DapClockSpeed" "100"
          CONFIG "DapBlock" "1"
          CONFIG "Dap2Pin" "0"
          CONFIG "EcuWatchdogPolarity" "1"
          CONFIG "HandshakeTimeout" "-1"
          CONFIG "EcuTrigRegPollRate" "50"
          CONFIG "PowerFailDetection" "SBRAM"
          CONFIG "TriggerInterface" "reg"
          CONFIG "EcuWatchdogControlDisabled"  "0"
          CONFIG "EcuWatchdogEnabled"  "1"
          DISPLAY_NAME "BR-XETK-S3"
        /end XETK
        /begin XETK
            3 /* ETK_XETK_ID   */
          CONFIG "CpuType" "TC39xED_B"
          CONFIG "BaseId" "11"
          CONFIG "Extension" "1"
          CONFIG "DapClockSpeed" "100"
          CONFIG "DapBlock" "1"
          CONFIG "Dap2Pin" "0"
          CONFIG "EcuWatchdogPolarity" "1"
          CONFIG "HandshakeTimeout" "-1"
          CONFIG "EcuTrigRegPollRate" "50"
          CONFIG "PowerFailDetection" "SBRAM"
          CONFIG "TriggerInterface" "reg"
          CONFIG "EcuWatchdogControlDisabled"  "0"
          CONFIG "EcuWatchdogEnabled"  "1"
            DISPLAY_NAME "XETK-S20/21"
        /end XETK
        /begin XETK
           4 /* ETK_XETK_ID   */
          CONFIG "CpuType" "TC39xED_B"
          CONFIG "BaseId" "14"
          CONFIG "Extension" "1"
          CONFIG "DapClockSpeed" "100"
          CONFIG "DapBlock" "1"
          CONFIG "Dap2Pin" "0"
          CONFIG "EcuWatchdogPolarity" "1"
          CONFIG "HandshakeTimeout" "-1"
          CONFIG "EcuTrigRegPollRate" "50"
          CONFIG "PowerFailDetection" "SBRAM"
          CONFIG "TriggerInterface" "reg"
          CONFIG "EcuWatchdogControlDisabled"  "0"
          CONFIG "EcuWatchdogEnabled"  "1"
            DISPLAY_NAME "XETK-S30/31"
        /end XETK
        /begin XETK
           5 /* ETK_XETK_ID   */
          CONFIG "CpuType" "TC39xED_B"
          CONFIG "BaseId" "16"
          CONFIG "Extension" "1"
          CONFIG "DapClockSpeed" "100"
          CONFIG "DapBlock" "1"
          CONFIG "Dap2Pin" "0"
          CONFIG "EcuWatchdogPolarity" "1"
          CONFIG "HandshakeTimeout" "-1"
          CONFIG "EcuTrigRegPollRate" "50"
          CONFIG "PowerFailDetection" "SBRAM"
          CONFIG "TriggerInterface" "reg"
          CONFIG "EcuWatchdogControlDisabled"  "0"
          CONFIG "EcuWatchdogEnabled"  "1"
            DISPLAY_NAME "BR-XETK-S1/2"
        /end XETK
        /begin FETK
           7 /* ETK_XETK_ID   */
          CONFIG "CpuType" "TC39xED_B"
          CONFIG "BaseId" "6"
          CONFIG "Extension" "0"
          CONFIG "DapClockSpeed" "100"
          CONFIG "Dap2Pin" "0"
          CONFIG "WatchdogControlDisabled"  "0"
          CONFIG "WatchdogDisable"  "0"
          CONFIG "WatchdogPolarity" "1"
          CONFIG "StartupTimeout" "-1"
          DISPLAY_NAME "FETK-T1/2 (Serial debug interface based data acquisition)"
        /end FETK
        /begin FETK
           8 /* ETK_XETK_ID   */
          CONFIG "CpuType" "TC39xED_B"
          CONFIG "BaseId" "7"
          CONFIG "Extension" "0"
          CONFIG "DapClockSpeed" "100"
          CONFIG "Dap2Pin" "0"
          CONFIG "WatchdogControlDisabled"  "0"
          CONFIG "WatchdogDisable"  "0"
          CONFIG "WatchdogPolarity" "1"
          CONFIG "StartupTimeout" "-1"
          DISPLAY_NAME "FETK-S1/2 "
        /end FETK

    /begin RASTER_CHECK
        OFFLINE_DEVICE 1 /* device with id 1 is the default device for offline raster check */
        ONLINE_RESPECT_OFFLINE_LIMIT
    /end RASTER_CHECK

      /end ETK_XETK_LIST

    /begin TP_BLOB
       /* ByteOrder */ BYTE_ORDER_MSB_LAST

       /begin DISTAB_CFG
         /* Distab Type */ 17
       /end DISTAB_CFG

    /begin ECU_EVENT_LIST
      0xB93F09B8 /* start address of ECU event list        */
     ETK_XETK_REF 1 2 3 4 5 7 8
    /end ECU_EVENT_LIST
    TABLE_ALIGNMENT ALIGNMENT_4_BYTE
    /begin EVENT_CONFIG_OUTPUT_AREA
      0xB93FB6F0 /* start of event config area */
      12324 /* size in bytes of event config area */
      0xB93FE714 /* start of event output area */
      6144 /* size in bytes of event output area */
      ETK_XETK_REF 1 2 3 4 5 7 8
    /end EVENT_CONFIG_OUTPUT_AREA
    /begin DATA_ACQUISITION
      PRIORITY_RANGE 1 3
      ETK_XETK_REF 1 2 3 4 5 7 8
    /end DATA_ACQUISITION
    /begin ECU_PROPERTY
      OVERALL_PERFORMANCE 303030 1212120
      CORE_PERFORMANCE 3 303030 1212120
      CORE_PERFORMANCE 1 454545 1818180
      CORE_PERFORMANCE 2 454545 1818180
      ETK_XETK_REF 1 2 3 4 5 7 8
    /end ECU_PROPERTY
    /begin TRIGGER_CFG
      TRIGGER 30  DIRECT ECU_ID 30
      TRIGGER 31  DIRECT ECU_ID 31
      TRIGGER 32  DIRECT ECU_ID 32
      ETK_XETK_REF 1 2 3 4 5
    /end TRIGGER_CFG
    /begin TRIGGER_CFG
      TRIGGER 94  DIRECT ECU_ID 94
      TRIGGER 95  DIRECT ECU_ID 95
      TRIGGER 96  DIRECT ECU_ID 96
      ETK_XETK_REF 7 8
    /end TRIGGER_CFG
    /begin CODE_CHK
      /* Address ECU DATA section   */ 0x80800118
      /* Address ECU RAM section    */ 0xB93FFFC0
      /* Length  ECU DATA sections  */ 8
      PATTERN_REFRESH_TIMEOUT 0x200
      ERROR_BEHAVIOR PERMANENT_RESET
      ETK_XETK_REF 1 2 3 4 5 7 8
    /end CODE_CHK
    /begin COLDSTART_HANDSHAKE
      /* Address of ETKS coldstart pattern */    0xB93FFFD8

      WAIT
        /* Dyn. length for wait pattern    */    0xE5 0xAD 0xEC 0x4D

      READY
        /* Dyn. length for ready pattern    */   0xDE 0xC0 0xED 0xFE

    ETK_XETK_REF 1 2 3 4 5 7 8
    /end COLDSTART_HANDSHAKE

    /begin PAGE_SWITCH_METHOD
        2               /* version                              */
        MAILBOX
            3           /* MBX_Version                                 */
                        /* Version of mailbox                          */
            200          /* MBX_PageSetupTime                           */
                        /* max time the ECU needs to set up page in ms */
            0xB93FFFF0  /* MBX_StartAddress                            */
                        /* Start address of table                      */

        AUTOSTART_BEHAVIOR    LAST_ACTIVE_PAGE  /* Table to be filled by INCA with info */
                                                /* for the current active page          */

        OMD
            0xB93FFF18     /* OMD_ADDRESS */
            1  /* OMD_CID */
            0  /* OMD_VERSION */
            0xA0   /* OMD_MAX_LEN */
            31  /* OMD_NUMBER_OF_EMU_HANDLES */
        CODE_CHK_PATTERN_WP
            0xB93FFFC8 /* Start address of WP CodeCheck Pattern  */
        ETK_XETK_REF 1 2 3 4 5 7 8
    /end PAGE_SWITCH_METHOD

    /begin ECU_DEFINED_ERRORCODES
          ERROR_ENTRY 0x00000001 "OMD error"
          ERROR_ENTRY 0x45525201 "Safety mode condition error"
          ERROR_ENTRY 0x45525202 "ECU does not support Programming at T15 OFF"
          ERROR_ENTRY 0x45525203 "Mail Box Version is invalid"
          ERROR_ENTRY 0x45525204 "Call Back Function is not configured"
    /end ECU_DEFINED_ERRORCODES

    /begin CAL_WAKEUP
        /* 1 = wake up enabled, 0=disabled */ CAL_WAKEUP_PIN 1
        CAL_TOOL_PRESENT
          /* address for the pattern       */ 0xB93FFFB8
          /* CAL_TOOL_PRESENT_PATTERN      */ 0x12345678
          /* ECU timeout for shutdown in s */ 2
        ETK_XETK_REF 1 2 3 4 5 7 8
    /end CAL_WAKEUP

    /begin DATA_FREEZE
      CONFIG  "SAFETY_MAILBOX_ADDRESS" "0xB93FFFE4" 
      CONFIG  "SAFETY_MAILBOX_VERSION" "0x4D310100" 
      CONFIG  "SAFETY_MAILBOX_WAITMSG" "Datafreeze is pending" 
      CONFIG  "SAFETY_MAILBOX_WAITTOUT" "2000" 
      CONFIG  "VALIDATE_PATTERN" "0x80800000 0x100" 
      CONFIG  "INVALIDATE_PATTERN" "0x80800120 0x00044408000004009011000208408C0090508808031010614000280812047640" 
       ETK_XETK_REF 1 2 3 4 5 7 8
    /end DATA_FREEZE

    /end TP_BLOB
    
    /begin SOURCE
      /* daq name        */ "segment synchronous"
      /* period unit CSE */ 103
      /* repetition rate */ 1
      /begin QP_BLOB
        /* RASTER_ID                             */ 1
        /* raster priority [1..32]               */ 3
        /* worst case raster time [us]           */ 2000
        /begin ETK_XETK_SPECIFIC
          /* hardware trigger                      */ TRG_NBR 0
        /begin ECU_PROPERTY
            PERFORMANCE  1 1136363 4545452
        /end ECU_PROPERTY
            ETK_XETK_REF 1 2 3 4 5 7 8
        /end ETK_XETK_SPECIFIC
      /end QP_BLOB
    /end SOURCE
    
    /begin SOURCE
      /* daq name        */ "10ms time synchronous"
      /* period unit CSE */ 4
      /* repetition rate */ 1
      /begin QP_BLOB
        /* RASTER_ID                             */ 2
        /* raster priority [1..32]               */ 2
        /* worst case raster time [us]           */ 9000
        /begin ETK_XETK_SPECIFIC
          /* hardware trigger                      */ TRG_NBR 0
        /begin ECU_PROPERTY
            PERFORMANCE  1 227272 909088
        /end ECU_PROPERTY
            ETK_XETK_REF 1 2 3 4 5 7 8
        /end ETK_XETK_SPECIFIC
      /end QP_BLOB
    /end SOURCE
    
    /begin SOURCE
      /* daq name        */ "100ms time synchronous"
      /* period unit CSE */ 5
      /* repetition rate */ 1
      /begin QP_BLOB
        /* RASTER_ID                             */ 3
        /* raster priority [1..32]               */ 1
        /* worst case raster time [us]           */ 90000
        /begin ETK_XETK_SPECIFIC
          /* hardware trigger                      */ TRG_NBR 0
        /begin ECU_PROPERTY
            PERFORMANCE  1 22727 90908
        /end ECU_PROPERTY
            ETK_XETK_REF 1 2 3 4 5 7 8
        /end ETK_XETK_SPECIFIC
      /end QP_BLOB
    /end SOURCE

  /end IF_DATA

/begin IF_DATA SERVICE_BASED_BYPASS
  /begin SERVICES
     SERVICE_AML_VERSION_3_1_1
     4 /* BaseOffsetValue */
     4 /* NumSrvPts */
     "rba_SvbbEtk_SrvPtResId_KWB" /* SERVICE_POINTS_RESOURCE_ID */
     "rba_SvbbEtk_SrvPtEnabled_KWB" /* SrvPtEnabled */
     "rba_SvbbEtk_TimeOutPre_KWB" /* TimeOutMaxPre*/
     "rba_SvbbEtk_TimeOutPost_KWB" /* TimeOutMaxPost*/
     DOUBLE_BUFFERING_USED
     "rba_SvbbEtk_DisableProcExec_KWB" /* DisableFctExec*/
     /begin IMPLEMENTED_SBB_VERSIONS
        SBB_V2_1
        SBB_V3_1
     /end IMPLEMENTED_SBB_VERSIONS
/* ---------------------------------------- */
    /begin SERVICE_POINT
       2 /* service point number */
       "rba_SvbbEtk_Seg1Byp" /* service point name */
       PRIORITY 2 /* service point priority */
       HOOKED
    /end SERVICE_POINT
    /begin SERVICE_POINT
       3 /* service point number */
       "rba_SvbbEtk_T10msByp" /* service point name */
       PRIORITY 3 /* service point priority */
       HOOKED
    /end SERVICE_POINT
    /begin SERVICE_POINT
       1 /* service point number */
       "rba_Svbb_DummyActivate" /* service point name */
       PRIORITY 1 /* service point priority */
    /end SERVICE_POINT
    /begin SERVICE_POINT
       4 /* service point number */
       "test_bypass_rba_Svbb_10ms_Proc" /* service point name */
       PRIORITY 4 /* service point priority */
    /end SERVICE_POINT
     SBB_DYNAMIC_STRUCTURE
       2 /* SBBDynStructVer */
       0xB93F5898 /* ResWorkArea: resource working area address,
         where resource blocks and address tables and default value tables are
         allocated. Located e.g. in ETK DATA region for parallel ETK types and ETK
         RAM regions for serial ETK types */
       0x2F70 /* ResWorkArea: length of the resource working
         area in bytes */
       0xB93F8810 /* EcuWrtblResWorkArea: where RAM resource blocks
         and data tables are allocated. Located e.g. in ETK RAM for parallel ETKs
         and ECU RAM for serial ETKs */
       12000 /* EcuWrtblResWorkAreaLength: length of the ECU
          writable resource working area in bytes */
               /* ---------------------------------------- */
    /begin TRIGGER_SEPARATED_FROM_CHANNEL
        /begin TRIGGER_CFG
          TRIGGER 1 DIRECT
          TRIGGER 2 DIRECT
          TRIGGER 3 DIRECT
          TRIGGER 4 DIRECT
          TRIGGER 5 DIRECT
          TRIGGER 6 DIRECT
          TRIGGER 7 DIRECT
          TRIGGER 8 DIRECT
          TRIGGER 9 DIRECT
          TRIGGER 10 DIRECT
          TRIGGER 11 DIRECT
          TRIGGER 12 DIRECT
          TRIGGER 13 DIRECT
          TRIGGER 14 DIRECT
          TRIGGER 15 DIRECT
          TRIGGER 16 DIRECT
          TRIGGER 17 DIRECT
          TRIGGER 18 DIRECT
          TRIGGER 19 DIRECT
          TRIGGER 20 DIRECT
          TRIGGER 21 DIRECT
          TRIGGER 22 DIRECT
          TRIGGER 23 DIRECT
          TRIGGER 24 DIRECT
          TRIGGER 25 DIRECT
          TRIGGER 26 DIRECT
          TRIGGER 27 DIRECT
          TRIGGER 28 DIRECT
          TRIGGER 29 DIRECT
          ETK_XETK_REF 1 2 3 4 5 
        /end TRIGGER_CFG
        /begin TRIGGER_CFG
          TRIGGER 1 DIRECT
          TRIGGER 2 DIRECT
          TRIGGER 3 DIRECT
          TRIGGER 4 DIRECT
          TRIGGER 5 DIRECT
          TRIGGER 6 DIRECT
          TRIGGER 7 DIRECT
          TRIGGER 8 DIRECT
          TRIGGER 9 DIRECT
          TRIGGER 10 DIRECT
          TRIGGER 11 DIRECT
          TRIGGER 12 DIRECT
          TRIGGER 13 DIRECT
          TRIGGER 14 DIRECT
          TRIGGER 15 DIRECT
          TRIGGER 16 DIRECT
          TRIGGER 17 DIRECT
          TRIGGER 18 DIRECT
          TRIGGER 19 DIRECT
          TRIGGER 20 DIRECT
          TRIGGER 21 DIRECT
          TRIGGER 22 DIRECT
          TRIGGER 23 DIRECT
          TRIGGER 24 DIRECT
          TRIGGER 25 DIRECT
          TRIGGER 26 DIRECT
          TRIGGER 27 DIRECT
          TRIGGER 28 DIRECT
          TRIGGER 29 DIRECT
          TRIGGER 30 DIRECT
          TRIGGER 31 DIRECT
          TRIGGER 32 DIRECT
          TRIGGER 33 DIRECT
          TRIGGER 34 DIRECT
          TRIGGER 35 DIRECT
          TRIGGER 36 DIRECT
          TRIGGER 37 DIRECT
          TRIGGER 38 DIRECT
          TRIGGER 39 DIRECT
          TRIGGER 40 DIRECT
          TRIGGER 41 DIRECT
          TRIGGER 42 DIRECT
          TRIGGER 43 DIRECT
          TRIGGER 44 DIRECT
          TRIGGER 45 DIRECT
          TRIGGER 46 DIRECT
          TRIGGER 47 DIRECT
          TRIGGER 48 DIRECT
          TRIGGER 49 DIRECT
          TRIGGER 50 DIRECT
          TRIGGER 51 DIRECT
          TRIGGER 52 DIRECT
          TRIGGER 53 DIRECT
          TRIGGER 54 DIRECT
          TRIGGER 55 DIRECT
          TRIGGER 56 DIRECT
          TRIGGER 57 DIRECT
          TRIGGER 58 DIRECT
          TRIGGER 59 DIRECT
          TRIGGER 60 DIRECT
          TRIGGER 61 DIRECT
          TRIGGER 62 DIRECT
          TRIGGER 63 DIRECT
          TRIGGER 64 DIRECT
          TRIGGER 65 DIRECT
          TRIGGER 66 DIRECT
          TRIGGER 67 DIRECT
          TRIGGER 68 DIRECT
          TRIGGER 69 DIRECT
          TRIGGER 70 DIRECT
          TRIGGER 71 DIRECT
          TRIGGER 72 DIRECT
          TRIGGER 73 DIRECT
          TRIGGER 74 DIRECT
          TRIGGER 75 DIRECT
          TRIGGER 76 DIRECT
          TRIGGER 77 DIRECT
          TRIGGER 78 DIRECT
          TRIGGER 79 DIRECT
          TRIGGER 80 DIRECT
          TRIGGER 81 DIRECT
          TRIGGER 82 DIRECT
          TRIGGER 83 DIRECT
          TRIGGER 84 DIRECT
          TRIGGER 85 DIRECT
          TRIGGER 86 DIRECT
          TRIGGER 87 DIRECT
          TRIGGER 88 DIRECT
          TRIGGER 89 DIRECT
          TRIGGER 90 DIRECT
          TRIGGER 91 DIRECT
          TRIGGER 92 DIRECT
          TRIGGER 93 DIRECT
          ETK_XETK_REF 6 7 8 
        /end TRIGGER_CFG
        /begin DATA_ACQUISITION
          PRIORITY_RANGE 4 32
          ETK_XETK_REF 1 2 3 4 5 
        /end DATA_ACQUISITION
        /begin DATA_ACQUISITION
          PRIORITY_RANGE 4 64
          ETK_XETK_REF 6 7 8 
        /end DATA_ACQUISITION
    /end TRIGGER_SEPARATED_FROM_CHANNEL
    /* ---------------------------------------- */
  /end SERVICES
/end IF_DATA /*Service_Based_Bypass*/
/begin IF_DATA XCPplus 0x0102
   /begin PAG
     /* MAX_SEGMENTS       */ 27
   /end PAG

/*************** start of PROTOCOL_LAYER *******************/

  /begin PROTOCOL_LAYER                                   /* At MODULE */

    0x0102                                                /* XCP protocol layer version */

    1000                                                   /* T1 [ms] */
    1000                                                   /* T2 [ms] */
    0                                                     /* T3 [ms] */
    0                                                     /* T4 [ms] */
    0                                                     /* T5 [ms] */
    0                                                     /* T6 [ms] */
    0                                                     /* T7 [ms] */

    50                                                     /* MAX_CTO */
    200                                                     /* MAX_DTO default for DAQ and STIM */

    BYTE_ORDER_MSB_LAST                                   /* BYTE_ORDER: INTEL */
    ADDRESS_GRANULARITY_BYTE                              /* ADDRESS_GRANULARITY */

    OPTIONAL_CMD GET_COMM_MODE_INFO
    OPTIONAL_CMD SET_MTA
    OPTIONAL_CMD UPLOAD
    OPTIONAL_CMD SHORT_UPLOAD
    OPTIONAL_CMD BUILD_CHECKSUM
    OPTIONAL_CMD DOWNLOAD
    OPTIONAL_CMD DOWNLOAD_NEXT
    OPTIONAL_CMD DOWNLOAD_MAX
    OPTIONAL_CMD SHORT_DOWNLOAD
    OPTIONAL_CMD SET_CAL_PAGE
    OPTIONAL_CMD GET_CAL_PAGE
    OPTIONAL_CMD COPY_CAL_PAGE
    OPTIONAL_CMD CLEAR_DAQ_LIST
    OPTIONAL_CMD SET_DAQ_PTR
    OPTIONAL_CMD WRITE_DAQ
    OPTIONAL_CMD SET_DAQ_LIST_MODE
    OPTIONAL_CMD START_STOP_DAQ_LIST
    OPTIONAL_CMD START_STOP_SYNCH
    OPTIONAL_CMD GET_DAQ_CLOCK
    OPTIONAL_CMD FREE_DAQ
    OPTIONAL_CMD ALLOC_DAQ
    OPTIONAL_CMD ALLOC_ODT
    OPTIONAL_CMD ALLOC_ODT_ENTRY
    OPTIONAL_CMD WRITE_DAQ_MULTIPLE

    COMMUNICATION_MODE_SUPPORTED                          /* optional modes supported */
      BLOCK
        SLAVE                                             /* Slave Block Mode supported  */
        MASTER                                            /* Master Block Mode supported */
          255                                             /* MAX_BS */
          0                                               /* MIN_ST */

  /end PROTOCOL_LAYER

/***************** end of PROTOCOL_LAYER *******************/
    
/********************* start of DAQ ************************/

  /begin DAQ                                              /* DAQ supported, at MODULE*/
    DYNAMIC                                               /* DAQ_CONFIG_TYPE */
    65535                                                 /* MAX_DAQ */
    3                                                     /* MAX_EVENT_CHANNEL */
    0                                                     /* MIN_DAQ */
    OPTIMISATION_TYPE_ODT_TYPE_32                             /* OPTIMISATION_TYPE */
    ADDRESS_EXTENSION_FREE                                /* ADDRESS_EXTENSION */
    IDENTIFICATION_FIELD_TYPE_RELATIVE_WORD_ALIGNED                    /* IDENTIFICATION_FIELD */
    GRANULARITY_ODT_ENTRY_SIZE_DAQ_BYTE                   /* GRANULARITY_ODT_ENTRY_SIZE_DAQ */
    255                                                   /* MAX_ODT_ENTRY_SIZE_DAQ */
    OVERLOAD_INDICATION_EVENT                             /* OVERLOAD_INDICATION */
    PRESCALER_SUPPORTED
    /begin TIMESTAMP_SUPPORTED
      1                           /* TIMESTAMP_TICKS */
      SIZE_DWORD             /* TIMESTAMP_SIZE */
      UNIT_10US  /* RESOLUTION OF TIMESTAMP */
    /end TIMESTAMP_SUPPORTED
    /begin DAQ_MEMORY_CONSUMPTION
      9995                                                /* DAQ_MEMORY_LIMIT: in Elements[AG] */
      616                                                  /* DAQ_SIZE: number of elements[AG] per DAQ list */
      6                                                   /* ODT_SIZE: number of elements[AG] per ODT */
      5                                                   /* ODT_ENTRY_SIZE: number of elements[AG] per ODT_entry */
      2                                                   /* ODT_DAQ_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(send buffer)[AG] */
      0                                                   /* ODT_STIM_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(receive buffer)[AG] */
    /end DAQ_MEMORY_CONSUMPTION

/******************* start of EVENT ************************/

    /begin EVENT                                          /* EVENT               */
      "100ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "100_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      0                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      100                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      5                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.1

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "10ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "10_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      1                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      10                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      6                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.5

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "1ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "1_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      2                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      1                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      7                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

    /end EVENT

/********************* end of EVENT ************************/

  /end DAQ

/********************* end of DAQ **************************/
    /begin XCP_ON_TCP_IP

/************************ start of TCP_IP ******************/

    0x0102 /* XCP on TCP_IP version */
    5555 /* PORT */
    ADDRESS  ""
  
    MAX_BUS_LOAD  90 /* maximum available bus */
                     /* load in percent */
    MAX_BIT_RATE  100 /* Network speed which is */
                              /* the base for MAX_BUS_LOAD in Mbit*/


/************************* end of TCP_IP *******************/
    
/*************** start of PROTOCOL_LAYER *******************/

  /begin PROTOCOL_LAYER                                   /* At MODULE */

    0x0102                                                /* XCP protocol layer version */

    1000                                                   /* T1 [ms] */
    1000                                                   /* T2 [ms] */
    0                                                     /* T3 [ms] */
    0                                                     /* T4 [ms] */
    0                                                     /* T5 [ms] */
    0                                                     /* T6 [ms] */
    0                                                     /* T7 [ms] */

    50                                                     /* MAX_CTO */
    200                                                     /* MAX_DTO default for DAQ and STIM */

    BYTE_ORDER_MSB_LAST                                   /* BYTE_ORDER: INTEL */
    ADDRESS_GRANULARITY_BYTE                              /* ADDRESS_GRANULARITY */

    OPTIONAL_CMD GET_COMM_MODE_INFO
    OPTIONAL_CMD SET_MTA
    OPTIONAL_CMD UPLOAD
    OPTIONAL_CMD SHORT_UPLOAD
    OPTIONAL_CMD BUILD_CHECKSUM
    OPTIONAL_CMD DOWNLOAD
    OPTIONAL_CMD DOWNLOAD_NEXT
    OPTIONAL_CMD DOWNLOAD_MAX
    OPTIONAL_CMD SHORT_DOWNLOAD
    OPTIONAL_CMD SET_CAL_PAGE
    OPTIONAL_CMD GET_CAL_PAGE
    OPTIONAL_CMD COPY_CAL_PAGE
    OPTIONAL_CMD CLEAR_DAQ_LIST
    OPTIONAL_CMD SET_DAQ_PTR
    OPTIONAL_CMD WRITE_DAQ
    OPTIONAL_CMD SET_DAQ_LIST_MODE
    OPTIONAL_CMD START_STOP_DAQ_LIST
    OPTIONAL_CMD START_STOP_SYNCH
    OPTIONAL_CMD GET_DAQ_CLOCK
    OPTIONAL_CMD FREE_DAQ
    OPTIONAL_CMD ALLOC_DAQ
    OPTIONAL_CMD ALLOC_ODT
    OPTIONAL_CMD ALLOC_ODT_ENTRY
    OPTIONAL_CMD WRITE_DAQ_MULTIPLE

    COMMUNICATION_MODE_SUPPORTED                          /* optional modes supported */
      BLOCK
        SLAVE                                             /* Slave Block Mode supported  */
        MASTER                                            /* Master Block Mode supported */
          255                                             /* MAX_BS */
          0                                               /* MIN_ST */

  /end PROTOCOL_LAYER

/***************** end of PROTOCOL_LAYER *******************/
    
/********************* start of DAQ ************************/

  /begin DAQ                                              /* DAQ supported, at MODULE*/
    DYNAMIC                                               /* DAQ_CONFIG_TYPE */
    65535                                                 /* MAX_DAQ */
    3                                                     /* MAX_EVENT_CHANNEL */
    0                                                     /* MIN_DAQ */
    OPTIMISATION_TYPE_ODT_TYPE_32                             /* OPTIMISATION_TYPE */
    ADDRESS_EXTENSION_FREE                                /* ADDRESS_EXTENSION */
    IDENTIFICATION_FIELD_TYPE_RELATIVE_WORD_ALIGNED                    /* IDENTIFICATION_FIELD */
    GRANULARITY_ODT_ENTRY_SIZE_DAQ_BYTE                   /* GRANULARITY_ODT_ENTRY_SIZE_DAQ */
    255                                                   /* MAX_ODT_ENTRY_SIZE_DAQ */
    OVERLOAD_INDICATION_EVENT                             /* OVERLOAD_INDICATION */
    PRESCALER_SUPPORTED
    /begin TIMESTAMP_SUPPORTED
      1                           /* TIMESTAMP_TICKS */
      SIZE_DWORD             /* TIMESTAMP_SIZE */
      UNIT_10US  /* RESOLUTION OF TIMESTAMP */
    /end TIMESTAMP_SUPPORTED
    /begin DAQ_MEMORY_CONSUMPTION
      9995                                                /* DAQ_MEMORY_LIMIT: in Elements[AG] */
      616                                                  /* DAQ_SIZE: number of elements[AG] per DAQ list */
      6                                                   /* ODT_SIZE: number of elements[AG] per ODT */
      5                                                   /* ODT_ENTRY_SIZE: number of elements[AG] per ODT_entry */
      2                                                   /* ODT_DAQ_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(send buffer)[AG] */
      0                                                   /* ODT_STIM_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(receive buffer)[AG] */
    /end DAQ_MEMORY_CONSUMPTION

/******************* start of EVENT ************************/

    /begin EVENT                                          /* EVENT               */
      "100ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "100_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      0                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      100                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      5                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.1

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "10ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "10_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      1                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      10                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      6                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.5

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "1ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "1_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      2                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      1                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      7                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

    /end EVENT

/********************* end of EVENT ************************/

  /end DAQ

/********************* end of DAQ **************************/
    
        TRANSPORT_LAYER_INSTANCE "Ethernet (TCP)"
    /end XCP_ON_TCP_IP
/begin XCP_ON_TCP_IP

/************************ start of TCP_IP ******************/

    0x0102 /* XCP on TCP_IP version */
    5555 /* PORT */
    ADDRESS  ""
  
    MAX_BUS_LOAD  90 /* maximum available bus */
                     /* load in percent */
    MAX_BIT_RATE  100 /* Network speed which is */
                              /* the base for MAX_BUS_LOAD in Mbit*/


/************************* end of TCP_IP *******************/
    
/*************** start of PROTOCOL_LAYER *******************/

  /begin PROTOCOL_LAYER                                   /* At MODULE */

    0x0102                                                /* XCP protocol layer version */

    1000                                                   /* T1 [ms] */
    1000                                                   /* T2 [ms] */
    0                                                     /* T3 [ms] */
    0                                                     /* T4 [ms] */
    0                                                     /* T5 [ms] */
    0                                                     /* T6 [ms] */
    0                                                     /* T7 [ms] */

    50                                                     /* MAX_CTO */
    200                                                     /* MAX_DTO default for DAQ and STIM */

    BYTE_ORDER_MSB_LAST                                   /* BYTE_ORDER: INTEL */
    ADDRESS_GRANULARITY_BYTE                              /* ADDRESS_GRANULARITY */

    OPTIONAL_CMD GET_COMM_MODE_INFO
    OPTIONAL_CMD SET_MTA
    OPTIONAL_CMD UPLOAD
    OPTIONAL_CMD SHORT_UPLOAD
    OPTIONAL_CMD BUILD_CHECKSUM
    OPTIONAL_CMD DOWNLOAD
    OPTIONAL_CMD DOWNLOAD_NEXT
    OPTIONAL_CMD DOWNLOAD_MAX
    OPTIONAL_CMD SHORT_DOWNLOAD
    OPTIONAL_CMD SET_CAL_PAGE
    OPTIONAL_CMD GET_CAL_PAGE
    OPTIONAL_CMD COPY_CAL_PAGE
    OPTIONAL_CMD CLEAR_DAQ_LIST
    OPTIONAL_CMD SET_DAQ_PTR
    OPTIONAL_CMD WRITE_DAQ
    OPTIONAL_CMD SET_DAQ_LIST_MODE
    OPTIONAL_CMD START_STOP_DAQ_LIST
    OPTIONAL_CMD START_STOP_SYNCH
    OPTIONAL_CMD GET_DAQ_CLOCK
    OPTIONAL_CMD FREE_DAQ
    OPTIONAL_CMD ALLOC_DAQ
    OPTIONAL_CMD ALLOC_ODT
    OPTIONAL_CMD ALLOC_ODT_ENTRY
    OPTIONAL_CMD WRITE_DAQ_MULTIPLE

    COMMUNICATION_MODE_SUPPORTED                          /* optional modes supported */
      BLOCK
        SLAVE                                             /* Slave Block Mode supported  */
        MASTER                                            /* Master Block Mode supported */
          255                                             /* MAX_BS */
          0                                               /* MIN_ST */

  /end PROTOCOL_LAYER

/***************** end of PROTOCOL_LAYER *******************/
    
/********************* start of DAQ ************************/

  /begin DAQ                                              /* DAQ supported, at MODULE*/
    DYNAMIC                                               /* DAQ_CONFIG_TYPE */
    65535                                                 /* MAX_DAQ */
    3                                                     /* MAX_EVENT_CHANNEL */
    0                                                     /* MIN_DAQ */
    OPTIMISATION_TYPE_ODT_TYPE_32                             /* OPTIMISATION_TYPE */
    ADDRESS_EXTENSION_FREE                                /* ADDRESS_EXTENSION */
    IDENTIFICATION_FIELD_TYPE_RELATIVE_WORD_ALIGNED                    /* IDENTIFICATION_FIELD */
    GRANULARITY_ODT_ENTRY_SIZE_DAQ_BYTE                   /* GRANULARITY_ODT_ENTRY_SIZE_DAQ */
    255                                                   /* MAX_ODT_ENTRY_SIZE_DAQ */
    OVERLOAD_INDICATION_EVENT                             /* OVERLOAD_INDICATION */
    PRESCALER_SUPPORTED
    /begin TIMESTAMP_SUPPORTED
      1                           /* TIMESTAMP_TICKS */
      SIZE_DWORD             /* TIMESTAMP_SIZE */
      UNIT_10US  /* RESOLUTION OF TIMESTAMP */
    /end TIMESTAMP_SUPPORTED
    /begin DAQ_MEMORY_CONSUMPTION
      19995                                                /* DAQ_MEMORY_LIMIT: in Elements[AG] */
      616                                                  /* DAQ_SIZE: number of elements[AG] per DAQ list */
      6                                                   /* ODT_SIZE: number of elements[AG] per ODT */
      5                                                   /* ODT_ENTRY_SIZE: number of elements[AG] per ODT_entry */
      2                                                   /* ODT_DAQ_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(send buffer)[AG] */
      0                                                   /* ODT_STIM_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(receive buffer)[AG] */
    /end DAQ_MEMORY_CONSUMPTION

/******************* start of EVENT ************************/

    /begin EVENT                                          /* EVENT               */
      "100ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "100_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      0                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      100                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      5                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.1

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "10ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "10_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      1                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      10                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      6                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.5

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "1ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "1_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      2                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      1                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      7                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

    /end EVENT

/********************* end of EVENT ************************/

  /end DAQ

/********************* end of DAQ **************************/
    
        TRANSPORT_LAYER_INSTANCE "Ethernet (TCP) (ED-RAM)"
    /end XCP_ON_TCP_IP
/begin XCP_ON_UDP_IP

/************************ start of UDP_IP ******************/

    0x0102 /* XCP on UDP_IP version */
    5555 /* PORT */
    ADDRESS  ""
  
    MAX_BUS_LOAD  90 /* maximum available bus */
                     /* load in percent */
    MAX_BIT_RATE  100 /* Network speed which is */
                              /* the base for MAX_BUS_LOAD in Mbit*/


/************************* end of UDP_IP *******************/
    
/*************** start of PROTOCOL_LAYER *******************/

  /begin PROTOCOL_LAYER                                   /* At MODULE */

    0x0102                                                /* XCP protocol layer version */

    1000                                                   /* T1 [ms] */
    1000                                                   /* T2 [ms] */
    0                                                     /* T3 [ms] */
    0                                                     /* T4 [ms] */
    0                                                     /* T5 [ms] */
    0                                                     /* T6 [ms] */
    0                                                     /* T7 [ms] */

    50                                                     /* MAX_CTO */
    200                                                     /* MAX_DTO default for DAQ and STIM */

    BYTE_ORDER_MSB_LAST                                   /* BYTE_ORDER: INTEL */
    ADDRESS_GRANULARITY_BYTE                              /* ADDRESS_GRANULARITY */

    OPTIONAL_CMD GET_COMM_MODE_INFO
    OPTIONAL_CMD SET_MTA
    OPTIONAL_CMD UPLOAD
    OPTIONAL_CMD SHORT_UPLOAD
    OPTIONAL_CMD BUILD_CHECKSUM
    OPTIONAL_CMD DOWNLOAD
    OPTIONAL_CMD DOWNLOAD_NEXT
    OPTIONAL_CMD DOWNLOAD_MAX
    OPTIONAL_CMD SHORT_DOWNLOAD
    OPTIONAL_CMD SET_CAL_PAGE
    OPTIONAL_CMD GET_CAL_PAGE
    OPTIONAL_CMD COPY_CAL_PAGE
    OPTIONAL_CMD CLEAR_DAQ_LIST
    OPTIONAL_CMD SET_DAQ_PTR
    OPTIONAL_CMD WRITE_DAQ
    OPTIONAL_CMD SET_DAQ_LIST_MODE
    OPTIONAL_CMD START_STOP_DAQ_LIST
    OPTIONAL_CMD START_STOP_SYNCH
    OPTIONAL_CMD GET_DAQ_CLOCK
    OPTIONAL_CMD FREE_DAQ
    OPTIONAL_CMD ALLOC_DAQ
    OPTIONAL_CMD ALLOC_ODT
    OPTIONAL_CMD ALLOC_ODT_ENTRY
    OPTIONAL_CMD WRITE_DAQ_MULTIPLE

    COMMUNICATION_MODE_SUPPORTED                          /* optional modes supported */
      BLOCK
        SLAVE                                             /* Slave Block Mode supported  */
        MASTER                                            /* Master Block Mode supported */
          255                                             /* MAX_BS */
          0                                               /* MIN_ST */

  /end PROTOCOL_LAYER

/***************** end of PROTOCOL_LAYER *******************/
    
/********************* start of DAQ ************************/

  /begin DAQ                                              /* DAQ supported, at MODULE*/
    DYNAMIC                                               /* DAQ_CONFIG_TYPE */
    65535                                                 /* MAX_DAQ */
    3                                                     /* MAX_EVENT_CHANNEL */
    0                                                     /* MIN_DAQ */
    OPTIMISATION_TYPE_ODT_TYPE_32                             /* OPTIMISATION_TYPE */
    ADDRESS_EXTENSION_FREE                                /* ADDRESS_EXTENSION */
    IDENTIFICATION_FIELD_TYPE_RELATIVE_WORD_ALIGNED                    /* IDENTIFICATION_FIELD */
    GRANULARITY_ODT_ENTRY_SIZE_DAQ_BYTE                   /* GRANULARITY_ODT_ENTRY_SIZE_DAQ */
    255                                                   /* MAX_ODT_ENTRY_SIZE_DAQ */
    OVERLOAD_INDICATION_EVENT                             /* OVERLOAD_INDICATION */
    PRESCALER_SUPPORTED
    /begin TIMESTAMP_SUPPORTED
      1                           /* TIMESTAMP_TICKS */
      SIZE_DWORD             /* TIMESTAMP_SIZE */
      UNIT_10US  /* RESOLUTION OF TIMESTAMP */
    /end TIMESTAMP_SUPPORTED
    /begin DAQ_MEMORY_CONSUMPTION
      9995                                                /* DAQ_MEMORY_LIMIT: in Elements[AG] */
      616                                                  /* DAQ_SIZE: number of elements[AG] per DAQ list */
      6                                                   /* ODT_SIZE: number of elements[AG] per ODT */
      5                                                   /* ODT_ENTRY_SIZE: number of elements[AG] per ODT_entry */
      2                                                   /* ODT_DAQ_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(send buffer)[AG] */
      0                                                   /* ODT_STIM_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(receive buffer)[AG] */
    /end DAQ_MEMORY_CONSUMPTION

/******************* start of EVENT ************************/

    /begin EVENT                                          /* EVENT               */
      "100ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "100_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      0                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      100                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      5                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.1

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "10ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "10_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      1                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      10                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      6                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.5

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "1ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "1_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      2                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      1                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      7                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

    /end EVENT

/********************* end of EVENT ************************/

  /end DAQ

/********************* end of DAQ **************************/
    
        TRANSPORT_LAYER_INSTANCE "Ethernet (UDP)"
    /end XCP_ON_UDP_IP
/begin XCP_ON_UDP_IP

/************************ start of UDP_IP ******************/

    0x0102 /* XCP on UDP_IP version */
    5555 /* PORT */
    ADDRESS  ""
  
    MAX_BUS_LOAD  90 /* maximum available bus */
                     /* load in percent */
    MAX_BIT_RATE  100 /* Network speed which is */
                              /* the base for MAX_BUS_LOAD in Mbit*/


/************************* end of UDP_IP *******************/
    
/*************** start of PROTOCOL_LAYER *******************/

  /begin PROTOCOL_LAYER                                   /* At MODULE */

    0x0102                                                /* XCP protocol layer version */

    1000                                                   /* T1 [ms] */
    1000                                                   /* T2 [ms] */
    0                                                     /* T3 [ms] */
    0                                                     /* T4 [ms] */
    0                                                     /* T5 [ms] */
    0                                                     /* T6 [ms] */
    0                                                     /* T7 [ms] */

    50                                                     /* MAX_CTO */
    200                                                     /* MAX_DTO default for DAQ and STIM */

    BYTE_ORDER_MSB_LAST                                   /* BYTE_ORDER: INTEL */
    ADDRESS_GRANULARITY_BYTE                              /* ADDRESS_GRANULARITY */

    OPTIONAL_CMD GET_COMM_MODE_INFO
    OPTIONAL_CMD SET_MTA
    OPTIONAL_CMD UPLOAD
    OPTIONAL_CMD SHORT_UPLOAD
    OPTIONAL_CMD BUILD_CHECKSUM
    OPTIONAL_CMD DOWNLOAD
    OPTIONAL_CMD DOWNLOAD_NEXT
    OPTIONAL_CMD DOWNLOAD_MAX
    OPTIONAL_CMD SHORT_DOWNLOAD
    OPTIONAL_CMD SET_CAL_PAGE
    OPTIONAL_CMD GET_CAL_PAGE
    OPTIONAL_CMD COPY_CAL_PAGE
    OPTIONAL_CMD CLEAR_DAQ_LIST
    OPTIONAL_CMD SET_DAQ_PTR
    OPTIONAL_CMD WRITE_DAQ
    OPTIONAL_CMD SET_DAQ_LIST_MODE
    OPTIONAL_CMD START_STOP_DAQ_LIST
    OPTIONAL_CMD START_STOP_SYNCH
    OPTIONAL_CMD GET_DAQ_CLOCK
    OPTIONAL_CMD FREE_DAQ
    OPTIONAL_CMD ALLOC_DAQ
    OPTIONAL_CMD ALLOC_ODT
    OPTIONAL_CMD ALLOC_ODT_ENTRY
    OPTIONAL_CMD WRITE_DAQ_MULTIPLE

    COMMUNICATION_MODE_SUPPORTED                          /* optional modes supported */
      BLOCK
        SLAVE                                             /* Slave Block Mode supported  */
        MASTER                                            /* Master Block Mode supported */
          255                                             /* MAX_BS */
          0                                               /* MIN_ST */

  /end PROTOCOL_LAYER

/***************** end of PROTOCOL_LAYER *******************/
    
/********************* start of DAQ ************************/

  /begin DAQ                                              /* DAQ supported, at MODULE*/
    DYNAMIC                                               /* DAQ_CONFIG_TYPE */
    65535                                                 /* MAX_DAQ */
    3                                                     /* MAX_EVENT_CHANNEL */
    0                                                     /* MIN_DAQ */
    OPTIMISATION_TYPE_ODT_TYPE_32                             /* OPTIMISATION_TYPE */
    ADDRESS_EXTENSION_FREE                                /* ADDRESS_EXTENSION */
    IDENTIFICATION_FIELD_TYPE_RELATIVE_WORD_ALIGNED                    /* IDENTIFICATION_FIELD */
    GRANULARITY_ODT_ENTRY_SIZE_DAQ_BYTE                   /* GRANULARITY_ODT_ENTRY_SIZE_DAQ */
    255                                                   /* MAX_ODT_ENTRY_SIZE_DAQ */
    OVERLOAD_INDICATION_EVENT                             /* OVERLOAD_INDICATION */
    PRESCALER_SUPPORTED
    /begin TIMESTAMP_SUPPORTED
      1                           /* TIMESTAMP_TICKS */
      SIZE_DWORD             /* TIMESTAMP_SIZE */
      UNIT_10US  /* RESOLUTION OF TIMESTAMP */
    /end TIMESTAMP_SUPPORTED
    /begin DAQ_MEMORY_CONSUMPTION
      19995                                                /* DAQ_MEMORY_LIMIT: in Elements[AG] */
      616                                                  /* DAQ_SIZE: number of elements[AG] per DAQ list */
      6                                                   /* ODT_SIZE: number of elements[AG] per ODT */
      5                                                   /* ODT_ENTRY_SIZE: number of elements[AG] per ODT_entry */
      2                                                   /* ODT_DAQ_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(send buffer)[AG] */
      0                                                   /* ODT_STIM_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(receive buffer)[AG] */
    /end DAQ_MEMORY_CONSUMPTION

/******************* start of EVENT ************************/

    /begin EVENT                                          /* EVENT               */
      "100ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "100_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      0                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      100                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      5                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.1

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "10ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "10_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      1                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      10                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      6                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.5

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "1ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "1_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      2                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      1                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      7                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

    /end EVENT

/********************* end of EVENT ************************/

  /end DAQ

/********************* end of DAQ **************************/
    
        TRANSPORT_LAYER_INSTANCE "Ethernet (UDP) (ED-RAM)"
    /end XCP_ON_UDP_IP
/begin XCP_ON_CAN

/************************ start of CAN *********************/
    0x0102                                                /* XCP on CAN version */
    CAN_ID_MASTER 0x7FD                                   /* CMD/STIM CAN-ID */
                                                          /* master -> slave */
    CAN_ID_SLAVE 0x7FE                                    /* RES/ERR/EV/SERV/DAQ CAN-ID */
                                                          /* slave -> master */
                                                          /* Bit31= 1: extended identifier */
    BAUDRATE 1000000                                      /* BAUDRATE [Hz] */
    SAMPLE_POINT 80                                       /* sample point */
                                                          /* [% complete bit time] */
    BTL_CYCLES 20                                         /* BTL_CYCLES */
                                                          /* [slots per bit time] */
    SJW 4                                                 /* length synchr. segment */
                                                          /* [BTL_CYCLES] */
    MAX_BUS_LOAD  100                                     /* maximum available bus */

/************************* end of CAN **********************/
    
/*************** start of PROTOCOL_LAYER *******************/

  /begin PROTOCOL_LAYER                                   /* At MODULE */

    0x0102                                                /* XCP protocol layer version */

    1000                                                   /* T1 [ms] */
    1000                                                   /* T2 [ms] */
    0                                                     /* T3 [ms] */
    0                                                     /* T4 [ms] */
    0                                                     /* T5 [ms] */
    0                                                     /* T6 [ms] */
    0                                                     /* T7 [ms] */

    8                                                     /* MAX_CTO */
    8                                                     /* MAX_DTO default for DAQ and STIM */

    BYTE_ORDER_MSB_LAST                                   /* BYTE_ORDER: INTEL */
    ADDRESS_GRANULARITY_BYTE                              /* ADDRESS_GRANULARITY */

    OPTIONAL_CMD GET_COMM_MODE_INFO
    OPTIONAL_CMD SET_MTA
    OPTIONAL_CMD UPLOAD
    OPTIONAL_CMD SHORT_UPLOAD
    OPTIONAL_CMD BUILD_CHECKSUM
    OPTIONAL_CMD DOWNLOAD
    OPTIONAL_CMD DOWNLOAD_NEXT
    OPTIONAL_CMD DOWNLOAD_MAX
    OPTIONAL_CMD SET_CAL_PAGE
    OPTIONAL_CMD GET_CAL_PAGE
    OPTIONAL_CMD COPY_CAL_PAGE
    OPTIONAL_CMD CLEAR_DAQ_LIST
    OPTIONAL_CMD SET_DAQ_PTR
    OPTIONAL_CMD WRITE_DAQ
    OPTIONAL_CMD SET_DAQ_LIST_MODE
    OPTIONAL_CMD START_STOP_DAQ_LIST
    OPTIONAL_CMD START_STOP_SYNCH
    OPTIONAL_CMD FREE_DAQ
    OPTIONAL_CMD ALLOC_DAQ
    OPTIONAL_CMD ALLOC_ODT
    OPTIONAL_CMD ALLOC_ODT_ENTRY

    COMMUNICATION_MODE_SUPPORTED                          /* optional modes supported */
      BLOCK
        SLAVE                                             /* Slave Block Mode supported  */
        MASTER                                            /* Master Block Mode supported */
          255                                             /* MAX_BS */
          0                                               /* MIN_ST */

  /end PROTOCOL_LAYER

/***************** end of PROTOCOL_LAYER *******************/
    
/********************* start of DAQ ************************/

  /begin DAQ                                              /* DAQ supported, at MODULE*/
    DYNAMIC                                               /* DAQ_CONFIG_TYPE */
    65535                                                 /* MAX_DAQ */
    3                                                     /* MAX_EVENT_CHANNEL */
    0                                                     /* MIN_DAQ */
    OPTIMISATION_TYPE_DEFAULT                             /* OPTIMISATION_TYPE */
    ADDRESS_EXTENSION_FREE                                /* ADDRESS_EXTENSION */
    IDENTIFICATION_FIELD_TYPE_ABSOLUTE                    /* IDENTIFICATION_FIELD */
    GRANULARITY_ODT_ENTRY_SIZE_DAQ_BYTE                   /* GRANULARITY_ODT_ENTRY_SIZE_DAQ */
    255                                                   /* MAX_ODT_ENTRY_SIZE_DAQ */
    OVERLOAD_INDICATION_EVENT                             /* OVERLOAD_INDICATION */
    PRESCALER_SUPPORTED
    /begin DAQ_MEMORY_CONSUMPTION
      4995                                                /* DAQ_MEMORY_LIMIT: in Elements[AG] */
      46                                                  /* DAQ_SIZE: number of elements[AG] per DAQ list */
      6                                                   /* ODT_SIZE: number of elements[AG] per ODT */
      5                                                   /* ODT_ENTRY_SIZE: number of elements[AG] per ODT_entry */
      2                                                   /* ODT_DAQ_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(send buffer)[AG] */
      0                                                   /* ODT_STIM_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(receive buffer)[AG] */
    /end DAQ_MEMORY_CONSUMPTION

/******************* start of EVENT ************************/

    /begin EVENT                                          /* EVENT               */
      "100ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "100_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      0                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      100                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      5                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.1

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "10ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "10_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      1                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      10                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      6                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.5

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "1ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "1_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      2                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      1                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      7                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

    /end EVENT

/********************* end of EVENT ************************/

  /end DAQ

/********************* end of DAQ **************************/
    
        TRANSPORT_LAYER_INSTANCE "Calibration CAN (APPL)"
    /end XCP_ON_CAN
/begin XCP_ON_CAN

/************************ start of CAN *********************/
    0x0102                                                /* XCP on CAN version */
    CAN_ID_MASTER 0x7FD                                   /* CMD/STIM CAN-ID */
                                                          /* master -> slave */
    CAN_ID_SLAVE 0x7FE                                    /* RES/ERR/EV/SERV/DAQ CAN-ID */
                                                          /* slave -> master */
                                                          /* Bit31= 1: extended identifier */
    BAUDRATE 1000000                                      /* BAUDRATE [Hz] */
    SAMPLE_POINT 80                                       /* sample point */
                                                          /* [% complete bit time] */
    BTL_CYCLES 20                                         /* BTL_CYCLES */
                                                          /* [slots per bit time] */
    SJW 4                                                 /* length synchr. segment */
                                                          /* [BTL_CYCLES] */
    MAX_BUS_LOAD  100                                     /* maximum available bus */

/************************* end of CAN **********************/
    
/*************** start of PROTOCOL_LAYER *******************/

  /begin PROTOCOL_LAYER                                   /* At MODULE */

    0x0102                                                /* XCP protocol layer version */

    1000                                                   /* T1 [ms] */
    1000                                                   /* T2 [ms] */
    0                                                     /* T3 [ms] */
    0                                                     /* T4 [ms] */
    0                                                     /* T5 [ms] */
    0                                                     /* T6 [ms] */
    0                                                     /* T7 [ms] */

    8                                                     /* MAX_CTO */
    8                                                     /* MAX_DTO default for DAQ and STIM */

    BYTE_ORDER_MSB_LAST                                   /* BYTE_ORDER: INTEL */
    ADDRESS_GRANULARITY_BYTE                              /* ADDRESS_GRANULARITY */

    OPTIONAL_CMD GET_COMM_MODE_INFO
    OPTIONAL_CMD SET_MTA
    OPTIONAL_CMD UPLOAD
    OPTIONAL_CMD SHORT_UPLOAD
    OPTIONAL_CMD BUILD_CHECKSUM
    OPTIONAL_CMD DOWNLOAD
    OPTIONAL_CMD DOWNLOAD_NEXT
    OPTIONAL_CMD DOWNLOAD_MAX
    OPTIONAL_CMD SET_CAL_PAGE
    OPTIONAL_CMD GET_CAL_PAGE
    OPTIONAL_CMD COPY_CAL_PAGE
    OPTIONAL_CMD CLEAR_DAQ_LIST
    OPTIONAL_CMD SET_DAQ_PTR
    OPTIONAL_CMD WRITE_DAQ
    OPTIONAL_CMD SET_DAQ_LIST_MODE
    OPTIONAL_CMD START_STOP_DAQ_LIST
    OPTIONAL_CMD START_STOP_SYNCH
    OPTIONAL_CMD FREE_DAQ
    OPTIONAL_CMD ALLOC_DAQ
    OPTIONAL_CMD ALLOC_ODT
    OPTIONAL_CMD ALLOC_ODT_ENTRY

    COMMUNICATION_MODE_SUPPORTED                          /* optional modes supported */
      BLOCK
        SLAVE                                             /* Slave Block Mode supported  */
        MASTER                                            /* Master Block Mode supported */
          255                                             /* MAX_BS */
          0                                               /* MIN_ST */

  /end PROTOCOL_LAYER

/***************** end of PROTOCOL_LAYER *******************/
    
/********************* start of DAQ ************************/

  /begin DAQ                                              /* DAQ supported, at MODULE*/
    DYNAMIC                                               /* DAQ_CONFIG_TYPE */
    65535                                                 /* MAX_DAQ */
    3                                                     /* MAX_EVENT_CHANNEL */
    0                                                     /* MIN_DAQ */
    OPTIMISATION_TYPE_DEFAULT                             /* OPTIMISATION_TYPE */
    ADDRESS_EXTENSION_FREE                                /* ADDRESS_EXTENSION */
    IDENTIFICATION_FIELD_TYPE_ABSOLUTE                    /* IDENTIFICATION_FIELD */
    GRANULARITY_ODT_ENTRY_SIZE_DAQ_BYTE                   /* GRANULARITY_ODT_ENTRY_SIZE_DAQ */
    255                                                   /* MAX_ODT_ENTRY_SIZE_DAQ */
    OVERLOAD_INDICATION_EVENT                             /* OVERLOAD_INDICATION */
    PRESCALER_SUPPORTED
    /begin DAQ_MEMORY_CONSUMPTION
      19995                                                /* DAQ_MEMORY_LIMIT: in Elements[AG] */
      46                                                  /* DAQ_SIZE: number of elements[AG] per DAQ list */
      6                                                   /* ODT_SIZE: number of elements[AG] per ODT */
      5                                                   /* ODT_ENTRY_SIZE: number of elements[AG] per ODT_entry */
      2                                                   /* ODT_DAQ_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(send buffer)[AG] */
      0                                                   /* ODT_STIM_BUFFER_ELEMENT_SIZE: number of */
                                                          /* payload elements[AG]*factor = sizeof(receive buffer)[AG] */
    /end DAQ_MEMORY_CONSUMPTION

/******************* start of EVENT ************************/

    /begin EVENT                                          /* EVENT               */
      "100ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "100_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      0                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      100                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      5                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.1

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "10ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "10_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      1                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      10                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      6                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

      CPU_LOAD_MAX 0.5

    /end EVENT

    /begin EVENT                                          /* EVENT               */
      "1ms time synchronous"                             /* EVENT_CHANNEL_NAME       */
      "1_ms"                                             /* EVENT_CHANNEL_SHORT_NAME */
      2                                                   /* EVENT_CHANNEL_NUMBER     */
      DAQ                                                 /* EVENT_CHANNEL_TYPE     */
      1                                                   /* MAX_DAQ_LIST */
      1                                                  /* EVENT_CHANNEL_TIME_CYCLE */
      6                                                   /* EVENT_CHANNEL_TIME_UNIT: UNIT_1MS */
      7                                                   /* EVENT_CHANNEL_PRIORITY (0xFF = highest) */
      
      
   
    

    /end EVENT

/********************* end of EVENT ************************/

  /end DAQ

/********************* end of DAQ **************************/
    
        TRANSPORT_LAYER_INSTANCE "Calibration CAN (APPL) (ED-RAM)"
    /end XCP_ON_CAN
/end IF_DATA 


/***********   Start of merged CHARACTERISTIC blocks    ***********/

/begin CHARACTERISTIC

    Com_stComIPdu_CCVS_xTxPduCtrl_C
    "Calibration parameter to control Ipdu ComIPdu_CCVS_xTx"
    VALUE
    0x808002F7
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_boolean
    1.0
    AUTOSAR_Com_CompuMethods_Com_IPduStatus_enum_type
    0.0
    1.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    Com_stComIPdu_C_xRxPduCtrl_C
    "Calibration parameter to control Ipdu ComIPdu_C_xRx"
    VALUE
    0x808002F6
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_boolean
    1.0
    AUTOSAR_Com_CompuMethods_Com_IPduStatus_enum_type
    0.0
    1.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    Com_stComIPdu_C_xTxPduCtrl_C
    "Calibration parameter to control Ipdu ComIPdu_C_xTx"
    VALUE
    0x808002F5
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_boolean
    1.0
    AUTOSAR_Com_CompuMethods_Com_IPduStatus_enum_type
    0.0
    1.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    Com_stComIPdu_EngCtrl1_xRxPduCtrl_C
    "Calibration parameter to control Ipdu ComIPdu_EngCtrl1_xRx"
    VALUE
    0x808002F4
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_boolean
    1.0
    AUTOSAR_Com_CompuMethods_Com_IPduStatus_enum_type
    0.0
    1.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    Com_stNM_TX_FAPduCtrl_C
    "Calibration parameter to control Ipdu NM_TX_FA"
    VALUE
    0x808002F3
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_boolean
    1.0
    AUTOSAR_Com_CompuMethods_Com_IPduStatus_enum_type
    0.0
    1.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_N_Rpl_u32_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E003C
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_N_Rpl_u32_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E003E
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_f32_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0038
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_f32_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E003A
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s16_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0034
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s16_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0036
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s32_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0030
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s32_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0032
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s8_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E002C
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_s8_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E002E
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u16_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0028
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u16_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E002A
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u32_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0024
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u32_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0026
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u8_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0020
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Add_u8_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0022
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_f32_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E001C
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_f32_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E001E
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s16_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0018
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s16_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E001A
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s32_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0014
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s32_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0016
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s8_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0010
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_s8_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0012
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u16_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E000C
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u16_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E000E
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u32_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0008
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u32_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E000A
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u8_bypass_CST.Vector_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0004
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_BypEtk_test_bypass_rbaBypDrv_T_Rpl_u8_bypass_CST.Channel_u16
    "Value must not be changed manually. This is done automatically by Ascet/Intecrio/"
    VALUE
    0xB93E0006
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"
    MAX_REFRESH 3 200


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_CalWup_Finish_C
    "Leave Calibration Wakeup calibration label"
    VALUE
    0x808002E2
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_CalWup_WakeupEnable_C
    "Enable Calibration Wakeup"
    VALUE
    0x808002E0
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_Etks_swt3rdPartySupp_C
    "Enable 3rd party tool support for Etks"
    VALUE
    0x808002F2
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    255.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    255.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_IoSigHlfBr_bds_Pb_preDefRef_vrnt01_HBR1_C
    "HW signal path for signal HBR1 in the post build config set bds_Pb_preDefRef_vrnt01"
    VALUE
    0x808002DE
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    0.0
    RB_RBA_rba_IoSigHlfBr_CompuMethods_rba_IoSigHlfBr_HWSigPathCompuMethod_bds_Pb_preDefRef_vrnt01
    0.0
    0.0

    FORMAT "%9.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_MRly_Diag_Stk_tiOkError_C
    "Debounce time of main relay sticky diagnosis for detecting an error"
    VALUE
    0x808002D8
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    3000.0
    RB_RBA_rba_MRly_BswModuleDescriptions_rba_MRly_Calibration_Common_milliseconds_CompuMethod
    0.0
    3000.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_MultiStackTrace_ResetMaxValues
    "Reset max stack values saved in NvM"
    VALUE
    0x808002F1
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    1.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    1.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_MultiStackTrace_ThresholdSwitch
    "Select the Stack Limit Threshold Range from 0-5"
    VALUE
    0x808002F0
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    5.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    5.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_OsMeasmt_ResetMaxCoreLoadValues_C
    "Reset max core load values saved in NvM"
    VALUE
    0x808002EF
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    1.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    1.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_OsMeasmt_ResetResponseTimeValues_C
    "Reset max response time values saved in NvM"
    VALUE
    0x808002EE
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    1.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    1.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_OsMeasmt_SwTrace_InitMode_C
    "Init mode which shall be used for the rba_SwTrace / Gliwa T1 initialization"
    VALUE
    0x808002ED
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    2.0
    RB_RBA_rba_OsMeasmt_CompuMethods_rba_OsMeasmt_SwTrace_InitMode_CompuMethod
    0.0
    2.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_Reset_rstExtHistBuf_C
    "calibration label to reset the extended reset history buffer"
    VALUE
    0x808002EC
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    255.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    255.

    FORMAT "%5.1"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_Reset_rstHistBuf_C
    "calibration label to reset the reset history buffer"
    VALUE
    0x808002EB
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    255.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    255.

    FORMAT "%5.1"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_Reset_xGrpId_C
    "calibration label for setting the reset group for triggering a reset"
    VALUE
    0x808002EA
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    255.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    255.

    FORMAT "%5.1"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_Reset_xTrgId_C
    "calibration label for triggering a reset"
    VALUE
    0x808002DC
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint16
    65535.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    65535.

    FORMAT "%5.1"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SvbbEtk_Enable_C
    "Enable Service Based Bypass"
    VALUE
    0x808002E9
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    255.0
    RB_RBA_rba_SvbbEtk_CompuMethods_rba_SvbbEtk_Enable_CM
    0.0
    255.

    FORMAT "%5.1"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SvbbEtk_MaxLostRaster_C
    "Set maximum number of allowed task delays. 0-254: max allowed Task delay for Service Based Bypass, 255: No Monitoring of Task delay"
    VALUE
    0x808002E8
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    255.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    255.

    FORMAT "%5.1"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SvbbEtk_WaitForBypconfigInIni_C
    "maximum delay of ECU intialization until Bypass config is downloaded by ETK in ms"
    VALUE
    0x808002E7
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    255.0
    RB_RBA_Common_CentralElements_CompuMethods_Identical
    0.0
    255.

    FORMAT "%5.1"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_PostDrive_Begin_Timeout_C
    "Maximum time for Begin phase in state PostDrive in seconds"
    VALUE
    0x808002D4
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    4294964.0
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Calibration_Timeout_CompuMethod
    3.
    4294967.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_PostDrive_ClearTimeoutIndication_C
    "Clear the timout indication in state PostDrive by setting it to 0x42 and then to 0x88"
    VALUE
    0x808002E6
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    255.0
    DefaultIdenticalCompu
    0.0
    255.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_PostDrive_End_Timeout_C
    "Maximum time for End phase in state PostDrive in seconds"
    VALUE
    0x808002D0
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    4294966.0
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Calibration_Timeout_CompuMethod
    1.
    4294967.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_PostDrive_MinimumTime_C
    "Minimum time for before state PostDrive is left in seconds"
    VALUE
    0x808002CC
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    59.8
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Calibration_Timeout_CompuMethod
    0.2
    60.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_PostDrive_Network_Timeout_C
    "Maximum time for network phase in state PostDrive in seconds"
    VALUE
    0x808002C8
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    4294964.0
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Calibration_Timeout_CompuMethod
    3.
    4294967.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_PrepareShutdown_ClearTimeoutIndication_C
    "Clear the timout indication in state PrepareShutdown by setting it to 0x42 and then to 0x88"
    VALUE
    0x808002E5
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    255.0
    DefaultIdenticalCompu
    0.0
    255.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_PrepareShutdown_MaximumTime_C
    "Maximum time for Begin phase in state PrepareShutdown in seconds"
    VALUE
    0x808002C4
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    4294964.0
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Calibration_Timeout_CompuMethod
    3.
    4294967.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_PrepareShutdown_MinimumTime_C
    "Minimum time for before state PrepareShutdown is left in seconds"
    VALUE
    0x808002C0
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    4294967.0
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Calibration_Timeout_CompuMethod
    0.0
    4294967.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_Wait_ClearTimeoutIndication_C
    "Clear the timout indication in state Wait by setting it to 0x42 and then to 0x88"
    VALUE
    0x808002E4
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint8
    255.0
    DefaultIdenticalCompu
    0.0
    255.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_Wait_Delay_Timeout_C
    "Maximum time for Delay phase in state Wait in seconds"
    VALUE
    0x808002BC
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    4294967.0
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Calibration_Timeout_CompuMethod
    0.0
    4294967.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_Wait_MinimumTime_C
    "Minimum time for before state Wait is left in seconds"
    VALUE
    0x808002B8
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    4294967.0
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Calibration_Timeout_CompuMethod
    0.0
    4294967.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_Wait_Network_Timeout_C
    "Maximum time for Network phase in state Wait in seconds"
    VALUE
    0x808002B4
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    4294966.0
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Calibration_Timeout_CompuMethod
    1.
    4294967.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_SyC_States_Wait_Prolong_Timeout_C
    "Maximum time for Prolong phase in state Wait in seconds"
    VALUE
    0x808002B0
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    4294966.0
    RB_RBA_rba_SyC_States_BswModuleDescriptions_rba_SyC_States_Calibration_Timeout_CompuMethod
    1.
    4294967.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_T15_Diag_ComInVld_tiDebPreFault_C
    "Debounce time of terminal 15 diagnosis ComInVld for OK to Fault"
    VALUE
    0x808002AC
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    1000.0
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Diag_Calibration_CompuMethod
    0.0
    1000.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_T15_Diag_ComInVld_tiDebPreOk_C
    "Debounce time of terminal 15 diagnosis ComInVld for Fault to OK"
    VALUE
    0x808002A8
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    1000.0
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Diag_Calibration_CompuMethod
    0.0
    1000.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_T15_Diag_ComOff_HwOn_tiDebPreFault_C
    "Debounce time of terminal 15 diagnosis ComOff_HwOn for OK to Fault"
    VALUE
    0x808002A4
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    1000.0
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Diag_Calibration_CompuMethod
    0.0
    1000.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_T15_Diag_ComOff_HwOn_tiDebPreOk_C
    "Debounce time of terminal 15 diagnosis ComOff_HwOn for fault to OK"
    VALUE
    0x808002A0
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    1000.0
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Diag_Calibration_CompuMethod
    0.0
    1000.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_T15_Diag_ComOn_HwOff_tiDebPreFault_C
    "Debounce time of terminal 15 diagnosis ComOn_HwOff for OK to Fault"
    VALUE
    0x8080029C
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    1000.0
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Diag_Calibration_CompuMethod
    0.0
    1000.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_T15_Diag_ComOn_HwOff_tiDebPreOk_C
    "Debounce time of terminal 15 diagnosis ComOn_HwOff for Fault to OK"
    VALUE
    0x80800298
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    1000.0
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Diag_Calibration_CompuMethod
    0.0
    1000.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_T15_Signal_tiDebHiLo_C
    "Terminal 15 software debounce time high to low"
    VALUE
    0x80800294
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    100.0
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Calibration_CompuMethod
    0.0
    100.

    FORMAT "%5.0"


/end CHARACTERISTIC


/begin CHARACTERISTIC

    rba_T15_Signal_tiDebLoHi_C
    "Terminal 15 software debounce time Low to High"
    VALUE
    0x80800290
    DefaultValueRecordLayout_AUTOSAR_Platform_BaseTypes_uint32
    100.0
    RB_RBA_rba_T15_BswModuleDescriptions_rba_T15_Signal_Calibration_CompuMethod
    0.0
    100.

    FORMAT "%5.0"


/end CHARACTERISTIC


/***********   End of merged CHARACTERISTIC blocks    ***********/
/begin CHARACTERISTIC

    ACCI_mEstimCAN_C
    "Calibration for Vehiclemass of the Massestimationunit (needed to be written on the CAN)"
    VALUE
    0x80809140
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ACCI_rSlpRoad_C
    "Calibration used to test the signal ACCI_rSlpRoad"
    VALUE
    0x80809142
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ACCI_stMVeh_C
    "Calibration for Qualification bit for the vehicle mass"
    VALUE
    0x80809144
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ACCI_stRSlpRoad_C
    "Calibration for Qualification bit for the highway slope"
    VALUE
    0x80809145
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_Standby_Disabled_C
    "Activate or deactivate Standbytest"
    VALUE
    0x80809058
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_tiTstDemHeal_C
    "Minimum time without actuator test for re-release after time"
    VALUE
    0x8080905A
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_tiTstDemMax_C
    "Maximum permissible actuator test time"
    VALUE
    0x8080905C
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_TmrBehaviour_C
    "Time limit response for new tester demands"
    VALUE
    0x8080905E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_TstDemMaxEngN_C
    "Maximum permissible engine speed for actuator test"
    VALUE
    0x8080905F
    Val_Wu8
    10200.
    EngN_LRes
    0.00
    10200.

    FORMAT "%5.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_TstDemMaxVSSCDV_C
    "Maximum permissible vehicle speed for actuator test"
    VALUE
    0x80809060
    Val_Ws16
    655.3500
    Vel
    -327.6800
    327.6700

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Brk_r_C
    "Standardized angle of brake pedal"
    VALUE
    0x80809146
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Brk_stBrkBstWarn_C
    "Calibration of enable the Brake booster warning"
    VALUE
    0x80809148
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Brk_stExt_C
    "calibration parameter for application variable"
    VALUE
    0x80809149
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CALIBID
    "Calibration ID (Programmstep making) according to SAE J1979 for Mode $09"
    VAL_BLK
    0x80808F98
    KwbUb
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 16 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoESS_stRcpt_C
    "Calibration for recuperation state"
    VALUE
    0x8080914A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ComDia_nMaxServCDI_C
    "maximum enginespeed to clear diagnostic information"
    VALUE
    0x80809118
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    COMDIA_TGEFN_CA
    "Test Group Engine Family Number"
    VAL_BLK
    0x80809024
    ValA_Wu8
    255.0
    dez
    0.00
    255.0

    FORMAT "%5.1"
    
    MATRIX_DIM 12 

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_APP_rUnFlt_C
    ""
    VALUE
    0x8080914C
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Bauteil_Temp_C
    ""
    VALUE
    0x8080914E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_elektr_Fehler_C
    ""
    VALUE
    0x8080914F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Fehler_CAN_Comm_C
    ""
    VALUE
    0x80809150
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_IstStrom_Aufnahme_C
    ""
    VALUE
    0x80809151
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Ist_Spannung_C
    ""
    VALUE
    0x80809152
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_mech_Fehler_C
    ""
    VALUE
    0x80809153
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_QBit_Bauteil_Temp_C
    ""
    VALUE
    0x80809154
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_QBit_Ist_Strom_C
    ""
    VALUE
    0x80809155
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Regelabweichung_C
    ""
    VALUE
    0x80809156
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_StromSens_KS_Masse_C
    ""
    VALUE
    0x80809157
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_StromSens_KS_Plus_C
    ""
    VALUE
    0x80809158
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Tempsens_KS_Masse_C
    ""
    VALUE
    0x80809159
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Tempsens_KS_Plus_C
    ""
    VALUE
    0x8080915A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Tempsens_OpenLoad_C
    ""
    VALUE
    0x8080915B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Uberspannung_48V_C
    ""
    VALUE
    0x8080915C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Ubertemperatur_C
    ""
    VALUE
    0x8080915D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Ueberspannung_12V_C
    ""
    VALUE
    0x8080915E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Unterspannung_12V_C
    ""
    VALUE
    0x8080915F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Unterspannung_48V_C
    ""
    VALUE
    0x80809160
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_Verpolung_48V_C
    ""
    VALUE
    0x80809161
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_ZyklusBit_EEPROM_C
    ""
    VALUE
    0x80809162
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_BOOST_ZyklusBit_kont_C
    ""
    VALUE
    0x80809163
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_dataEngCod0_C
    ""
    VALUE
    0x80809164
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_dataEngCod1_C
    ""
    VALUE
    0x80809165
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_dataEngCod2_C
    ""
    VALUE
    0x80809166
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_dataEngCod3_C
    ""
    VALUE
    0x80809167
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_dCANVer_C
    "Supported CAN version sent via CAN"
    VALUE
    0x80809168
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_dOilTOut_C
    "calibration parameter for application variable"
    VALUE
    0x80809169
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_drAPPPrefilg_C
    "calibration parameter for application variable"
    VALUE
    0x8080916A
    Val_Ws16
    199996.9
    PrcPerSec_4ms
    -100000.0
    99996.9

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_flgSwvar_C
    "Calibration Variable for Pdu Ecuvariant"
    VALUE
    0x80808FA8
    RB_Val_Wu8
    1.00000000000
    B_TRUE
    0.00
    1.00000000000

    FORMAT "%13.11"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_MO_Drehzahl_VM_C
    ""
    VALUE
    0x8080916C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_MO_Fehlerstatus_Antrieb_FDR_C
    ""
    VALUE
    0x8080916E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_MO_Mom_Begr_Schalt_C
    ""
    VALUE
    0x80809170
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_MO_Mom_Begr_Schalt_Min_C
    ""
    VALUE
    0x80809172
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_MO_Primaerachse_Anforderung_C
    ""
    VALUE
    0x80809174
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_nEngDes_C
    "calibration parameter for application variable"
    VALUE
    0x80809176
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_nEngMin_C
    "engine speed threshold to detect that the engine is not rotating"
    VALUE
    0x80809178
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_nEng_C
    "Calibration value for Engine RPM"
    VALUE
    0x8080917A
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_numCDA_C
    "Number of engine shut off in half engine mode"
    VALUE
    0x8080917C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_numGearPos_C
    "calibration parameter for application variable"
    VALUE
    0x8080917D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_pCACDs_C
    "calibration variable"
    VALUE
    0x8080917E
    Val_Wu16
    65535.00
    Pres_hPa
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_pEnv_C
    ""
    VALUE
    0x80809180
    Val_Ws16
    65535.00
    Pres_hPa
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_pwrPTC_C
    "calibration variable"
    VALUE
    0x80809182
    Val_Wu8
    12750.
    Pwr_50
    0.00
    12750.

    FORMAT "%5.0"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_rIncrRmn_C
    "calibration parameter for application variable"
    VALUE
    0x80809184
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_rNOvrd_C
    "calibration parameter for application variable"
    VALUE
    0x80809186
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_rWaPmpHeat_C
    "calibration parameter for application variable"
    VALUE
    0x80809188
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stAftRunTyp_C
    ""
    VALUE
    0x8080918A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stAirCIntv_C
    "calibration variable"
    VALUE
    0x8080918B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stAPPGradSign_C
    "calibration parameter for application variable"
    VALUE
    0x8080918C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stAPPLowIdl_C
    "calibration variable"
    VALUE
    0x8080918D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stBrkTOut_C
    "calibration variable"
    VALUE
    0x8080918E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stCarTyp_C
    "calibration parameter for application variable"
    VALUE
    0x8080918F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stCDA_C
    "calibration parameter for application variable"
    VALUE
    0x80809190
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stClthEngNegAvl_C
    "calibration variable"
    VALUE
    0x80809192
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stClthOut_C
    "calibration variable"
    VALUE
    0x80809194
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stCylShOff_C
    "calibration parameter for application variable"
    VALUE
    0x80809195
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stDFESEntry_C
    ""
    VALUE
    0x80809196
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stEngTQBit_C
    "calibration parameter for application variable"
    VALUE
    0x80809197
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stEngTxt_C
    "calibration parameter for application variable"
    VALUE
    0x80809198
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stEng_C
    "Calibration for Com_stEng"
    VALUE
    0x80809199
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stFanMuxCode_C
    "calibration parameter for application variable"
    VALUE
    0x8080919A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stFlConsOvrFlw_C
    "calibration parameter for application variable"
    VALUE
    0x8080919B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stGbxIntvLeadActv_C
    "calibration parameter for application variable"
    VALUE
    0x8080919C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stGearAdvPrs_C
    "calibration parameter for application variable"
    VALUE
    0x8080919D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stGearPos_C
    "calibration variable"
    VALUE
    0x8080919E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stIntrLck_C
    "calibration variable"
    VALUE
    0x8080919F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stKD_C
    "Calibration corresponding to Secured kick down signal"
    VALUE
    0x808091A0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stMKBMux_C
    "calibration parameter for application variable"
    VALUE
    0x808091A1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stOilTQBit_C
    "calibration parameter for application variable"
    VALUE
    0x808091A2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stPFltRgnActv_C
    "calibration parameter for application variable"
    VALUE
    0x808091A3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stScrWarn_C
    "Mask for SCR warning levels for Display-ECU"
    VALUE
    0x808091A4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stSwsVWGearActDspl_C
    "calibration variable"
    VALUE
    0x808091A5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stSysErr_C
    "calibration parameter for application variable"
    VALUE
    0x808091A6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stSysLmp_C
    "calibration parameter for application variable"
    VALUE
    0x808091A7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stTransptModeActv_C
    ""
    VALUE
    0x808091A8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stTRQ_C
    "calibration parameter for application variable"
    VALUE
    0x808091A9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_stWaHtStg_C
    "calibration parameter for application variable"
    VALUE
    0x808091AA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_swtSCRDsplEna_C
    "calibration parameter for application variable"
    VALUE
    0x808091AB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_tEngTEng07_C
    "calibration parameter for application variable"
    VALUE
    0x808091AC
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_tEngTEng09_C
    "calibration parameter for application variable"
    VALUE
    0x808091AE
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_tIntkAirT_C
    "calibration parameter for application variable"
    VALUE
    0x808091B0
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_trqClthEngDesFlt_C
    "calibration parameter for application variable"
    VALUE
    0x808091B2
    Val_Ws16
    6553.500
    Trq
    -3276.800
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_trqClthEngDes_C
    "calibration parameter for application variable"
    VALUE
    0x808091B4
    Val_Ws16
    6553.500
    Trq
    -3276.800
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_trqClthEngLimDyn_C
    "calibration parameter for application variable"
    VALUE
    0x808091B6
    Val_Ws16
    6553.500
    Trq
    -3276.800
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_trqClthEngLimStat_C
    "calibration parameter for application variable"
    VALUE
    0x808091B8
    Val_Ws16
    6553.500
    Trq
    -3276.800
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_trqClthEngNegAvl_C
    "calibration parameter for application variable"
    VALUE
    0x808091BA
    Val_Ws16
    6553.500
    Trq
    -3276.800
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_trqClthEng_C
    "calibration parameter for application variable"
    VALUE
    0x808091BC
    Val_Ws16
    6553.500
    Trq
    -3276.800
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Com_trqLos_C
    "calibration parameter for application variable"
    VALUE
    0x808091BE
    Val_Ws16
    6553.500
    Trq
    -3276.800
    3276.700

    FORMAT "%8.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoVeh_bRollrModeActv_C
    "Calibration for Status of local roll mode activates export BIT"
    VALUE
    0x808091C0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoVOM_bSailEna_C
    "Calibration for Sail release for the transmission"
    VALUE
    0x808091C1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_2.isJmpDwnActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Failed"" to ""Passed"" debouncing"
    VALUE
    0x80808FAA
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_2.isJmpUpActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Passed"" to ""Failed"" debouncing"
    VALUE
    0x80808FAB
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_2.limPassd_C
    "Parameters of ArCtrBase debouncing /  / ""Passed"" limit"
    VALUE
    0x80808FAC
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_2.limFaild_C
    "Parameters of ArCtrBase debouncing /  / ""Failed"" limit"
    VALUE
    0x80808FAE
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_2.jmpUpVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Failed"""
    VALUE
    0x80808FB0
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_2.jmpDwnVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Passed"""
    VALUE
    0x80808FB2
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_2.stepUp_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Failed"" direction"
    VALUE
    0x80808FB4
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_2.stepDwn_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Passed"" direction"
    VALUE
    0x80808FB6
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_1.isJmpDwnActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Failed"" to ""Passed"" debouncing"
    VALUE
    0x80808FB8
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_1.isJmpUpActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Passed"" to ""Failed"" debouncing"
    VALUE
    0x80808FB9
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_1.limPassd_C
    "Parameters of ArCtrBase debouncing /  / ""Passed"" limit"
    VALUE
    0x80808FBA
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_1.limFaild_C
    "Parameters of ArCtrBase debouncing /  / ""Failed"" limit"
    VALUE
    0x80808FBC
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_1.jmpUpVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Failed"""
    VALUE
    0x80808FBE
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_1.jmpDwnVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Passed"""
    VALUE
    0x80808FC0
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_1.stepUp_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Failed"" direction"
    VALUE
    0x80808FC2
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.MyCtrBasedClass_1.stepDwn_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Passed"" direction"
    VALUE
    0x80808FC4
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_0.isJmpDwnActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Failed"" to ""Passed"" debouncing"
    VALUE
    0x80808FC6
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_0.isJmpUpActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Passed"" to ""Failed"" debouncing"
    VALUE
    0x80808FC7
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_0.limPassd_C
    "Parameters of ArCtrBase debouncing /  / ""Passed"" limit"
    VALUE
    0x80808FC8
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_0.limFaild_C
    "Parameters of ArCtrBase debouncing /  / ""Failed"" limit"
    VALUE
    0x80808FCA
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_0.jmpUpVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Failed"""
    VALUE
    0x80808FCC
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_0.jmpDwnVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Passed"""
    VALUE
    0x80808FCE
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_0.stepUp_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Failed"" direction"
    VALUE
    0x80808FD0
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_0.stepDwn_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Passed"" direction"
    VALUE
    0x80808FD2
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_1.isJmpDwnActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Failed"" to ""Passed"" debouncing"
    VALUE
    0x80808FD4
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_1.isJmpUpActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Passed"" to ""Failed"" debouncing"
    VALUE
    0x80808FD5
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_1.limPassd_C
    "Parameters of ArCtrBase debouncing /  / ""Passed"" limit"
    VALUE
    0x80808FD6
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_1.limFaild_C
    "Parameters of ArCtrBase debouncing /  / ""Failed"" limit"
    VALUE
    0x80808FD8
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_1.jmpUpVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Failed"""
    VALUE
    0x80808FDA
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_1.jmpDwnVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Passed"""
    VALUE
    0x80808FDC
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_1.stepUp_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Failed"" direction"
    VALUE
    0x80808FDE
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_1.stepDwn_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Passed"" direction"
    VALUE
    0x80808FE0
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_2.isJmpDwnActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Failed"" to ""Passed"" debouncing"
    VALUE
    0x80808FE2
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_2.isJmpUpActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Passed"" to ""Failed"" debouncing"
    VALUE
    0x80808FE3
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_2.limPassd_C
    "Parameters of ArCtrBase debouncing /  / ""Passed"" limit"
    VALUE
    0x80808FE4
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_2.limFaild_C
    "Parameters of ArCtrBase debouncing /  / ""Failed"" limit"
    VALUE
    0x80808FE6
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_2.jmpUpVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Failed"""
    VALUE
    0x80808FE8
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_2.jmpDwnVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Passed"""
    VALUE
    0x80808FEA
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_2.stepUp_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Failed"" direction"
    VALUE
    0x80808FEC
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_2.stepDwn_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Passed"" direction"
    VALUE
    0x80808FEE
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_3.isJmpDwnActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Failed"" to ""Passed"" debouncing"
    VALUE
    0x80808FF0
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_3.isJmpUpActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Passed"" to ""Failed"" debouncing"
    VALUE
    0x80808FF1
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_3.limPassd_C
    "Parameters of ArCtrBase debouncing /  / ""Passed"" limit"
    VALUE
    0x80808FF2
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_3.limFaild_C
    "Parameters of ArCtrBase debouncing /  / ""Failed"" limit"
    VALUE
    0x80808FF4
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_3.jmpUpVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Failed"""
    VALUE
    0x80808FF6
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_3.jmpDwnVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Passed"""
    VALUE
    0x80808FF8
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_3.stepUp_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Failed"" direction"
    VALUE
    0x80808FFA
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.CANSM_E_DemDebounceCounterBasedClass_NETWORK_3.stepDwn_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Passed"" direction"
    VALUE
    0x80808FFC
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.DemDebounceCounterBasedClass_standard.isJmpDwnActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Failed"" to ""Passed"" debouncing"
    VALUE
    0x80808FFE
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.DemDebounceCounterBasedClass_standard.isJmpUpActv_C
    "Parameters of ArCtrBase debouncing /  / Jump at change from ""Passed"" to ""Failed"" debouncing"
    VALUE
    0x80808FFF
    RB_Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.DemDebounceCounterBasedClass_standard.limPassd_C
    "Parameters of ArCtrBase debouncing /  / ""Passed"" limit"
    VALUE
    0x80809000
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.DemDebounceCounterBasedClass_standard.limFaild_C
    "Parameters of ArCtrBase debouncing /  / ""Failed"" limit"
    VALUE
    0x80809002
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.DemDebounceCounterBasedClass_standard.jmpUpVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Failed"""
    VALUE
    0x80809004
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.DemDebounceCounterBasedClass_standard.jmpDwnVal_C
    "Parameters of ArCtrBase debouncing /  / Jumppoint direction ""Passed"""
    VALUE
    0x80809006
    RB_Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.DemDebounceCounterBasedClass_standard.stepUp_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Failed"" direction"
    VALUE
    0x80809008
    RB_Val_Ws16
    32766.00
    OneToOne
    1.00
    32767.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArCtrBase.DemDebounceCounterBasedClass_standard.stepDwn_C
    "Parameters of ArCtrBase debouncing /  / Stepsize of ""Passed"" direction"
    VALUE
    0x8080900A
    RB_Val_Ws16
    32767.00
    OneToOne
    -32768.00
    -1.00

    FORMAT "%8.2"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArTime.DFC_rbr_mo_OV_VSS1.tiLimFaild_C
    "Parameters of ArTime debouncing /  / ""Failed"" limit"
    VALUE
    0x8080900C
    RB_Val_Ws16
    327660.0
    DDRCTime_ms
    10.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArTime.DFC_rbr_mo_OV_VSS1.tiLimPassd_C
    "Parameters of ArTime debouncing /  / ""Passed"" limit"
    VALUE
    0x8080900E
    RB_Val_Ws16
    327670.0
    DDRCTime_ms
    -327680.0
    -10.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArTime.DFC_rbr_mo_OV_VSS2.tiLimFaild_C
    "Parameters of ArTime debouncing /  / ""Failed"" limit"
    VALUE
    0x80809012
    RB_Val_Ws16
    327660.0
    DDRCTime_ms
    10.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArTime.DFC_rbr_mo_OV_VSS2.tiLimPassd_C
    "Parameters of ArTime debouncing /  / ""Passed"" limit"
    VALUE
    0x80809014
    RB_Val_Ws16
    327670.0
    DDRCTime_ms
    -327680.0
    -10.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArTime.DFC_rbr_mo_UV_VSS1.tiLimFaild_C
    "Parameters of ArTime debouncing /  / ""Failed"" limit"
    VALUE
    0x80809018
    RB_Val_Ws16
    327660.0
    DDRCTime_ms
    10.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArTime.DFC_rbr_mo_UV_VSS1.tiLimPassd_C
    "Parameters of ArTime debouncing /  / ""Passed"" limit"
    VALUE
    0x8080901A
    RB_Val_Ws16
    327670.0
    DDRCTime_ms
    -327680.0
    -10.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArTime.DFC_rbr_mo_UV_VSS2.tiLimFaild_C
    "Parameters of ArTime debouncing /  / ""Failed"" limit"
    VALUE
    0x8080901E
    RB_Val_Ws16
    327660.0
    DDRCTime_ms
    10.0
    327670.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DebArTime.DFC_rbr_mo_UV_VSS2.tiLimPassd_C
    "Parameters of ArTime debouncing /  / ""Passed"" limit"
    VALUE
    0x80809020
    RB_Val_Ws16
    327670.0
    DDRCTime_ms
    -327680.0
    -10.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808002F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_OV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808002FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3DebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808002FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3DebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_mo_UV_SAV_LSS_MEAS_CLUSTER_1_3"
    VALUE
    0x808002FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA01OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA01OL"
    VALUE
    0x80800300
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA01OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA01OL"
    VALUE
    0x80800302
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA01OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA01OT"
    VALUE
    0x80800304
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA01OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA01OT"
    VALUE
    0x80800306
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA01SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA01SCB"
    VALUE
    0x80800308
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA01SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA01SCB"
    VALUE
    0x8080030A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA01SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA01SCG"
    VALUE
    0x8080030C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA01SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA01SCG"
    VALUE
    0x8080030E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA02OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA02OL"
    VALUE
    0x80800310
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA02OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA02OL"
    VALUE
    0x80800312
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA02OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA02OR"
    VALUE
    0x80800314
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA02OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA02OR"
    VALUE
    0x80800316
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA02OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA02OT"
    VALUE
    0x80800318
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA02OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA02OT"
    VALUE
    0x8080031A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA02SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA02SCB"
    VALUE
    0x8080031C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA02SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA02SCB"
    VALUE
    0x8080031E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA02SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA02SCG"
    VALUE
    0x80800320
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA02SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA02SCG"
    VALUE
    0x80800322
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA03OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA03OL"
    VALUE
    0x80800324
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA03OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA03OL"
    VALUE
    0x80800326
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA03OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA03OT"
    VALUE
    0x80800328
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA03OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA03OT"
    VALUE
    0x8080032A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA03SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA03SCB"
    VALUE
    0x8080032C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA03SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA03SCB"
    VALUE
    0x8080032E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA03SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA03SCG"
    VALUE
    0x80800330
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA03SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA03SCG"
    VALUE
    0x80800332
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA04OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA04OL"
    VALUE
    0x80800334
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA04OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA04OL"
    VALUE
    0x80800336
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA04OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA04OT"
    VALUE
    0x80800338
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA04OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA04OT"
    VALUE
    0x8080033A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA04SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA04SCB"
    VALUE
    0x8080033C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA04SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA04SCB"
    VALUE
    0x8080033E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA04SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA04SCG"
    VALUE
    0x80800340
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA04SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA04SCG"
    VALUE
    0x80800342
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA05OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA05OL"
    VALUE
    0x80800344
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA05OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA05OL"
    VALUE
    0x80800346
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA05OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA05OR"
    VALUE
    0x80800348
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA05OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA05OR"
    VALUE
    0x8080034A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA05OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA05OT"
    VALUE
    0x8080034C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA05OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA05OT"
    VALUE
    0x8080034E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA05SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA05SCB"
    VALUE
    0x80800350
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA05SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA05SCB"
    VALUE
    0x80800352
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA05SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA05SCG"
    VALUE
    0x80800354
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA05SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA05SCG"
    VALUE
    0x80800356
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA06OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA06OL"
    VALUE
    0x80800358
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA06OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA06OL"
    VALUE
    0x8080035A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA06OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA06OR"
    VALUE
    0x8080035C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA06OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA06OR"
    VALUE
    0x8080035E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA06OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA06OT"
    VALUE
    0x80800360
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA06OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA06OT"
    VALUE
    0x80800362
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA06SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA06SCB"
    VALUE
    0x80800364
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA06SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA06SCB"
    VALUE
    0x80800366
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA06SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA06SCG"
    VALUE
    0x80800368
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA06SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA06SCG"
    VALUE
    0x8080036A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA07OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA07OL"
    VALUE
    0x8080036C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA07OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA07OL"
    VALUE
    0x8080036E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA07OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA07OT"
    VALUE
    0x80800370
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA07OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA07OT"
    VALUE
    0x80800372
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA07SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA07SCB"
    VALUE
    0x80800374
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA07SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA07SCB"
    VALUE
    0x80800376
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA07SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA07SCG"
    VALUE
    0x80800378
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA07SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA07SCG"
    VALUE
    0x8080037A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA08OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA08OL"
    VALUE
    0x8080037C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA08OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA08OL"
    VALUE
    0x8080037E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA08OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA08OT"
    VALUE
    0x80800380
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA08OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA08OT"
    VALUE
    0x80800382
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA08SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA08SCB"
    VALUE
    0x80800384
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA08SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA08SCB"
    VALUE
    0x80800386
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA08SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA08SCG"
    VALUE
    0x80800388
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA08SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA08SCG"
    VALUE
    0x8080038A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA09OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA09OL"
    VALUE
    0x8080038C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA09OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA09OL"
    VALUE
    0x8080038E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA09OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA09OR"
    VALUE
    0x80800390
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA09OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA09OR"
    VALUE
    0x80800392
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA09OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA09OT"
    VALUE
    0x80800394
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA09OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA09OT"
    VALUE
    0x80800396
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA09SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA09SCB"
    VALUE
    0x80800398
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA09SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA09SCB"
    VALUE
    0x8080039A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA09SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA09SCG"
    VALUE
    0x8080039C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA09SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA09SCG"
    VALUE
    0x8080039E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA10OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA10OL"
    VALUE
    0x808003A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA10OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA10OL"
    VALUE
    0x808003A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA10OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA10OT"
    VALUE
    0x808003A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA10OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA10OT"
    VALUE
    0x808003A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA10SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA10SCB"
    VALUE
    0x808003A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA10SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA10SCB"
    VALUE
    0x808003AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA10SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA10SCG"
    VALUE
    0x808003AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA10SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA10SCG"
    VALUE
    0x808003AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA11OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA11OL"
    VALUE
    0x808003B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA11OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA11OL"
    VALUE
    0x808003B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA11OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA11OT"
    VALUE
    0x808003B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA11OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA11OT"
    VALUE
    0x808003B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA11SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA11SCB"
    VALUE
    0x808003B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA11SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA11SCB"
    VALUE
    0x808003BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA11SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA11SCG"
    VALUE
    0x808003BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA11SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA11SCG"
    VALUE
    0x808003BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA12OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA12OR"
    VALUE
    0x808003C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA12OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA12OR"
    VALUE
    0x808003C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA12SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA12SCB"
    VALUE
    0x808003C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA12SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA12SCB"
    VALUE
    0x808003C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA12SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA12SCG"
    VALUE
    0x808003C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA12SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA12SCG"
    VALUE
    0x808003CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA16OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA16OL"
    VALUE
    0x808003CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA16OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA16OL"
    VALUE
    0x808003CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA16OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA16OT"
    VALUE
    0x808003D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA16OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA16OT"
    VALUE
    0x808003D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA16SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA16SCB"
    VALUE
    0x808003D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA16SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA16SCB"
    VALUE
    0x808003D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA16SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA16SCG"
    VALUE
    0x808003D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA16SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA16SCG"
    VALUE
    0x808003DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA17OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA17OL"
    VALUE
    0x808003DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA17OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA17OL"
    VALUE
    0x808003DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA17OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA17OR"
    VALUE
    0x808003E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA17OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA17OR"
    VALUE
    0x808003E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA17OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA17OT"
    VALUE
    0x808003E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA17OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA17OT"
    VALUE
    0x808003E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA17SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA17SCB"
    VALUE
    0x808003E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA17SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA17SCB"
    VALUE
    0x808003EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA17SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA17SCG"
    VALUE
    0x808003EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA17SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA17SCG"
    VALUE
    0x808003EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA18OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA18OL"
    VALUE
    0x808003F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA18OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA18OL"
    VALUE
    0x808003F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA18OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA18OT"
    VALUE
    0x808003F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA18OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA18OT"
    VALUE
    0x808003F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA18SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA18SCB"
    VALUE
    0x808003F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA18SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA18SCB"
    VALUE
    0x808003FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA18SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA18SCG"
    VALUE
    0x808003FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA18SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA18SCG"
    VALUE
    0x808003FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA19OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA19OL"
    VALUE
    0x80800400
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA19OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA19OL"
    VALUE
    0x80800402
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA19OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA19OR"
    VALUE
    0x80800404
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA19OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA19OR"
    VALUE
    0x80800406
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA19OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA19OT"
    VALUE
    0x80800408
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA19OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA19OT"
    VALUE
    0x8080040A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA19SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA19SCB"
    VALUE
    0x8080040C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA19SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA19SCB"
    VALUE
    0x8080040E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA19SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA19SCG"
    VALUE
    0x80800410
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA19SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA19SCG"
    VALUE
    0x80800412
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA20OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA20OL"
    VALUE
    0x80800414
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA20OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA20OL"
    VALUE
    0x80800416
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA20OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA20OR"
    VALUE
    0x80800418
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA20OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA20OR"
    VALUE
    0x8080041A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA20OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA20OT"
    VALUE
    0x8080041C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA20OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA20OT"
    VALUE
    0x8080041E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA20SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA20SCB"
    VALUE
    0x80800420
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA20SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA20SCB"
    VALUE
    0x80800422
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA20SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA20SCG"
    VALUE
    0x80800424
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA20SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA20SCG"
    VALUE
    0x80800426
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA31OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA31OL"
    VALUE
    0x80800428
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA31OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA31OL"
    VALUE
    0x8080042A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA31OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA31OR"
    VALUE
    0x8080042C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA31OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA31OR"
    VALUE
    0x8080042E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA31OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA31OT"
    VALUE
    0x80800430
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA31OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA31OT"
    VALUE
    0x80800432
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA31SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA31SCB"
    VALUE
    0x80800434
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA31SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA31SCB"
    VALUE
    0x80800436
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA31SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA31SCG"
    VALUE
    0x80800438
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA31SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA31SCG"
    VALUE
    0x8080043A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA32OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA32OL"
    VALUE
    0x8080043C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA32OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA32OL"
    VALUE
    0x8080043E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA32OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA32OR"
    VALUE
    0x80800440
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA32OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA32OR"
    VALUE
    0x80800442
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA32OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA32OT"
    VALUE
    0x80800444
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA32OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA32OT"
    VALUE
    0x80800446
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA32SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA32SCB"
    VALUE
    0x80800448
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA32SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA32SCB"
    VALUE
    0x8080044A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA32SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA32SCG"
    VALUE
    0x8080044C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA32SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA32SCG"
    VALUE
    0x8080044E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA33OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA33OL"
    VALUE
    0x80800450
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA33OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA33OL"
    VALUE
    0x80800452
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA33OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA33OR"
    VALUE
    0x80800454
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA33OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA33OR"
    VALUE
    0x80800456
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA33OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA33OT"
    VALUE
    0x80800458
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA33OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA33OT"
    VALUE
    0x8080045A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA33SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA33SCB"
    VALUE
    0x8080045C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA33SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA33SCB"
    VALUE
    0x8080045E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA33SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA33SCG"
    VALUE
    0x80800460
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA33SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA33SCG"
    VALUE
    0x80800462
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA34OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA34OL"
    VALUE
    0x80800464
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA34OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA34OL"
    VALUE
    0x80800466
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA34OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA34OR"
    VALUE
    0x80800468
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA34OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA34OR"
    VALUE
    0x8080046A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA34OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA34OT"
    VALUE
    0x8080046C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA34OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA34OT"
    VALUE
    0x8080046E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA34SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA34SCB"
    VALUE
    0x80800470
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA34SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA34SCB"
    VALUE
    0x80800472
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA34SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA34SCG"
    VALUE
    0x80800474
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA34SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA34SCG"
    VALUE
    0x80800476
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA35OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA35OL"
    VALUE
    0x80800478
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA35OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA35OL"
    VALUE
    0x8080047A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA35OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA35OR"
    VALUE
    0x8080047C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA35OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA35OR"
    VALUE
    0x8080047E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA35OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA35OT"
    VALUE
    0x80800480
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA35OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA35OT"
    VALUE
    0x80800482
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA35SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA35SCB"
    VALUE
    0x80800484
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA35SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA35SCB"
    VALUE
    0x80800486
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA35SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA35SCG"
    VALUE
    0x80800488
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA35SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA35SCG"
    VALUE
    0x8080048A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA46OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA46OL"
    VALUE
    0x8080048C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA46OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA46OL"
    VALUE
    0x8080048E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA46OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA46OR"
    VALUE
    0x80800490
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA46OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA46OR"
    VALUE
    0x80800492
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA46OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA46OT"
    VALUE
    0x80800494
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA46OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA46OT"
    VALUE
    0x80800496
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA46SCB_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA46SCB"
    VALUE
    0x80800498
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA46SCB_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA46SCB"
    VALUE
    0x8080049A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA46SCG_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA46SCG"
    VALUE
    0x8080049C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA46SCG_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA46SCG"
    VALUE
    0x8080049E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47OL_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA47OL"
    VALUE
    0x808004A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47OL_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA47OL"
    VALUE
    0x808004A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47OR_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA47OR"
    VALUE
    0x808004A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47OR_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA47OR"
    VALUE
    0x808004A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47OT_tiDebOk_C
    "debouncing parameter / Duration of healing debouncing for check DFC_rbr_outA47OT"
    VALUE
    0x808004A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DFC_rbr_outA47OT_tiDebDef_C
    "debouncing parameter / Duration of defect debouncing for check DFC_rbr_outA47OT"
    VALUE
